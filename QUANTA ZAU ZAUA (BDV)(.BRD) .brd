# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_TXP5_C: length 7.6
  BOTTOM w0.079: 98.54,44.82 98.52,44.82 98.5,44.8 97.98,44.8 97.78,45 97.22,45 97.12,45.1 97.12,45.22 97.2,45.29 U2030.A17
  BOTTOM w0.102: 98.54,44.82 99.29,44.82 101.26,42.85 103.02,42.85 103.09,42.93 C193.2
PEG_TXP6: length 101.3
  IN1 w0.089: v1(105.1,43.04) 104.87,42.81 104.15,42.81 102.14,44.82 102.14,46 102.58,46.43 102.58,47.75 102.15,48.17 100.84,48.17 100.64,47.97 97.22,47.97 95.03,50.15 93.67,50.15 92.42,51.4 92.42,53.28 91.2,54.5 91.2,57.06 89.55,58.71 89.55,75.37 89.83,75.65 89.83,82 90.21,82.39 90.21,86.35 91.39,87.52 91.39,89.54 93.97,92.12 93.97,93.51 93.05,94.42 93.05,97.28 94.78,99.01 94.78,100.97 94.32,101.42 94.32,101.75 95.45,102.88 95.45,113.09 97.05,114.69 97.05,115.59 99.05,117.59 99.44,117.59 99.62,117.41 99.62,117.07 99.53,116.98 v1(99.25,116.98)
  BOTTOM w0.102: U8.AF7 99.31,113.55 99.31,113.43 99.19,113.31 98.95,113.31 98.84,113.42 98.84,113.81 99.02,113.99 99.44,113.99 99.57,114.12 99.57,114.71 99.5,114.78 99.5,115.82 99.63,115.94 99.63,116.85 99.5,116.98 v1(99.25,116.98) ; v1(105.1,43.04) 104.86,42.8 104.7,42.8 103.71,41.81 102.64,41.81 C195.1
PEG_TXP6_C: length 7.7
  BOTTOM w0.079: 98.23,44.35 98.21,44.33 97.91,44.33 97.65,44.59 96.47,44.59 96.4,44.66 U2030.C16
  BOTTOM w0.102: 98.23,44.35 99.01,44.35 99.84,43.51 99.84,43.23 101.42,41.66 102.06,41.66 102.11,41.71 102.11,41.88 C195.2
PEG_TXP7: length 98.2
  IN1 w0.089: v1(106.27,45.43) 106.49,45.43 106.59,45.32 106.59,44.93 106.45,44.79 104.99,44.79 103.83,45.95 103.83,48.86 101.97,50.72 97.79,50.72 96.53,51.98 96.53,53.61 95.75,54.39 95.59,54.39 93.22,56.77 93.22,57.84 92.52,58.53 91.77,58.53 90.92,59.39 90.92,64.9 91.17,65.15 91.17,71.54 91.39,71.76 91.39,72.44 91.17,72.66 91.17,74.66 91.45,74.94 91.45,83.02 92.34,83.91 92.34,85.03 91.58,85.79 91.58,86.02 92.58,87.03 92.58,88.03 94.81,90.26 94.81,91.28 95.16,91.63 95.16,97.7 96.05,98.59 96.05,101.11 96.7,101.76 96.7,112.56 97.77,113.63 98.62,113.63 99.63,114.64 99.63,115.78 99.88,116.03 100.37,116.03 100.47,115.94 v1(100.47,115.66)
  BOTTOM w0.102: C197.1 102.64,43.97 103.91,43.97 104.73,44.79 106.44,44.79 106.58,44.93 106.58,45.35 106.5,45.43 v1(106.27,45.43) ; U8.AE9 100.91,113.11 100.56,113.46 100.56,113.69 100.36,113.89 100.36,114.67 100.93,115.23 100.93,115.88 100.8,116.01 100.54,116.01 100.47,115.93 v1(100.47,115.66)
PEG_TXP7_C: length 7.6
  BOTTOM w0.079: 98.54,45.24 98.52,45.24 98.5,45.21 98.1,45.21 97.6,45.72 97.23,45.72 97.19,45.7 96.91,45.7 96.87,45.72 96.55,45.72 96.43,45.65 96.27,45.49 96.12,45.49 96.07,45.44 U2030.C17
  BOTTOM w0.102: C197.2 102.06,44.23 102.11,44.18 102.11,43.89 102.07,43.84 101.16,43.84 99.77,45.24 98.54,45.24
PEG_TXP8: length 88.1
  IN1 w0.089: v1(105.04,46.24) 104.83,46.45 104.55,46.45 104.27,46.73 104.27,49.04 102.07,51.24 101.15,51.24 99.66,52.74 98.26,52.74 95.29,55.71 95.29,56.17 93.69,57.77 93.69,58.53 92.39,59.83 92.39,64.93 91.98,65.35 91.98,70.43 91.91,70.5 91.91,72.05 92.29,72.43 92.29,73.38 92.09,73.59 92.09,76.93 92.27,77.12 92.27,82.75 92.98,83.45 92.98,87.83 95.2,90.06 95.2,91.11 95.55,91.46 95.55,97.54 96.44,98.43 96.44,100.94 97.43,101.93 97.43,102.98 97.52,103.08 97.52,111.19 97.6,111.27 97.6,111.83 97.37,112.06 97.37,112.67 97.84,113.14 99.93,113.14 100.98,114.19 100.98,115.4 101.52,115.95 101.84,115.95 v1(102.04,116.15)
  BOTTOM w0.102: U8.AG9 101.09,114.61 101.09,114.71 101.38,115.01 101.38,115.64 101.69,115.95 101.84,115.95 v1(102.04,116.15) ; C199.1 102.76,45.89 104.03,45.89 104.63,46.49 104.79,46.49 v1(105.04,46.24)
PEG_TXP8_C: length 5.9
  BOTTOM w0.079: U2030.A19 97.37,46.75 97.45,46.82 98.05,46.82 98.95,45.93 99.12,45.93 99.14,45.9
  BOTTOM w0.102: 99.14,45.9 101.66,45.9 101.77,46.02 102.18,46.02 102.24,45.97 102.24,45.82 C199.2
PEGX_RST#: length 24
  TOP w0.102: R306.2 117.16,123.29 117.41,123.53 118.77,123.53 118.87,123.63 118.87,123.95 118.77,124.05 U6505.4 117.27,124.05 117.11,124.22 117.11,125.56 116.24,126.43 106.23,126.43 105.09,125.28 104.55,125.28 103.77,124.51 R25521.1 103.16,124.41 103.14,124.44 102.65,124.44 R296.1 102.63,123.89 102.79,123.73 103.71,123.73 103.91,123.53 R384.2
PEX_CLKREQ#: length 21.6
  BOTTOM w0.102: U8.AC6 97.96,110.76 94.22,110.76 92.85,112.13 92.85,116.89 93.46,117.51 93.46,119.93 93.77,120.24 94.16,120.24 94.91,119.49 95.81,119.49 96.07,119.76 R25563.1 96.07,120.46 95.96,120.58 R25487.2 95.96,121.51 R297.1 96.24,122.84 Q9.1
PEX_PLLVDD: length 12.9
  TOP w0.152: v1(106.59,116.04) 106.49,116.14 R25515.2
  IN1 w0.152: v1(106.59,116.04) 106.59,114.89 107.81,113.67 107.81,112.22 106.23,110.64 106.23,109.75 v1(105.56,109.07)
  BOTTOM w0.381: U8.AA14 105.03,109.57 v1(104.53,109.06) ; U8.AA15 105.56,109.28 v1(105.56,109.07)
PEX_TERMP: length 6.5
  BOTTOM w0.102: R312.2 115.37,118.73 115.83,118.27 115.83,116.89 114.54,115.6 114.54,114.04 U8.AF25
PEX_TSTCLK: length 5.7
  BOTTOM w0.102: R307.2 114.81,117.52 114.81,117.29 113.56,116.04 113.56,115.57 113.55,115.56 113.55,115.55 U8.AF22
PEX_TSTCLK#: length 6.5
  BOTTOM w0.102: U8.AE22 112.08,113.28 112.08,113.79 113.75,115.47 113.75,115.96 115,117.21 115,117.58 R307.1
PHASE1_CORE: length 14.8
  TOP w0.508: v1(118.18,71.15) 118.18,70.5 PC7105.1
  IN3 w0.508: v1(126.33,65.24) 125.11,66.46 123.38,66.46 122.87,66.97 122.87,68.39 122.06,69.2 120.92,69.2 120.31,68.59 119.24,68.59 118.18,69.65 v1(118.18,71.15)
  BOTTOM w0.254: v1(118.18,71.15) 118.46,70.87 PU7002.2
PHASE2_CORE: length 12
  IN3 w0.508: v1(133.46,45.81) 133.4,45.87 133.4,46.21 133.04,46.57 132.6,46.57 131.33,47.84 130.27,47.84 129.55,48.56 129.55,49.44 127.21,51.78 v1(126.88,51.78)
  BOTTOM w0.305: v1(133.46,45.81) 133.44,45.81 133.36,45.89 PU7001.2
  BOTTOM w0.508: v1(133.46,45.81) 133.7,45.57 PC7056.1
PHASE_GT: length 15.8
  TOP w0.508: PC7101.1 128.29,75.73 v1(127.98,75.42) ; PR7095.2 117.69,76.82 v1(117.28,76.82)
  IN3 w0.508: v1(117.28,76.82) 118.71,76.82 120.29,78.4 122.98,78.4 125.95,75.42 v1(127.98,75.42)
  BOTTOM w0.254: v1(127.98,75.42) 128.25,75.69 PU7003.2
PHASE_SA: length 7.3
  TOP w0.508: v1(137.82,39.36) 137.07,39.36 PR7087.2 ; v1(141.28,39.37) 141.28,39.94 PC7103.1
  IN3 w0.508: v1(137.82,39.36) 139.03,39.36 139.62,39.95 140.82,39.95 141.28,39.5 v1(141.28,39.37)
  BOTTOM w0.305: PU7004.2 140.98,39.71 141.28,39.42 v1(141.28,39.37)
PIRQA#: length 88.1
  TOP w0.102: R593.1 123,25.59 R580.1 123,26.38 123.32,26.71 126.07,26.71 v1(126.5,26.28)
  IN2 w0.089: v1(69.48,34.45) 69.48,34.68 69.99,35.19 71.74,35.19 72.25,34.68 72.96,34.68 73.39,35.11 73.82,35.11 75.02,36.31 78.93,36.31 80.25,34.99 80.25,34.53 80.48,34.3 80.99,34.3 81.24,34.56 81.24,35.02 81.7,35.48 82.45,35.48 82.98,34.95 82.98,31.36 83.35,30.98 85.38,30.98 86.62,32.22 87.3,32.22 88.15,33.07 89.16,33.07 89.7,32.53 91.03,32.53 92.96,34.46 96.4,34.46 96.68,34.18 97.9,34.18 97.98,34.1 100.16,34.1 101.33,32.93 103.29,32.93 104.16,33.8 104.58,33.8 104.77,33.61 104.77,32.13 105.13,31.78 105.13,31.22 105.74,30.61 107.42,30.61 111.97,26.05 126.28,26.05 v1(126.5,26.28)
  BOTTOM w0.102: U2030.BB11 74.56,41.81 74.33,41.58 74.13,41.58 70.98,38.43 70.98,36.76 70.29,36.08 70.29,35.61 69.48,34.79 v1(69.48,34.45) 69.48,34.2 68.87,33.59 R2554.2
PLTRST#: length 432
  TOP w0.102: v1(28.31,3.26) 28.25,3.21 R648.2 ; v1(124.65,25.16) 124.19,25.16 123.83,24.8 R601.1 ; U24.19 47.3,104.8 v1(47.48,104.61) ; v1(59.93,29.58) 60.59,29.58 61.15,30.13 v1(62.04,30.13) 62.06,30.11 62.06,29.43 62.75,28.74 R2309.2 62.94,29.03 62.6,29.37 R2302.1 C2363.2 62.61,30.3 U2019.4 ; R894.1 179.97,19.54 v2(180.2,19.77)
  IN1 w0.089: v1(47.48,104.61) 46.3,104.61 45.05,103.36 42.29,103.36 42.16,103.48 40.52,103.48 39.69,102.65 26.79,102.65 25.63,101.49 21.58,101.49 19.68,99.58 19.68,94.94 18.58,93.84 17.32,93.84 17.15,93.67 17.15,87.16 17.47,86.85 17.47,85.65 20.17,82.95 20.17,80.87 21.79,79.25 21.79,77.57 23.5,75.86 23.5,74.29 23.92,73.87 23.92,72.51 24.7,71.73 24.7,67.63 25.43,66.9 25.43,66.53 23.98,65.08 23.98,60.71 23.38,60.11 23.38,54.95 23.04,54.62 23.04,53.48 24.23,52.3 24.23,42.96 23.8,42.53 23.8,39.37 24.23,38.94 27.08,36.09 27.08,35.37 30.21,32.24 30.21,31.6 32.76,29.06 34.96,29.06 35.47,28.54 v1(35.47,28.18) 36.04,27.61 36.04,27.24 37.16,26.12 37.16,22.61 37.95,21.82 44.48,21.82 45.79,20.5 45.79,19.84 46.59,19.04 46.59,17.74 45.81,16.96 45.81,15.12 37.13,6.44 34.17,6.44 31.43,3.69 28.74,3.69 v1(28.31,3.26) ; v1(70.77,112.15) 70.38,112.54 70.38,113.21 70.79,113.63 70.79,114.68 72.41,116.29 72.41,122.69 73.54,123.82 85.1,123.82 89.34,119.58 92.69,119.58 94.27,121.16 94.27,123.06 95.82,124.61 96.37,124.61 v1(96.47,124.5) ; v1(175.14,16.8) 173.89,15.55 122.98,15.55 v1(122.34,16.19) 122.3,16.23 119.18,16.23 118.48,16.93 110.56,16.93 109.69,16.06 102.08,16.06 100.78,17.36 96.67,17.36 96.16,17.87 93.56,17.87 89.06,22.36 83.35,22.36 81.98,20.99 70.47,20.99 65.83,25.63 65.83,27.36 64.59,28.6 63.18,28.6 62.6,29.19 62.6,29.57 v1(62.04,30.13)
  IN3 w0.089: v2(193.99,22.31) 193.71,22.59 192.65,22.59 192.6,22.63 188.73,22.63 187.99,23.37 184.23,23.37 180.63,19.77 v2(180.2,19.77) ; v1(59.93,29.58) 59.7,29.35 57.54,29.35 56.78,28.59 55.89,28.59 54.75,27.44 53.96,27.44 53.4,28 52.84,28 52.39,28.46 47.51,28.46 47.3,28.67 44.89,28.67 44.64,28.92 36.21,28.92 v1(35.47,28.18) ; v1(47.48,104.61) 50.59,104.61 51.59,105.61 51.59,107.36 51.89,107.66 51.89,108.14 52.13,108.37 53.31,108.37 53.48,108.55 53.48,109.37 53.91,109.8 54.46,109.8 54.94,110.29 56.35,110.29 57.25,111.18 58.4,111.18 60.35,113.13 61.74,113.13 62.11,112.77 66.84,112.77 67.45,112.15 v1(70.77,112.15)
  BOTTOM w0.102: v1(175.14,16.8) 176.07,15.87 179.41,15.87 180.55,17.02 180.55,19.41 v2(180.2,19.77) ; U6504.2 97.75,124.7 97.53,124.48 96.5,124.48 v1(96.47,124.5) ; v1(124.65,25.16) 124.55,25.06 122.72,25.06 122.39,24.73 122.39,24.07 121.6,23.28 121.6,22.4 121.92,22.09 121.92,21.18 122.39,20.71 122.39,19.29 122.79,18.89 122.79,16.97 122.34,16.52 v1(122.34,16.19) ; v2(193.99,22.31) 194.21,22.09 194.21,21.31 194.04,21.14 192.85,21.14 R2665.2
PLTRST#_EC: length 5
  TOP w0.102: U37.22 182.29,19.78 182.21,19.7 181.37,19.7 181.26,19.81 C2374.1 180.55,19.58 180.55,19.47 180.18,19.09 R894.2 179.43,19.09 179.07,19.46 v1(178.75,19.46)
PMON: length 34.1
  TOP w0.152: v1(138.7,32.75) 138.7,32.29 138.02,31.62 PR23.1 137.03,31.62 PC18.2 ; v1(142.86,40.45) 144.18,41.77 144.18,45.83 144.97,46.62 144.97,47.13 146.62,48.78 146.85,48.78 147.13,49.06 147.13,50.71 146.75,51.09 146.54,51.09 146.36,50.91 145.58,50.91 144.41,52.08 143.57,52.08 143.46,51.97 143,51.97 142.86,52.12 142.38,52.12 141.66,51.4 141.19,51.4 140.93,51.66 PR7039.1
  IN2 w0.152: v1(138.7,32.75) 138.7,32.78 138.72,32.8 139.56,32.8 139.84,33.08 139.84,36.28 142.86,39.31 v1(142.86,40.45)
  BOTTOM w0.152: v1(138.7,32.75) 138.8,32.65 138.8,32.13 138.27,31.6 PR25.1
PP: length 1.3
  TOP w0.102: U33.4 129.2,20.21 R600.2
PROC_POPIRCOMP: length 13.4
  TOP w0.079: 76.59,45.35 76.69,45.35 77.48,44.99 78.4,44.62 v4(78.84,44.29)
  TOP w0.381: 76.59,45.35 76.59,45.35 74.25,45.35 74.18,45.43 R2201.2
  BOTTOM w0.102: U2030.AT16 v4(78.84,44.29)
PROC_PWRGD: length 7
  BOTTOM w0.102: U2030.A68 97.37,74.68 97.83,75.14 97.83,75.42 98.07,75.67 98.07,77.77 97.27,78.57 R2453.1 97.58,79.5 98.13,80.05 R2454.1
PROCHOT_EC: length 9.2
  TOP w0.102: Q6509.2 175.81,22.27 176.89,21.2 R25298.1 177,21.03 177.24,20.79 179.24,20.79 C6610.2 180.28,21.2 180.61,20.86 180.95,20.86 181.15,21.07 181.72,21.07 182.43,21.78 U37.17
PS_FB_CLAMP: length 12.3
  BOTTOM w0.102: R313.1 90.97,105.84 91.15,106.02 92.51,106.02 93.35,105.19 93.35,99.44 94.7,98.09 94.7,97.73 94.91,97.52 95.54,97.52 U8.F3
PTP_PWR_EN#: length 2.3
  TOP w0.102: U37.125 186.05,30.56 185.63,30.97 185.63,31.71 TP9019.1
PWM1_CORE: length 28.5
  TOP w0.508: v1(118.04,67.05) 118.04,67.66 PR7105.1
  IN3 w0.152: v1(118.04,67.05) 118.04,65.92 119.77,64.19 119.77,63.8 120.92,62.66 120.92,59.3 121.8,58.41 129.3,58.41 130.77,56.95 130.77,56.22 133.97,53.02 v1(134.45,53.02)
  BOTTOM w0.203: PU7000.17 135.08,53.87 134.45,53.24 v1(134.45,53.02)
PWM2_CORE: length 3.6
  BOTTOM w0.203: PU7000.16 135.11,53.47 134.91,53.27 134.91,52.4 133.75,51.24 PR7077.1
PWM-VID: length 41.6
  TOP w0.102: v1(70.99,113.18) 71.25,113.45 PR9015.1 ; v2(96.35,97.52) 97.04,97.52 97.72,96.84 R25571.2 R370.2
  IN2 w0.089: v2(96.35,97.52) 95.44,97.52 93.94,99.02 93.94,104.13 91.95,106.12 88.59,106.12 86.13,103.67 84.97,103.67 84.59,103.29 79.81,103.29 74.63,108.47 73.67,108.47 73.1,109.04 73.1,109.13 71.77,110.46 71.77,112.75 71.34,113.18 v1(70.99,113.18)
PWM_GT: length 47.4
  IN1 w0.152: v1(134.52,55.63) 135.34,55.63 136.64,56.93 139.58,56.93 142.35,59.7 142.35,62.59 141.73,63.21 141.73,64.49 140.12,66.1 140.12,68.62 140.23,68.73 140.23,70.58 142.25,72.6 142.25,77.13 139.74,79.64 v1(126.77,79.64)
  BOTTOM w0.152: v1(126.77,79.64) 126.77,79.37 PR7109.1
  BOTTOM w0.203: PU7000.22 135.11,55.87 134.87,55.63 v1(134.52,55.63)
PWM_SA: length 23
  IN2 w0.203: v1(141.64,57.69) 141.84,57.5 141.84,54.01 142.29,53.56 144.06,53.56 144.6,53.02 144.6,52.3 144.43,52.13 144.43,51.64 142.43,49.64 142.43,43.14 142.14,42.85 140.88,42.85 v1(140.3,43.43)
  BOTTOM w0.203: PR7113.1 139.54,43.6 139.71,43.43 v1(140.3,43.43) ; PU7000.36 140.95,57.92 141.05,58.02 141.32,58.02 v1(141.64,57.69)
PWRLED#: length 75.2
  TOP w0.102: U37.24 183.92,18.98 184.34,18.56 184.34,18.15 184.92,17.58 185.23,17.58 185.48,17.32 185.48,16.72 v2(185.1,16.34)
  IN2 w0.089: v2(185.1,16.34) 186.05,15.4 192.51,15.4 194.48,13.44 196.71,13.44 197.66,12.49 197.87,12.49 199.25,11.1 202.31,11.1 202.98,11.76 204.59,11.76 204.81,11.99 v2(204.91,11.99)
  IN3 w0.089: v1(212.15,36.78) 212.6,36.78 216.53,32.85 216.53,28.06 215.59,27.12 215.59,26.71 213.27,24.39 213.27,24.09 213.07,23.88 213.07,20.5 215.71,17.85 216.51,17.85 217.51,16.85 217.51,11.62 215.77,9.88 205.08,9.88 204.22,10.74 204.22,11.39 204.81,11.99 v2(204.91,11.99)
  BOTTOM w0.102: CN35.22 212.77,37.4 v1(212.15,36.78)
R_SPK+: length 101.3
  TOP w1.016: 119.98,16.35 121.03,15.3 181.41,15.3 182.22,14.49 183.09,14.49 183.73,13.85
  IN3 w1.016: 185.66,13.32 187.23,14.9 189.79,14.9 189.84,14.85 197.41,14.85 197.98,15.42 197.98,15.47 198.47,15.96 201.13,15.96 203.32,18.15 203.32,18.73 204.8,20.21 205.34,20.21 206.68,21.55 206.68,22.07 210.53,25.92 210.53,27.21 210.09,27.64 210.09,29.04
  BOTTOM w0.203: U20.45 208.38,31.63 v1(209.61,30.39)
  vias: v1(210.25,30.39) v2(184.44,12.92) v2(184.99,12.61)
R_SPK+_1:
  vias: v1(119.65,23.07) v1(120.28,23.07)
R_SPK-: length 100.1
  TOP w1.016: 182.48,13.22 181.7,13.22 180.88,14.03 120.51,14.03 117.99,16.54
  IN3 w1.016: 211.36,29.75 211.36,28.16 211.8,27.73 211.8,25.39 208.05,21.65 208.05,20.35 206.16,18.45 205.52,18.45 201.19,14.13 199.83,14.13 198.64,12.94 196.86,12.94 196.54,13.27 190.25,13.27
  BOTTOM w0.203: 209.51,31.18 209.27,31.18 208.42,32.03 U20.44
  vias: v1(209.66,31.18) v1(210.35,31.18) v2(185.78,11.9) v2(185.78,11.26)
R_SPK-_1:
  vias: v1(118.25,23.07) v1(118.88,23.07)
RAM_ID0: length 8.8
  BOTTOM w0.102: U2030.P2 89.61,36.06 89.61,35.3 89.39,35.09 89.39,31.92 89.64,31.68 89.64,31.07 89.3,30.73 R2567.2 89.67,30.35 89.67,29.31 R2576.1
RAM_ID1: length 6.8
  BOTTOM w0.102: U2030.P3 90.17,36.7 90.17,35.27 89.83,34.93 89.83,32.07 R2565.2 R2574.1
RAM_ID2: length 8.9
  BOTTOM w0.102: R2573.1 R2564.2 91.71,32.02 91.71,32.65 91.5,32.85 91.22,32.85 90.05,34.02 90.05,34.86 90.46,35.27 90.46,35.48 90.84,35.87 90.84,36.83 90.67,37 90.39,37 90.14,37.25 90.14,37.38 U2030.P4
RAM_ID3: length 8.9
  BOTTOM w0.102: U2030.P1 89.88,35.28 89.6,34.99 89.6,32.01 89.88,31.73 89.88,28.7 89.85,28.67 R2566.2 89.61,28.28 R2575.1
REGN6V: length 3.6
  TOP w0.254: PR39.1 PC9.1
  TOP w0.457: v1(131.12,29.28) 131.61,29.28 131.94,29.61 PC9.1
  BOTTOM w0.198: v1(131.12,29.28) 131.36,29.28 131.61,29.52 131.96,29.52 131.97,29.51 PU1.24
REQ_WLAN#: length 15.7
  TOP w0.102: v1(171.97,17.18) 172.01,17.14 Q63.1
  BOTTOM w0.102: CN17.53 182.11,18.13 182.09,18.15 v1(181.32,18.15) 181.32,17.27 181.42,17.17 181.42,15.8 R652.2 180.75,16.08 180.19,16.08 179.58,15.47 173.68,15.47 v1(171.97,17.18)
RF_EN: length 23.8
  TOP w0.102: v2(193.79,10.53) 193.64,10.69 R25318.2
  BOTTOM w0.102: R672.1 192.87,19.32 192.59,19.03 192.43,19.03 192.26,18.86 192.26,18.67 191.88,18.29 191.88,18 191.7,17.82 191.7,17.49 191.59,17.38 CN17.56 189.68,17.38 189.12,17.94 186.65,17.94 186.42,17.72 186.42,16.65 185.81,16.04 185.81,12.83 186.47,12.17 186.47,11.85 188.43,9.9 193.15,9.9 v2(193.79,10.53)
RGND_CORE: length 44
  TOP w0.203: PC7009.1 144.71,49.89 144.71,50.57 PC7008.1 143.52,50.82 142.66,50.82 v1(142.56,50.91)
  TOP w0.254: v1(118.88,51.07) 118.88,50.86 118.98,50.75 PR7046.2
  IN1 w0.127: v1(118.88,51.07) 119.41,51.6 120.76,51.6 122.46,49.9 122.46,46.32 123.95,44.83 124.62,44.83 124.86,44.59 134.69,44.59 135.55,45.45 136.57,45.45 137.22,44.8 138.64,44.8 139.04,45.2 141.88,45.2 144.79,48.12 144.79,49.44 143.32,50.91 v1(142.56,50.91)
  BOTTOM w0.203: v1(142.56,50.91) 142.12,51.35 142.12,52.22 142.07,52.27 PU7000.48
RGND_GT: length 88.4
  TOP w0.203: v1(134.55,57.21) 134.89,56.88 PC7015.1
  TOP w0.254: PR7053.2 96.25,81.29 v1(95.95,81.6)
  IN1 w0.102: v1(134.55,57.21) 134.91,56.86 135.52,56.86 136.23,57.57 139.24,57.57 141.69,60.01 141.69,62.26 139.4,64.55 139.4,70.65 141.62,72.87 141.62,76.77 139.39,78.99 132.78,78.99 132.18,78.4 131.7,78.4 131.34,78.76 126.23,78.76 125.27,79.72 122.77,79.72 122.28,80.21 117.85,80.21 115.78,82.27 112.6,82.27 112.29,82.59 109.16,82.59 107.51,80.94 104.88,80.94 103.13,79.19 103.13,78.81 103.12,78.81 103.12,78.26 102.56,77.71 101.22,77.71 99.47,79.46 97.58,79.46 96.58,80.46 96.58,80.97 v1(95.95,81.6)
  IN2 w0.203: v1(134.49,60.37) 134.55,60.3 v1(134.55,57.21)
  BOTTOM w0.203: PU7000.25 136.55,57.22 136.33,57.01 134.76,57.01 v1(134.55,57.21) ; PC7014.1 134.03,60.03 134.36,60.37 v1(134.49,60.37)
RGND_SA: length 40.7
  TOP w0.203: v1(143.63,52.54) 143.54,52.63 143.54,52.84 PC7022.1 v1(143.97,54.14) ; v1(118.07,45.76) PR7062.2
  IN1 w0.127: v1(118.07,45.76) 118.46,46.15 118.88,46.15 119.07,45.96 120.34,45.96 120.65,45.64 121.53,45.64 122.57,44.6 124.53,44.6 124.77,44.36 134.78,44.36 135.65,45.23 136.48,45.23 137.13,44.58 138.74,44.58 139.14,44.97 141.97,44.97 145.02,48.02 145.02,50.03 143.63,51.42 v1(143.63,52.54)
  BOTTOM w0.203: v1(143.97,54.14) 143.97,53.83 143.81,53.66 PC7024.1 143.34,53.51 143.13,53.72 142.62,53.72 142.47,53.87 PU7000.44
RING2: length 19.4
  IN3 w1.016: 198.69,33.64 198.69,36.31 199.6,37.22 200.87,37.22 200.98,37.32 201.97,37.32 208.44,43.8 210.09,43.8
  BOTTOM w0.203: v1(199.65,32.02) 199.7,32.02 200.12,31.6 v1(200.12,31.59) 200.13,31.6 200.39,31.6 200.81,32.03 U20.17
  vias: v1(211.69,43.83)
ROM_CS: length 1.7
  TOP w0.102: TP67.1 103.64,95.68 v2(103,95.04)
  BOTTOM w0.102: v2(103,95.04) U8.D12
ROM_SCLK: length 21.7
  TOP w0.102: R342.1 R352.2 113.35,81.58 113.35,86.88 113.07,87.16 111.01,87.16 108.42,89.74 107.71,89.74 107.29,90.16 105.42,90.16 103.69,91.89 103.69,92.95 102.97,93.67 v2(102.97,94.27)
  BOTTOM w0.102: U8.C12 103.33,94.63 v2(102.97,94.27)
ROM_SI: length 18.6
  TOP w0.102: v1(102.78,92.59) 102.78,91.91 103,91.69 103.13,91.69 105.11,89.71 107.1,89.71 107.52,89.29 108.21,89.29 111.08,86.41 111.08,83.8 110.46,83.17 110.46,82.47 R350.2 R341.1
  BOTTOM w0.102: U8.B12 103.05,93.49 103.05,92.86 v1(102.78,92.59)
ROM_SO: length 19.9
  TOP w0.102: v1(103.26,92.14) 103.24,92.12 103.24,91.93 105.23,89.94 107.2,89.94 107.62,89.51 108.33,89.51 110.91,86.93 112.76,86.93 112.99,86.7 112.99,84.97 112.74,84.72 112.08,84.72 111.97,84.61 111.97,83.4 112.33,83.04 112.33,82.48 R351.2 R343.1
  BOTTOM w0.102: U8.A12 103.39,92.24 103.29,92.14 v1(103.26,92.14)
RSET: length 2.1
  TOP w0.203: 42.99,108.37 43.13,108.22 U24.31
  TOP w0.254: 42.99,108.37 42.2,109.16 R508.2
RSMRST#: length 181.7
  TOP w0.102: v2(192.13,23.01) 191.97,23.01 191.65,23.33 191.65,23.93 191.98,24.26 191.98,24.76 190.82,25.93 190.82,28.51 191.25,28.94 U37.112
  IN1 w0.089: v2(192.13,23.01) 192.13,22.6 193.57,21.16 194.86,21.16 195.08,20.94 195.08,20.55 195.45,20.18 195.45,19.1 196.97,17.58 197.6,17.58 198.37,16.81 198.37,15.09 197.51,14.22 190.9,14.22 189.89,15.23 186.7,15.23 185.49,16.45 185.49,16.64 185.38,16.75 183.25,16.75 182.29,17.71 180.81,17.71 180.66,17.86 178.83,17.86 178.62,18.07 168.11,18.07 167.62,17.58 153.98,17.58 153.85,17.7 152.87,17.7 152.75,17.58 151.96,17.58 151.48,18.06 142.2,18.06 141.57,18.68 139.22,18.68 138.16,17.62 131.41,17.62 131.09,17.94 123.28,17.94 122.88,18.33 119.63,18.33 119.37,18.59 110.09,18.59 109.65,19.02 98.99,19.02 98.07,19.94 96.44,19.94 95.19,21.19 93.4,21.19 92.85,21.75 92.22,22.38 92.22,22.79 90.89,24.12 82.69,24.12 81.27,22.69 71.28,22.69 67.88,26.1 67.88,27.88 65.49,30.26 64.35,30.26 63.74,30.87 63.1,30.87 62.98,30.75 v1(62.06,30.75)
  BOTTOM w0.102: R2504.1 63.89,43.29 61.43,40.83 61.43,32.5 62.06,31.86 v1(62.06,30.75)
RTC_RST#: length 51.5
  TOP w0.079: 76.88,46.43 76.98,46.34 76.98,45.52 77.15,45.35 77.51,45.35 77.66,45.2 78.17,45.2 78.63,44.73 80.9,44.73 v4(81.35,44.28)
  TOP w0.102: 76.88,46.43 76.08,47.23 69.14,47.23 68.91,47 66.58,47 66.41,47.18 65.76,47.18 Q2014.3 64.16,45.58 61.83,45.58 58.94,42.69 58.94,40.1 58.51,39.67 58.51,33.09 57.69,32.28 57.69,29.45 57.03,28.79 57.03,26.11 C2419.1 56.55,25.69 55.91,25.04 54.48,25.04 53.65,24.21 v1(53.58,24.21) 53.12,24.21 52.53,24.8 J2000.1 52.23,25.13 51.43,24.33 R2360.2
  BOTTOM w0.102: v4(81.35,44.28) 81.35,44.51 U2030.AM16
RTC_X1: length 23.6
  IN1 w0.079: v4(80.76,45.2) 80.4,45.56 78.52,45.56 78.52,45.56 78.01,45.56
  IN1 w0.089: v1(77.3,32.87) 77.18,33 77.18,34.28 76.67,34.78 76.67,36.79 76.03,37.43 76.03,42.35 77.05,43.37 77.05,44.6 78.01,45.56
  BOTTOM w0.102: U2030.AM18 81.11,45.55 v4(80.76,45.2) ; Y2004.1 79.53,29.19 C2596.2 79.53,31 R2553.1 79.42,31.48 v1(78.98,31.93) 78.61,32.29 78.17,32.29 77.59,32.87 v1(77.3,32.87)
RTC_X2: length 24.5
  IN1 w0.079: 76.41,43.13 76.77,43.49 76.77,44.55 77.94,45.72 81.11,45.72 v2(81.49,46.1)
  IN1 w0.089: 76.41,43.13 75.64,42.36 75.64,37.31 76.24,36.71 76.24,34.66 76.67,34.22 v1(76.67,32.84)
  BOTTOM w0.102: v2(81.49,46.1) 81.49,46.2 U2030.AM20 ; Y2004.2 78.41,29.07 C2595.1 78.41,30.87 R2553.2 78.64,31.46 77.64,32.46 77.05,32.46 v1(76.67,32.84)
S5_ON: length 219.6
  TOP w0.102: PR6027.1 27.63,26.45 v1(28.09,26.91) ; R25309.1 195.38,31.43 196.05,30.77 U37.100 196.05,29.1 196.68,28.46 196.68,27.61 195.32,26.25 195.01,26.25 193.83,25.07 193.83,23.43 194.65,22.6 195.06,22.6 195.26,22.4 195.26,20.53 v2(195.82,19.98) ; PR566.2 39.2,26.81 39.61,26.81 39.61,26.81 v1(39.64,26.81)
  IN2 w0.089: v2(195.82,19.98) 195.13,19.28 193.98,19.28 190.55,22.71 190.55,24.14 190.24,24.45 187.4,24.45 187.06,24.8 184.8,24.8 184.22,24.22 177.96,24.22 177.74,24.43 173.37,24.43 v1(171.96,25.84) 170.72,24.6 167.42,24.6 166.72,25.3 162.91,25.3 162.64,25.04 162.63,25.04 162.15,24.56 161.49,24.56 160.66,23.73 158.67,23.73 157.41,22.47 155.87,22.47 155.09,21.68 154.01,21.68 153.54,22.15 152.04,22.15 151.79,21.91 149.2,21.91 148.55,22.55 146.32,22.55 142.3,18.53 124.89,18.53 124.45,18.98 119.88,18.98 119.02,19.84 104.95,19.84 101.11,23.67 100.37,23.67 98.65,25.39 94.04,25.39 93.34,26.09 92.39,26.09 92.25,26.23 91.44,26.23 90.8,25.59 82.26,25.59 80.86,24.19 78.42,24.19 77.63,24.98 75.6,24.98 74.36,23.74 64.15,23.74 62.44,22.03 54.29,22.03 52.36,23.96 49.77,23.96 48.35,25.39 42.86,25.39 42.71,25.23 v1(42.71,24.85)
  BOTTOM w0.102: v1(28.09,26.91) 28.63,26.38 29.81,26.38 30.16,26.73 34.48,26.73 34.66,26.55 34.66,25.64 34.89,25.41 36.18,25.41 36.49,25.72 38.51,25.72 39.61,26.81 v1(39.64,26.81) 40.63,25.82 41.95,25.82 42.71,25.06 v1(42.71,24.85) ; PR6015.2 160.41,29.55 160.54,29.68 162.57,29.68 162.85,29.4 166.06,29.4 168.91,26.55 170.65,26.55 170.9,26.3 170.9,25.74 171.03,25.61 171.72,25.61 171.95,25.84 v1(171.96,25.84)
SATA_LED#: length 2.2
  TOP w0.102: TP2092.1 37.76,2.91 v1(37.76,3.26)
  BOTTOM w0.102: v1(37.76,3.26) 37.7,3.21 37.7,3.08 37.6,2.98 CN16.10
SATA_RXN0_C: length 12
  TOP w0.102: C6592.1 210.37,11.53 v1(210.5,11.4) ; R25352.2 v1(210.25,21.11)
  IN3 w0.089: v1(210.25,21.11) 209.71,20.57 209.71,17.76 209.26,17.3 209.26,14.5 209.97,13.79 209.97,12.95 209.9,12.89 209.9,11.49 209.99,11.4 v1(210.5,11.4)
SATA_RXN0_CN: length 8.2
  TOP w0.102: v1(210.19,10.68) 210.04,10.83 210.04,11.67 209.79,11.92 209.79,12.36 209.87,12.44 210.27,12.44 C6596.2
  BOTTOM w0.102: HD1.8 213.38,12.82 213.17,13.03 211.38,13.03 210.04,11.7 210.04,10.76 210.12,10.68 v1(210.19,10.68)
SATA_RXN0_HDD: length 138.5
  TOP w0.102: R25352.1 209.82,20.15 209.72,20.25 209.72,20.83 209.81,20.93 209.81,21.51 v1(210.02,21.72)
  IN1 w0.089: v1(210.02,21.72) 209.81,21.93 209.81,22.2 206.82,25.18 203.97,25.18 203.85,25.3 199.69,25.3 195.72,29.27 191.63,29.27 190.68,28.33 188.28,28.33 187.38,27.43 177.27,27.43 176.9,27.8 174.19,27.8 173.43,27.04 173.13,27.04 172.51,27.65 169.92,27.65 169.75,27.82 167.07,27.82 165.87,29.02 163.6,29.02 162.59,30.03 157.69,30.03 155.75,28.09 150.28,28.09 149.23,27.04 147.54,27.04 146.66,27.92 144.9,27.92 142.95,25.97 133.13,25.97 131.84,27.27 124.63,27.27 124.04,27.86 124.04,28.32 119.79,32.57 112.09,32.57 111.83,32.83 109.13,32.83 106.61,35.35 103.9,35.35 101.15,38.09 101.15,39.8 98.99,41.95 98.99,42.27 98.41,42.85 97.17,42.85 96.73,43.28 96.73,45.99 96.01,46.72 94.88,46.72 v4(94.27,46.11)
  BOTTOM w0.102: U2030.F20 v4(94.27,46.11)
SATA_RXN0_IN: length 2.1
  TOP w0.102: U42.4 210.13,18.8 209.98,18.95 209.98,19.18 209.72,19.44 209.72,19.6 209.82,19.7 C6588.2
SATA_RXN1A_C: length 2.4
  TOP w0.102: C782.1 134.44,17.12 134.34,17.02 134.34,16.66 134.55,16.45 v1(134.71,16.45)
  BOTTOM w0.102: CN15.5 134.85,17.1 134.71,16.96 v1(134.71,16.45)
SATA_RXN1A_ODD: length 68.1
  TOP w0.102: C782.2 134.32,18.3 134.32,20.86 135.08,21.61 135.08,24.27 137.34,26.53 137.34,27.29 v1(137.54,27.5)
  IN1 w0.089: v4(93.69,47.94) 93.69,47.94 93.86,47.76 93.86,47.55 94.16,47.26 96.19,47.26 97.19,46.26 97.19,45.7 102.07,40.82 102.07,38.66 102.53,38.2 102.53,37.57 104.14,35.95 106.96,35.95 109.49,33.43 122.11,33.43 124.08,31.46 129.24,31.46 129.59,31.1 130.08,31.1 130.41,30.76 130.41,28.83 130.91,28.33 131.38,28.33 131.66,28.61 132.64,28.61 133.56,27.7 135.21,27.7 136.12,26.78 136.97,26.78 137.32,27.13 137.32,27.28 v1(137.54,27.5)
  BOTTOM w0.102: U2030.G21 93.69,47.83 v4(93.69,47.94)
SATA_RXN_OUT: length 2.2
  TOP w0.102: C6596.1 210.01,12.78 209.91,12.89 209.91,13.03 209.99,13.1 209.99,13.65 210.13,13.8 U42.12
SATA_RXP0_C: length 12
  TOP w0.102: v1(209.38,11.39) 209.15,11.39 209.07,11.48 209.07,11.72 C6593.1 ; v1(209.07,21.11) 208.98,21.01 R25353.2
  IN3 w0.089: v1(209.07,21.11) 209.51,20.67 209.51,17.84 209.05,17.38 209.05,14.41 209.76,13.7 209.76,13.04 209.7,12.97 209.7,11.5 209.6,11.4 209.39,11.4 v1(209.38,11.39)
SATA_RXP0_CN: length 8.2
  TOP w0.102: C6597.2 209.35,12.33 209.57,12.11 209.57,11.83 209.83,11.58 209.83,11.09 v1(209.41,10.68)
  BOTTOM w0.102: HD1.7 213.38,13.32 213.31,13.24 211.29,13.24 209.83,11.78 209.83,11.09 v1(209.41,10.68)
SATA_RXP0_HDD: length 138.4
  TOP w0.102: v1(209.39,21.72) 209.6,21.51 209.6,21.02 209.5,20.92 209.5,20.25 209.4,20.15 R25353.1
  IN1 w0.089: v4(94.88,46.13) 94.88,46.44 94.97,46.52 95.92,46.52 96.53,45.91 96.53,43.2 97.08,42.65 98.33,42.65 98.79,42.18 98.79,41.87 100.95,39.71 100.95,38.01 103.82,35.14 106.53,35.14 109.05,32.63 111.75,32.63 112.01,32.36 119.7,32.36 123.84,28.23 123.84,27.78 124.55,27.06 131.75,27.06 133.05,25.77 143.04,25.77 144.99,27.72 146.57,27.72 147.46,26.83 149.31,26.83 150.37,27.89 155.84,27.89 157.78,29.83 162.5,29.83 163.52,28.82 165.79,28.82 166.98,27.62 169.66,27.62 169.84,27.45 172.43,27.45 173.04,26.83 173.52,26.83 174.28,27.6 176.81,27.6 177.18,27.23 187.47,27.23 188.36,28.12 190.77,28.12 191.71,29.07 195.63,29.07 199.6,25.1 203.77,25.1 203.89,24.98 206.74,24.98 209.6,22.12 209.6,21.93 v1(209.39,21.72)
  BOTTOM w0.102: v4(94.88,46.13) 94.88,46.38 95.01,46.5 95.01,46.72 94.88,46.85 94.73,46.85 94.65,46.77 U2030.E20
SATA_RXP0_IN: length 2.1
  TOP w0.102: C6589.2 209.4,19.7 209.5,19.6 209.5,19.35 209.76,19.09 209.76,18.94 209.63,18.81 U42.5
SATA_RXP1A_C: length 2.3
  TOP w0.102: C781.1 134.01,17.12 134.12,17.01 134.12,16.62 v1(133.95,16.45)
  BOTTOM w0.102: v1(133.95,16.45) 134.35,16.84 CN15.6
SATA_RXP1A_ODD: length 68.2
  TOP w0.102: v1(136.78,27.5) 136.99,27.5 137.12,27.37 137.12,26.62 134.86,24.36 134.86,21.7 134.1,20.95 134.1,18 134,17.9 C781.2
  IN1 w0.089: v4(94.31,47.94) 94.2,47.94 94.07,47.81 94.07,47.64 94.25,47.46 96.28,47.46 97.39,46.34 97.39,45.78 102.27,40.91 102.27,38.75 102.73,38.29 102.73,37.65 104.22,36.16 107.05,36.16 109.57,33.63 122.2,33.63 124.17,31.66 129.32,31.66 129.68,31.3 130.16,31.3 130.62,30.85 130.62,28.92 131,28.54 131.3,28.54 131.58,28.82 132.73,28.82 133.64,27.9 135.29,27.9 136.21,26.99 136.89,26.99 137.12,27.22 137.12,27.37 136.99,27.5 v1(136.78,27.5)
  BOTTOM w0.102: U2030.F21 94.07,47.56 94.07,47.84 94.17,47.94 v4(94.31,47.94)
SATA_RXP_OUT: length 2.2
  TOP w0.102: U42.11 209.63,13.8 209.77,13.65 209.77,13.19 209.69,13.12 209.69,12.89 209.59,12.78 C6597.1
SATA_TXN0_C: length 12.1
  TOP w0.102: R25351.2 211.01,21.18 v1(211.09,21.26) ; C6591.1 v1(211.14,11.4)
  IN3 w0.089: v1(211.14,11.4) 211.58,11.4 211.67,11.49 211.67,14.96 212.09,15.38 212.09,17.25 211.47,17.87 211.47,20.88 v1(211.09,21.26)
SATA_TXN0_CN: length 5.8
  TOP w0.102: C6591.2 211.38,12.33 211.59,12.12 211.59,10.89 v1(211.38,10.68)
  BOTTOM w0.102: v1(211.38,10.68) 211.66,10.96 211.66,11.1 211.66,11.11 211.66,11.57 212.16,12.08 212.67,12.08 213.07,11.68 213.24,11.68 213.38,11.82 HD1.10
SATA_TXN0_HDD: length 137.5
  TOP w0.102: v1(211.06,22.39) 211.27,22.18 211.27,21.81 211.54,21.54 211.54,20.25 211.43,20.15 R25351.1
  IN1 w0.089: v1(211.06,22.39) 211.28,22.61 211.28,23.09 208.71,25.67 204.96,25.67 204.51,26.12 203.27,26.12 202.93,25.79 199.8,25.79 195.87,29.71 191.13,29.71 190.68,29.26 188.11,29.26 186.67,27.82 180.77,27.82 180.08,28.51 178.45,28.51 178.2,28.27 171.5,28.27 171.26,28.51 167.29,28.51 166.21,29.59 164.91,29.59 163.99,30.52 162.79,30.52 162.44,30.87 157.67,30.87 156.31,29.5 152.7,29.5 151.68,28.48 147.59,28.48 147.41,28.66 140.73,28.66 140.12,28.05 137.8,28.05 136.1,29.75 136.1,31.15 135.88,31.38 132.01,31.38 131.12,32.26 124.41,32.26 122.45,34.23 111.48,34.23 109.05,36.66 109.05,39.47 108.68,39.84 104.72,39.84 99.98,44.59 99.98,47.06 v1(99.78,47.26)
  BOTTOM w0.079: U2030.B21 96.99,47.5 98.34,47.5 98.37,47.48 98.38,47.48
  BOTTOM w0.102: v1(99.78,47.26) 99.91,47.39 99.91,47.53 99.72,47.72 99.01,47.72 98.77,47.48 98.38,47.48
SATA_TXN0_IN: length 2.1
  TOP w0.102: U42.2 211.13,18.85 211.29,19.01 211.29,19.21 211.54,19.45 211.54,19.6 211.43,19.7 C6587.2
SATA_TXN1A_C: length 2.5
  TOP w0.102: v1(136.75,16.45) 136.66,16.45 136.42,16.69 136.42,17.02 136.52,17.12 C784.1
  BOTTOM w0.102: CN15.2 136.35,17.1 136.31,17.06 136.31,16.91 136.44,16.78 136.44,16.55 136.55,16.45 v1(136.75,16.45)
SATA_TXN1A_ODD: length 74.2
  TOP w0.102: v1(140.39,29.5) 140.18,29.29 140.18,28.67 139.39,27.89 139.11,27.89 138.3,27.07 138.3,26.62 135.77,24.09 135.77,21.4 135.06,20.69 135.06,19.6 C784.2
  IN1 w0.089: v1(101.96,47.51) 101.76,47.32 101.76,46.71 101.36,46.31 101.36,44.74 104.97,41.13 105.23,41.13 105.51,40.85 109.29,40.85 110.07,40.07 110.07,37.15 112,35.23 122.86,35.23 124.8,33.29 131.4,33.29 132.02,33.91 132.92,33.91 134.41,32.42 136.42,32.42 137.15,31.69 137.15,30.13 137.54,29.73 138.26,29.73 138.75,30.21 139.92,30.21 140.19,29.94 140.19,29.7 v1(140.39,29.5)
  BOTTOM w0.079: 98.84,48.43 98.82,48.41 98.65,48.41 98.3,48.06 97.8,48.06 97.66,48.2 97.24,48.2 97.2,48.18 96.9,48.18 96.85,48.2 96.56,48.2 96.49,48.15 96.04,48.15 95.66,47.77 U2030.D21
  BOTTOM w0.102: v1(101.96,47.51) 101.76,47.7 101.76,48.08 101.41,48.43 98.84,48.43
SATA_TXN_OUT: length 2.3
  TOP w0.102: U42.14 211.13,13.91 211.27,13.77 211.27,13.42 211.63,13.06 211.63,12.9 211.51,12.78 C6595.1
SATA_TXP0_C: length 12.2
  TOP w0.102: v1(212.2,21.26) 212.28,21.18 R25350.2 ; C6590.1 v1(212.41,11.4)
  IN3 w0.089: v1(212.41,11.4) 211.96,11.4 211.87,11.49 211.87,14.88 212.29,15.29 212.29,17.33 211.67,17.95 211.67,20.72 v1(212.2,21.26)
SATA_TXP0_CN: length 5.8
  TOP w0.102: v1(212.16,10.68) 211.98,10.68 211.81,10.85 211.81,12.23 211.91,12.33 C6590.2
  BOTTOM w0.102: HD1.11 213.38,11.32 213.24,11.46 212.98,11.46 212.58,11.86 212.25,11.86 211.87,11.48 211.87,11.2 211.88,11.19 211.88,10.96 v1(212.16,10.68)
SATA_TXP0_HDD: length 137.3
  TOP w0.102: v1(211.7,22.39) 211.49,22.18 211.49,21.9 211.75,21.63 211.75,20.25 211.85,20.15 R25350.1
  IN1 w0.089: v1(100.42,47.25) 100.24,47.26 100.18,47.21 100.18,47.01 100.18,44.67 104.81,40.05 108.77,40.05 109.26,39.56 109.26,36.74 111.57,34.43 122.53,34.43 124.49,32.47 131.21,32.47 132.09,31.58 135.96,31.58 136.31,31.24 136.31,29.83 137.88,28.26 140.03,28.26 140.64,28.87 147.49,28.87 147.67,28.69 151.6,28.69 152.61,29.7 156.22,29.7 157.59,31.07 162.53,31.07 162.88,30.72 164.07,30.72 165,29.79 166.29,29.79 167.37,28.71 171.35,28.71 171.59,28.47 178.12,28.47 178.36,28.71 180.17,28.71 180.85,28.03 186.59,28.03 188.03,29.47 190.6,29.47 191.05,29.91 195.96,29.91 199.88,25.99 202.85,25.99 203.19,26.33 204.59,26.33 205.05,25.87 208.79,25.87 211.48,23.18 211.48,22.61 v1(211.7,22.39)
  BOTTOM w0.079: 98.37,47.68 98.34,47.66 97.48,47.66 U2030.A21
  BOTTOM w0.102: v1(100.42,47.25) 100.31,47.25 100.16,47.4 100.16,47.57 99.81,47.92 98.93,47.92 98.69,47.68 98.37,47.68
SATA_TXP0_IN: length 2
  TOP w0.102: U42.1 211.63,18.86 211.51,18.98 211.51,19.12 211.75,19.36 211.75,19.6 211.85,19.7 C6586.2
SATA_TXP1A_C: length 2.5
  TOP w0.102: C783.1 136.04,17.12 136.21,16.95 136.21,16.67 v1(135.98,16.45)
  BOTTOM w0.102: v1(135.98,16.45) 136.13,16.45 136.23,16.55 136.23,16.69 136.09,16.82 136.09,16.9 135.85,17.14 CN15.3
SATA_TXP1A_ODD: length 74.3
  TOP w0.102: C783.2 136.19,17.9 136.26,17.97 136.26,18.1 134.85,19.51 134.85,20.78 135.56,21.49 135.56,24.18 138.09,26.71 138.09,27.16 139.02,28.1 139.3,28.1 139.97,28.76 139.97,29.4 139.86,29.5 v1(139.63,29.5)
  IN1 w0.089: v1(139.63,29.5) 139.91,29.5 139.99,29.58 139.99,29.86 139.84,30.01 138.83,30.01 138.35,29.53 137.46,29.53 136.94,30.04 136.94,31.61 136.33,32.22 134.33,32.22 132.83,33.71 132.11,33.71 131.48,33.09 124.71,33.09 122.78,35.03 111.91,35.03 109.87,37.07 109.87,39.98 109.2,40.65 105.43,40.65 105.14,40.93 104.88,40.93 101.15,44.66 101.15,46.39 101.56,46.8 101.56,47.43 101.48,47.51 v1(101.32,47.51)
  BOTTOM w0.079: 98.84,48.23 98.82,48.25 98.71,48.25 98.36,47.9 97.73,47.9 97.59,48.04 97.27,48.04 97.23,48.02 96.87,48.02 96.82,48.04 96.6,48.04 96.53,47.99 96.15,47.99 96.07,47.92 U2030.C21
  BOTTOM w0.102: 98.84,48.23 101.32,48.23 101.56,47.99 101.56,47.61 101.46,47.51 v1(101.32,47.51)
SATA_TXP_OUT: length 2.4
  TOP w0.102: C6594.1 211.97,12.78 211.85,12.9 211.85,13.15 211.49,13.51 211.49,13.76 211.63,13.9 U42.15
SATAGP0: length 7.6
  BOTTOM w0.102: R2543.2 95.62,30.49 96,30.86 96,32.45 93.5,34.95 93.5,36.36 93.35,36.51 U2030.H2
SATAGP1: length 6
  BOTTOM w0.102: R2545.2 95.46,32.67 93.28,34.85 93.28,35.41 92.92,35.77 92.92,37.03 92.94,37.05 U2030.H3
SD_1P8_RCOPM: length 13.1
  TOP w0.079: v4(86.79,39.23) 87.31,39.75 87.31,42.29 87.64,42.62 87.96,42.62 88.5,42.08 88.5,39.47 88.65,39.33 88.65,38.93 88.6,38.88 88.6,36.81 88.69,36.69 89.8,35.58 R2207.2
  BOTTOM w0.102: v4(86.79,39.23) 86.62,39.06 U2030.AB7
SDVO_CLK: length 148
  TOP w0.102: v1(22.62,61.89) 22.88,61.89 23.18,61.58 24.31,61.58 R775.1 ; v1(18.73,82.79) 18.6,82.92 R494.2 18.2,83.01 18.2,82.52 18.87,81.85 19.33,81.85 19.51,81.67 U23.7
  IN1 w0.089: v1(18.73,82.79) 18.58,82.64 18.58,82.08 19.3,81.35 19.3,77.25 21.5,75.05 21.5,74.56 23.06,73.01 23.06,72.15 23.84,71.37 23.84,66.16 22.62,64.94 v1(22.62,61.89) 21.27,60.54 21.27,57.45 21.74,56.98 21.74,56.25 22.18,55.81 22.18,53.11 23.36,51.93 23.36,43.32 22.93,42.89 22.93,39.01 25.38,36.56 25.38,35.09 27.13,33.34 28.42,33.34 v1(28.45,33.31)
  IN3 w0.089: v1(28.45,33.31) 28.45,32.84 29.43,31.86 29.43,27.48 32.02,24.89 37.62,24.89 38.44,25.72 48.68,25.72 48.83,25.56 51.52,25.56 52.44,24.65 56.22,24.65 57.11,25.54 57.49,25.54 58.43,26.48 62.16,26.48 62.85,27.17 62.85,27.27 64.65,29.07 64.65,29.57 69.08,34 71.18,34 71.45,33.73 73.68,33.73 74.49,32.93 76.02,32.93 76.5,32.44 78.45,32.44 78.61,32.29 80.64,32.29 81.86,31.06 82.19,31.06 82.61,31.48 82.61,33.45 83.55,34.39 84.09,34.39 85.84,36.15 86.83,36.15 87.41,36.73 89.18,36.73 90.35,37.89 90.35,42.71 v4(90.94,43.31)
  BOTTOM w0.102: U2030.L13 91.06,43.31 v4(90.94,43.31)
SDVO_DATA: length 146.4
  TOP w0.102: R777.1 23.7,61.17 22.69,61.17 v1(22.64,61.23) ; v1(19.49,82.79) 19.49,83.16 R502.2 20,83.16 20,83.05 20.01,83.04 U23.6
  IN1 w0.089: v1(27.98,33.8) 27.23,33.8 25.78,35.25 25.78,36.72 23.33,39.17 23.33,42.73 23.76,43.16 23.76,52.09 22.57,53.28 22.57,55.97 22.13,56.41 22.13,57.15 21.66,57.62 21.66,60.25 v1(22.64,61.23) 23.18,61.77 23.18,64.95 24.23,65.99 24.23,71.54 23.45,72.32 23.45,73.17 21.89,74.73 21.89,75.21 19.7,77.41 19.7,82.59 v1(19.49,82.79)
  IN3 w0.089: v4(90.94,42.68) 90.51,42.25 90.51,37.83 89.25,36.57 87.48,36.57 86.9,35.98 85.91,35.98 84.15,34.23 83.62,34.23 82.78,33.39 82.78,31.41 82.26,30.9 81.79,30.9 80.57,32.12 78.52,32.12 78.36,32.28 76.43,32.28 75.95,32.76 74.3,32.76 73.52,33.54 69.18,33.54 65.06,29.42 65.06,28.92 63.26,27.11 63.26,27.02 62.31,26.07 58.58,26.07 57.64,25.13 57.26,25.13 56.39,24.26 52.27,24.26 51.78,24.75 49.06,24.75 48.5,25.31 38.59,25.31 37.78,24.5 31.86,24.5 29.04,27.32 29.04,31.7 27.98,32.75 v1(27.98,33.8)
  BOTTOM w0.102: U2030.L12 91.03,42.68 v4(90.94,42.68)
SEL: length 5.2
  BOTTOM w0.102: R25276.1 19.42,18.71 R25280.2 20.31,18.71 20.98,19.38 v1(20.98,19.68) 20.92,19.68 R25277.2 19.33,20.44 19.1,20.67 U6502.6
SENSEA: length 3.4
  TOP w0.381: R451.1 199.48,30.91 v1(199.48,30.3)
  BOTTOM w0.203: U20.13 200.24,30.43 R452.1
  BOTTOM w0.381: R452.1 200.17,30.35 199.56,30.35 199.51,30.3 v1(199.48,30.3) 199.45,30.34 R733.1
SERIRQ: length 145.1
  TOP w0.102: v2(180,28.07) 180.14,27.93 180.68,27.93 180.96,27.65 180.96,26.81 181.19,26.58 U37.5
  IN2 w0.089: v2(180,28.07) 179.27,28.8 176.65,28.8 176.24,29.2 172.45,29.2 171.84,29.81 168.09,29.81 167.91,29.63 165.94,29.63 165.45,29.14 163.32,29.14 162.48,29.98 158.11,29.98 156.17,28.03 151.55,28.03 148.55,25.03 144.55,25.03 143.7,24.17 132.97,24.17 131.36,25.78 125.98,25.78 125.9,25.86 111.77,25.86 107.21,30.42 105.67,30.42 104.94,31.14 104.94,31.7 104.18,32.46 103.8,32.46 103.52,32.74 101.25,32.74 100.08,33.9 97.83,33.9 97.74,33.99 96.6,33.99 96.32,34.27 93.04,34.27 91.11,32.34 89.62,32.34 89.08,32.88 88.23,32.88 87.38,32.03 86.7,32.03 85.46,30.79 83.28,30.79 82.79,31.28 82.79,34.81 82.31,35.29 81.78,35.29 81.43,34.94 81.43,34.43 81.1,34.1 80.4,34.1 80.05,34.45 80.05,34.89 78.81,36.12 75.11,36.12 73.9,34.91 73.49,34.91 73.06,34.48 72.17,34.48 71.66,34.99 70.34,34.99 70.12,34.76 70.12,34.48 v1(70.09,34.45)
  BOTTOM w0.102: U2030.AY11 75.71,41.53 74.64,41.53 71.18,38.08 71.18,36.68 70.6,36.09 70.6,35.6 70.09,35.09 v1(70.09,34.45) 70.09,34.2 69.61,33.72 69.61,32.19 69.4,31.99 R2551.1
SIO_EXT_SCI#: length 119.7
  TOP w0.079: v4(89.9,40.64) 90.28,40.26 90.28,39.87 90.37,39.78 90.37,37.97 90.84,37.5 90.84,36.84 90.84,36.84 90.84,36.69 91.27,36.26
  TOP w0.102: U37.23 182.35,19.38 181.6,18.63 180.51,18.63 180.33,18.81 179.47,18.81 179.24,19.04 178.57,19.04 178.32,19.29 178.32,19.8 178.07,20.05 175.82,20.05 173.28,22.6 173.28,24.25 173.13,24.4 173.13,25.89 173.02,25.99 173.02,27.23 v1(173.26,27.47) ; v1(100.21,27.76) 100.21,28.99 100.34,29.11 R2604.1 100.34,30.58 100.52,30.77 100.52,32.23 99.84,32.92 96.23,32.92 94.41,34.74 93.73,34.74 92.64,35.82 91.71,35.82 91.27,36.26
  IN2 w0.089: v1(100.21,27.76) 100.5,27.48 100.82,27.48 101.46,26.84 103.07,26.84 104.71,25.21 105.94,25.21 108.78,22.37 113.67,22.37 115.38,24.08 120.22,24.08 120.83,24.69 121.45,24.69 122.06,24.08 127.12,24.08 127.68,24.64 131.16,24.64 132.57,23.22 144.42,23.22 145.27,24.08 149.18,24.08 149.79,23.47 151.2,23.47 151.4,23.68 153.73,23.68 153.94,23.88 155.13,23.88 155.23,23.99 156.75,23.99 157.4,24.64 157.4,25.85 158.36,26.81 158.36,27.12 158.53,27.29 159.6,27.29 160.01,26.88 165.35,26.88 166.57,28.1 169.92,28.1 170.35,27.68 173.05,27.68 v1(173.26,27.47)
  BOTTOM w0.102: v4(89.9,40.64) 90.17,40.37 U2030.N9
SIO_RCIN#: length 169.4
  TOP w0.102: v2(193.81,19.98) 193.76,19.98 193.35,20.38 192.4,20.38 190.25,22.53 189.69,22.53 188,24.22 188,24.59 186.78,25.81 185.13,25.81 183.96,26.98 U37.4
  IN1 w0.089: v1(65.67,32.22) 65.95,31.94 67.17,31.94 68.01,31.1 73.04,31.1 75.22,28.92 75.22,26.76 77.91,24.07 80.71,24.07 82.09,25.45 91.46,25.45 93.15,23.76 93.39,23.76 94.63,22.52 96.22,22.52 97.41,21.33 100.45,21.33 100.91,20.87 102.1,20.87 102.62,20.36 110.21,20.36 110.64,19.93 120.02,19.93 120.28,19.67 124.4,19.67 124.68,19.94 127.19,19.94 127.86,19.27 131.64,19.27 131.96,18.95 137.42,18.95 138.51,20.05 166.03,20.05 166.25,19.82 166.25,19.37 166.61,19.01 174.78,19.01 175.3,19.53 177.35,19.53 177.54,19.35 180.68,19.35 181.37,18.65 183.84,18.65 184.24,18.25 186.5,18.25 186.85,17.91 187.29,17.91 189.03,16.17 190.28,16.17 191.29,15.16 197.12,15.16 197.43,15.48 197.43,16.42 197.21,16.64 196.56,16.64 193.99,19.21 193.99,19.8 v2(193.81,19.98)
  BOTTOM w0.102: R2521.1 65.6,34.48 65.8,34.28 65.8,33.4 65.67,33.28 v1(65.67,32.22)
SLEEVE: length 16.4
  IN3 w1.016: 201.48,33.13 201.48,33.13 201.48,35.04 202.25,35.8 203.9,35.8 205.67,37.58 205.67,38.88 209.08,42.28 210.63,42.28
  BOTTOM w0.203: v1(200.2,32.9) v1(200.65,32.45) 200.68,32.43 U20.18
  vias: v1(211.72,42.51) v1(212.28,42.76)
SM_RCOMP_0: length 1.2
  TOP w0.254: v4(79.49,45.18) 79.64,45.33 80.04,45.33 R2199.1
  BOTTOM w0.305: U2030.AR18 79.49,45.2 v4(79.49,45.18)
SM_RCOMP_1: length 2.3
  TOP w0.381: R2197.2 77.68,45.77 77.91,45.55 78.49,45.55 v2(78.86,45.18)
  BOTTOM w0.254: v2(78.86,45.18) 78.86,45.32 U2030.AT18
SM_RCOMP_2: length 2.5
  TOP w0.254: R2204.1 78.1,43.72 77.54,44.27 v4(77.54,44.29)
  BOTTOM w0.254: U2030.AU18 77.47,45.27 77.47,44.35 v4(77.54,44.29)
SMB1ALERT#: length 16.5
  TOP w0.079: 81.11,35.52 81.11,36.2 82.15,37.24 82.15,38.44 81.89,38.71 v4(81.62,38.71)
  TOP w0.102: R2290.1 82.31,25.02 TP2050.1 82.33,25.44 82.33,29.98 81.11,31.2 81.11,35.52
  BOTTOM w0.102: v4(81.62,38.71) 81.6,38.74 81.6,38.77 81.21,39.15 81.21,39.16 U2030.AM7
SMB_ME1_CLK: length 5.2
  BOTTOM w0.079: 87.72,35.69 87.63,35.92 87.63,36.59 U2030.W3
  BOTTOM w0.102: R2538.2 88.71,33.07 88.71,34.7 87.72,35.69
SMB_ME1_DAT: length 5.2
  BOTTOM w0.102: R2539.2 88.96,32.93 89.01,32.98 89.01,34.7 88.23,35.49 88.23,36.98 U2030.V3
SMB_RUN_CLK: length 75.6
  TOP w0.102: R557.2 95.49,27.88 95.59,27.98 v1(95.59,28.1) ; R591.1 58.53,23.4 59.27,24.14 v2(59.27,24.19)
  IN1 w0.089: v2(55.66,27.47) 57.26,27.47 57.39,27.34 57.39,25.34 58.15,24.57 58.15,23.96 58.35,23.76 59.04,23.76 59.27,23.99 v2(59.27,24.19) ; v1(100.47,26.19) 100.18,26.48 96.15,26.48 95.72,26.92 95.72,27.98 v1(95.59,28.1)
  IN2 w0.089: v1(95.59,28.1) 95.59,28.17 95.39,28.37 93.6,28.37 93.5,28.47 92.81,28.47 92.63,28.29 85.03,28.29 84.37,27.63 81.48,27.63 81.09,27.24 77.18,27.24 76.8,27.62 76.8,30 76.05,30.74 76.05,31.11 75.65,31.51 73.9,31.51 73.72,31.69 70.42,31.69 69.72,30.99 69.33,30.72 65.23,26.63 63.87,26.63 63.59,26.91 56.53,26.91 55.97,27.47 v2(55.66,27.47)
  BOTTOM w0.102: Q2026.1 101.96,31.08 101.61,30.74 101.61,28.87 R2610.1 102.03,28.42 101.74,28.13 101.45,28.13 100.87,27.55 100.87,27.26 100.47,26.85 v1(100.47,26.19) ; JDIM2000.253 57.52,31.2 57.11,31.61 55.69,31.61 55.31,31.23 55.31,29.44 55.66,29.09 v2(55.66,27.47)
SMB_RUN_DAT: length 79.5
  TOP w0.102: v1(49.87,25.16) 50.18,24.85 50.18,23.15 52.23,21.1 R590.1 ; v1(93.8,28.77) 93.69,28.65 R561.2
  IN1 w0.089: v1(93.8,28.77) 94.11,28.77 95.49,27.39 95.49,26.83 96.18,26.14 99.54,26.14 v1(99.96,25.73) ; v2(55.22,27.02) 55.22,26.82 54.47,26.07 50.2,26.07 49.87,25.74 v1(49.87,25.16)
  IN2 w0.089: v2(55.22,27.02) 55.22,27.74 55.38,27.9 55.87,27.9 56.63,27.14 63.69,27.14 63.97,26.86 65.16,26.86 69.19,30.89 69.59,31.16 70.42,31.99 75.58,31.99 76.26,31.3 76.26,30.83 77.01,30.09 77.01,27.71 77.27,27.46 81,27.46 81.39,27.84 84.28,27.84 84.94,28.51 92.54,28.51 92.72,28.68 93.72,28.68 v1(93.8,28.77)
  BOTTOM w0.102: Q2026.4 100.72,29.74 100.72,29.02 101.06,28.68 R2614.1 100.67,28.06 100.67,27.67 100.62,27.62 100.62,27.6 99.96,26.94 v1(99.96,25.73) ; JDIM2000.254 53.29,30.95 55.33,28.92 55.33,27.95 55.22,27.84 v2(55.22,27.02)
SMBALERT#: length 20.3
  IN1 w0.089: v1(98.31,37.34) 93.03,37.34 92.64,37.72 91.93,37.72 91.52,37.31 90.69,37.31 89.39,38.6 89.39,40.16 v4(88.89,40.66)
  BOTTOM w0.102: U2030.R10 89.25,41.02 v4(88.89,40.66) ; v1(98.31,37.34) 98.55,37.58 99.02,37.58 99.35,37.25 99.35,36.59 98.87,36.1 98.87,35.72 98.59,35.44 98.59,35.11 99.81,33.89 99.81,33.25 100.17,32.89 100.17,32.64 100.62,32.18 R2571.2
SML0ALERT#: length 5.6
  BOTTOM w0.102: R2592.2 87.64,30.84 87.64,32.8 88.17,33.33 88.17,34.66 87.23,35.6 U2030.W1
SP_PLLVDD: length 16.6
  TOP w0.381: L8.2 88.33,107.04 L32.2 88.35,105.94 C462.1 91.85,105.94 93.13,104.65 93.13,103.64 94,102.77 96,102.77 96.69,102.09 R329.2 97.54,102.09 97.96,101.67 v2(98,101.67) 98.16,101.83 98.36,101.83 C461.1 99.36,102.09 99.47,101.97 C460.2 C459.2
  BOTTOM w0.254: U8.M6 98,101.72 v2(98,101.67)
SPI_CLK_8M: length 5
  TOP w0.102: R2622.1 160.03,32.22 159.72,32.53 159.72,33.21 R2616.2 161.09,34.59 v1(161.09,34.93)
  BOTTOM w0.102: U2031.6 160.72,34.55 v1(161.09,34.93)
SPI_HOLD_IO3_ME: length 3.9
  TOP w0.102: R2625.2 R2624.1 162.24,34.44 v1(161.75,34.92)
  BOTTOM w0.102: 161.99,33.73 161.99,34.69 v1(161.75,34.92)
SPI_SI_8M: length 4.5
  TOP w0.102: R2617.2 158.05,32.29 158.54,32.79 R2611.1 158.78,33.16 v1(158.78,33.69)
  BOTTOM w0.102: U2031.5 159.45,33.05 159.26,32.86 158.78,32.86 v1(158.58,33.06) 158.58,33.5 v1(158.78,33.69)
SPI_SO_8M: length 4.8
  TOP w0.102: v1(160.16,28.36) 159.85,28.66 R2619.2 160.21,29.03 160.26,29.08 R2626.2
  BOTTOM w0.102: v1(160.16,28.36) 160.26,28.36 161.99,26.63 161.99,26.18
SPI_TPM_CS#: length 55.5
  TOP w0.102: R599.1 R586.1 121.12,21.54 v1(121.49,21.91)
  IN3 w0.089: v1(97.53,19.41) 98.09,19.41 98.73,18.77 102.92,18.77 103.69,19.54 118.29,19.54 120.19,21.44 120.86,21.44 121.33,21.91 v1(121.49,21.91)
  BOTTOM w0.102: U2030.AU1 78.23,35.69 79.39,34.53 79.65,34.27 79.65,32.67 80.53,31.79 80.53,30.52 81.82,29.22 81.82,28.46 84.77,25.51 89.14,25.51 89.7,24.95 90.61,24.95 94.7,20.86 94.7,20.67 95.01,20.35 95.95,20.35 96.43,19.87 97.07,19.87 v1(97.53,19.41)
SPI_WP_IO2_ME: length 5.8
  TOP w0.102: R2621.2 158.11,29.84 158.72,29.22 R2620.2 158.89,28.76 158.81,28.69 v1(158.81,28.43)
  BOTTOM w0.102: v1(158.81,28.43) 159.47,28.43 159.65,28.26 159.65,27.54 159.9,27.29 160.46,27.29 160.72,27.04 U2031.3
SRTC_RST#: length 46.9
  TOP w0.102: R2359.2 55.22,26.2 C2418.1 56.07,27.05 56.07,28.2 57.01,29.14 57.01,29.25 57.49,29.73 57.49,32.36 58.2,33.07 58.2,40.35 v1(58.36,40.51) 58.36,42.54 61.75,45.92 63.23,45.92 65.57,48.26 65.57,48.95 Q2013.3 66.21,48.13 66.94,47.41 68.74,47.41 68.97,47.64 77.03,47.64 78.07,46.6 80.38,46.6 v4(80.87,46.11)
  BOTTOM w0.102: U2030.AN18 80.46,45.7 v4(80.87,46.11)
STRAP0: length 7
  BOTTOM w0.102: R344.1 88.59,95.98 88.81,96.2 90.32,96.2 R353.2 92.44,96.76 93.28,95.92 93.84,95.92 U8.D1
STRAP1: length 7.8
  BOTTOM w0.102: U8.D2 94.87,95.43 94.5,95.06 94.22,95.06 93.67,95.6 93.27,95.6 92.67,96.2 91.33,96.2 R354.2 90.32,95.19 89.85,95.19 89.27,94.6 R345.1
STRAP2: length 9.6
  BOTTOM w0.102: R346.1 88.59,96.85 88.78,97.04 89.69,97.04 90,97.35 90.45,97.35 R355.2 91.78,97.78 93.41,96.15 93.94,96.15 94.16,95.94 96.39,95.94 U8.E4
STRAP3: length 9.1
  BOTTOM w0.102: U8.E3 95.45,96.76 94.22,96.76 93.95,96.49 93.5,96.49 91.2,98.79 R356.2 90.32,98.23 89.17,98.23 R347.1
STRAP4: length 10.5
  BOTTOM w0.102: U8.D3 95.76,95.43 95.39,95.06 94.88,95.06 94.67,94.85 94.67,94.49 94.47,94.29 94.19,94.29 94,94.47 93.28,94.47 93.06,94.69 93.06,95.13 92.65,95.54 92.21,95.54 91.32,94.65 91.32,94.15 90.88,93.7 R357.2 90.78,93.59 90.36,93.16 90.18,93.16 89.77,92.75 89.77,92.49 89.69,92.42 88.98,92.42 R348.1
STRAP5: length 7.4
  BOTTOM w0.102: R349.1 89.01,93.62 89.04,93.59 89.31,93.59 89.94,94.22 90.74,94.22 90.88,94.35 R358.2 91.94,95.79 92.72,95.79 93.24,95.27 93.65,95.27 94.29,94.63 U8.C1
SUSACK#_R: length 21.4
  TOP w0.079: v4(79.53,41.57) 79.1,42 78.17,42 78.04,41.87 76.74,41.87 76.1,41.23
  TOP w0.102: TP2042.1 61.2,37.96 63.18,37.96 63.49,38.26 63.82,38.26 64.12,38.57 65.14,38.57 65.7,38.01 66.75,38.01 67.31,38.57 71.33,38.57 73.2,40.44 75.31,40.44 76.1,41.23
  BOTTOM w0.114: U2030.AP11 79.81,41.86 v4(79.53,41.57)
SUSB#: length 151
  TOP w0.102: v2(190.94,23.91) 191.17,24.15 191.17,24.64 190.1,25.71 190.1,27.62 189.47,28.26 189.03,28.26 188.72,28.57 188.72,28.65 188.45,28.92 U37.119 ; U2014.1 110.54,30.83 110.65,30.72 110.65,29.88 110.37,29.6 110.37,27.74 109.36,26.73 v2(109.36,26.7)
  IN1 w0.089: v4(80.06,43.38) 79.84,43.17 79.84,42.35 79.56,42.06 77.13,42.06 76.85,41.79 76.85,39.43 76.95,39.33 76.95,38.24 77.99,37.2 77.99,37.04 78.98,36.04 82.49,36.04 83.32,35.22 83.32,31.41 83.81,30.92 85.63,30.92 85.66,30.95 85.86,30.95 86.53,31.61 87.53,31.61 88.19,32.27 93.32,32.27 94.21,31.38 94.67,31.38 94.77,31.48 94.77,31.78 95.29,32.29 99.72,32.29 102.18,29.83 102.28,29.83 102.48,29.64 103.87,29.64 104.18,29.33 104.18,28.96 105.57,27.57 105.57,27.37 106.44,26.5 106.95,26.5 106.98,26.54 108.51,26.54 108.68,26.7 v2(109.36,26.7) 109.36,26.68 109.67,26.36 115.84,26.36 116.38,25.82 121.12,25.82 123.93,23 126.2,23 126.73,22.48 146.48,22.48 146.97,22.97 154.03,22.97 154.18,23.12 160.99,23.12 161.76,23.89 163.37,23.89 164.86,22.39 167.06,22.39 167.42,22.03 176.8,22.03 177.58,22.81 181.18,22.81 183.05,20.93 184.97,20.93 185.37,20.54 187.86,20.54 188.06,20.74 188.09,20.74 188.18,20.83 188.18,21.16 v2(190.94,23.91)
  BOTTOM w0.102: v4(80.06,43.38) 80.06,43.59 U2030.AP15
SUSC#: length 183.9
  TOP w0.102: v1(174.94,25.26) 175.26,24.94 175.26,22.13 176.77,20.61 181.04,20.61 181.32,20.89 181.99,20.89 182.48,21.38 U37.18 ; v2(67.85,41.13) 67.52,41.46 66.59,41.46 64.91,39.79 64.6,39.79 64.53,39.71 63.08,39.71 62.33,38.96 60.88,38.96 60.11,38.19 60.11,32.98 58.84,31.71 58.84,28.74 59.6,27.98 60.77,27.98 60.95,27.8 60.95,27.62 v2(61,27.57)
  IN1 w0.089: v2(61,27.57) 61.58,26.99 62.01,26.99 63.29,25.71 63.29,23.15 64.04,22.4 64.04,21.46 65.41,20.09 66.99,20.09 67.74,19.34 81.24,19.34 83.59,21.69 88.03,21.69 88.83,21.69 93.55,16.97 100.61,16.97 101.91,15.66 109.85,15.66 110.73,16.54 118.21,16.54 119.59,15.16 174.24,15.16 v1(175.88,16.8)
  BOTTOM w0.102: v1(174.94,25.26) 175.4,24.8 177.48,24.8 178.75,23.53 178.75,19.57 179.53,18.79 179.53,17.98 178.75,17.21 178.75,16.9 178.32,16.47 176.21,16.47 v1(175.88,16.8) ; v2(67.85,41.13) 71.05,44.33 72.88,44.33 73.29,44.74 75.61,44.74 U2030.BA16
