# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V_S5_ON: length 93.9
  TOP w0.102: U37.95 198.15,27.78 197.93,27.55 197.93,27.24 195.61,24.92 v2(195.57,24.92)
  IN1 w0.089: v1(148.19,29.3) 148.19,29.81 147.81,30.19 145.53,30.19 144.87,29.53 143.19,29.53 141.91,30.81 138.35,30.81 137.91,31.25 137.91,31.78 135.72,33.96 133.72,33.96 133.17,34.51 131.68,34.51 131.05,33.89 125.07,33.89 123.04,35.92 v1(123.04,37.76)
  IN2 w0.089: v1(148.19,29.3) 149.07,28.41 153.73,28.41 153.88,28.57 153.88,28.87 154.12,29.11 155.62,29.11 157.56,31.06 162.1,31.06 162.43,30.72 162.43,30.57 163.48,29.52 165.29,29.52 165.78,30.02 167.75,30.02 167.93,30.19 172,30.19 172.61,29.58 176.55,29.58 176.95,29.18 179.86,29.18 180.2,29.52 183.33,29.52 183.7,29.15 187.49,29.15 188.72,27.92 189.62,27.92 190.67,26.88 191.66,26.88 193.66,24.88 195.53,24.88 v2(195.57,24.92)
  BOTTOM w0.102: PR274.2 122.26,42.02 122.85,41.44 122.85,37.95 v1(123.04,37.76)
+1V_SUS: length 58.7
  TOP w0.508: PQ11.1 121.83,64.81 v1(121.96,64.68) 121.88,64.61 121.27,64.61 121.05,64.38 121.05,63.81 120.74,63.5 120.74,63.46 120.56,63.29 120.56,62.71 120.8,62.47 PC83.2 121.6,62.34 122.03,61.91 122.03,53.73 121.65,53.35 121.12,53.35 119.57,51.8 119.57,50.46 120.55,49.47 PR105.1 121.34,49.47 122.56,48.25 122.56,46.16 122.01,45.6 120.66,45.6 119.85,46.42 115.12,46.42 114.04,47.5 112.7,47.5 112.29,47.9 R2506.1 111.66,47.87 R2499.1
  IN1 w0.508: v1(139.64,60.44) 138.88,59.68 137.37,59.68 136.93,60.12 135.32,60.12 134.82,59.62 133.73,59.62 131.21,62.14 130.21,62.14 128.2,64.15 122.49,64.15 v1(121.96,64.68)
+1V_VCCST: length 64.2
  TOP w0.279: v4(98.16,45.7) 98.91,46.44 101.1,46.44 101.42,46.13 C2579.2 102.64,46.13 102.9,45.87 C20023.2 ; v1(108.67,44.4) 107.91,44.4 107.4,44.91 106.48,44.91 106.26,44.69 105.37,44.69 104.99,45.07 104.49,45.07 C20023.2 ; C20023.2 104.39,46.57 104.39,47.77 v1(105.09,48.47)
  TOP w0.508: v1(108.16,47.94) 108.24,47.87 R2499.2
  IN1 w0.508: v1(105.09,48.47) 105.35,48.73 106.31,48.73 107.02,48.02 107.07,48.02 107.1,47.99 108.12,47.99 v1(108.16,47.94)
  IN3 w0.508: 109.89,45.17 109.89,46.37 109.59,46.67 109.59,48.72 106.25,52.05 105.76,52.05 104.91,52.89 103.85,52.89 103.44,53.3 103.44,56.94 102.53,57.85 102.53,60.58 103.84,61.89 104.48,61.89 105.8,63.21 105.8,65.28 104.28,66.8 104.28,67.6 v1(104.15,67.73)
  BOTTOM w0.254: U2030.A18 97.89,45.97 v4(98.16,45.7)
  BOTTOM w0.279: 102.59,75.65 102.17,76.07 102.17,76.82 102.83,77.48 102.83,80.61 102.42,81.01 100.95,81.01 100.64,80.7 R2229.2
  BOTTOM w0.305: U2029.5 102.98,71.63 102.67,71.32 R2479.1 102.22,71.58 102.84,72.19 105.9,72.19 105.99,72.28 R2478.2
+2.5V_SUS: length 104.3
  IN1 w1.016: 47.54,54 46.8,54.75 46.8,55.38 47.54,56.13 47.54,57.89 46.9,58.53 46.9,59.65 ; 26.09,105.37 27.48,106.76 37.01,106.76 39.53,109.28 39.53,112.43 38.47,113.5 38.47,114.72 39.84,116.09 41.48,116.09 42.86,114.71 49.08,114.71 49.13,114.66 60.49,114.66 61.73,113.42 64.84,113.42 67.98,116.56 67.98,117.21
  IN2 w0.508: 31.48,96.86 44.42,96.86 v1(45.18,96.1)
  BOTTOM w0.508: v2(48.93,81.08) 48.93,76.16 48.53,75.75 47.69,75.75 46.42,74.48 46.42,73.67 46.7,73.39 46.7,68.87 45.15,67.32 45.15,65.01 47.08,63.08 v2(47.08,60.72)
  BOTTOM w1.016: 33.14,41.97 33.14,39.87 32.42,39.15 32.42,36.02
  vias: v1(24.46,103.74) v1(24.94,104.17) v1(30.75,96.96) v1(30.72,96.33) v1(30.69,84.37) v1(30.7,83.71) v1(34.56,34.23) v1(34.94,33.69) v1(47.12,32.96) v1(47.13,32.33) v1(56.12,30.14) v1(56.63,30.67) v1(70.12,118.88) v1(70.27,118.25) v2(30.6,52.06) v2(30.62,51.04) v2(30.74,71.19) v2(30.74,70.51) v2(46.36,60.73) v2(46.37,46.16) v2(46.92,45.74)
+3V: length 375.3
  TOP w0.254: v1(203.16,11.11) 201.74,11.11 201,11.85 ; R25465.1 60.22,107.99 v1(60.23,107.99) ; R2281.1 65.04,35.9 v2(64.55,35.9) ; Q41.2 24.95,66.66 v1(25.03,66.74) ; PR6416.1 164.17,29.75 v1(163.88,30.05) ; Q41.5 24.95,62.75 24.75,62.55 v1(23.58,62.55) ; PR9255.1 44.97,28.96 v1(45.07,29.07) ; R2615.1 61.7,36.67 62.1,37.07 R2301.1 v2(64.55,37.07) R2612.1 ; R25502.2 40.24,110.32 40.09,110.48 40.09,113.37 v1(40.04,113.42) ; R378.2 201.75,15.45 201.75,13.82 201.58,13.65 201.58,12.43 201,11.85 ; R2278.1 65.14,34.71 v1(64.55,34.71) 64.45,34.81 R2286.1 ; U6505.5 118.88,125.35 119.51,124.72 C20006.2 119.94,125.13 v1(120.08,125.13) ; 201,11.85 R340.2 ; R2604.2 99.89,29.98 v1(99.91,30) ; v2(86.78,101.43) 86.88,101.34 R25558.2 ; R460.2 202.04,27.54 201.97,27.54 v2(201.56,27.95) 200.97,28.54 R741.1 ; R1239.2 205.57,11.15 v1(205.55,11.17) ; U2019.5 63.91,31.81 64.16,32.07 64.35,32.07 64.56,32.27 C2369.2 64.63,32.02 64.63,31.48 v1(64.73,31.38)
  TOP w0.381: R25312.2 169.51,27.16 v1(169.45,27.11) ; R638.2 v1(130.49,16.52) ; v1(74.95,34.09) 74.95,33.1 77.04,31.01 77.04,24.74 77.61,24.17 77.61,22.06 ; R25474.1 87.9,33.14 v1(87.07,33.97) ; v1(135.85,20.36) 135.85,19.92 138.74,17.03 v1(139.46,17.03) ; v1(32.93,24.04) 32.32,23.43 32.32,21.75 32.6,21.47 39.58,21.47 40.04,21.93 43.32,21.93 44.41,23.02 45.25,23.02 46.82,21.45 R582.1 ; v1(114.21,14.77) 113.23,15.75 113.23,22.31 113.8,22.88 113.8,24.62 v1(114.21,25.03)
  TOP w0.508: R2282.1 64.36,24.06 64.3,24.12 v1(64.3,24.75) ; v1(132.52,20.1) 132.43,20.01 R25346.1 ; R2274.1 53.24,31.39 53.54,31.09 R2269.2 54.01,29.96 53.05,28.99 v1(53.05,28.43) 52.94,28.43 52.67,28.15 R2273.1 ; v1(97.81,125.91) 98.26,125.46 R385.1 ; v1(130.49,16.52) 130.72,16.75 R25348.2
  IN1 w0.381: v1(97.81,125.91) 99.03,124.69 v1(101.42,124.69)
  IN1 w0.508: v1(45.38,31.53) 45.02,31.89 45.02,33.44 45.86,34.28 48.07,34.28 48.59,34.8 48.59,42.64 45.6,45.63 45.6,47.41 48.65,50.46 v2(48.91,50.46)
  IN2 w0.254: v1(101.97,68.67) 101.97,74.66 102.22,74.92 102.22,75.6 101.5,76.32 101.5,77.98 100.98,78.5 100.98,79.53 101.43,79.99 101.43,82.21 99.36,84.28 98.84,84.28 98.07,85.05 96.73,85.05 96.24,85.55 94.95,85.55 92.47,88.03 88.57,88.03 85.86,90.74 84.52,90.74 83.12,92.14 v2(83.12,92.73) ; v2(203.95,26.73) 204,26.73 204.7,26.03 204.7,24.9 207.15,22.45 207.15,19.91 206.77,19.53 206.77,15.94 207.22,15.48 207.22,13.33 207,13.1 207,12.62 v1(205.55,11.17)
  IN2 w0.381: v1(119.75,40.68) 120.13,40.29 120.13,33.88 119.54,33.28 115.15,33.28 113.25,31.39 v1(113.25,30.47) ; v1(63.28,124.62) 70.91,124.62 72.93,122.6 85.34,122.6 88.79,119.15 90.68,119.15 v1(91.09,118.74) ; v1(101.42,124.69) 101.8,124.3 101.8,123.06 101.53,122.8 101.53,121.78 103.31,120 v1(104.61,120) 104.81,120 105.5,120.68 105.5,121.69 106.81,123 106.81,123.76 108.17,125.13 v1(120.08,125.13)
  IN2 w0.508: v1(53.05,28.43) 52.28,27.67 52.28,26.12 53.61,24.8 54.19,24.8 55.84,23.15 62.11,23.15 63.71,24.75 v1(64.3,24.75) ; v1(132.52,20.1) 132.52,20.84 133.06,21.37 133.69,21.37 134.7,20.36 v1(135.85,20.36)
  IN3 w0.381: v1(91.09,118.74) 94.09,118.74 96,120.66 96,123.16 97.81,124.97 v1(97.81,125.91)
  BOTTOM w0.203: R2549.2 74.89,32.24 R2555.1 ; R2483.2 102.9,68.67 v1(101.97,68.67) ; v1(143.15,59.42) 143.44,59.13 PR7068.1
  BOTTOM w0.254: v2(64.55,37.07) v2(64.55,35.9) v1(64.55,34.71) 64.5,34.66 64.5,31.61 v1(64.73,31.38) ; v1(102.86,29.09) 102.86,28.5 R2610.2 ; R2554.1 69.32,32.88 v1(69.1,32.65) ; v2(201.56,27.95) 201.21,27.6 R742.1 ; R2533.2 98.91,32.83 v1(98.91,33.5) ; PR9075.1 75.36,103.12 74.03,101.78 74.03,100.11 73.67,99.76 73.67,98.69 73.82,98.54 v2(73.82,98.18) ; R25537.2 87.56,99.44 86.68,98.56 86.68,98.44 86.18,97.94 86.14,97.94 ; v1(104.61,120) 104.46,119.86 104.46,119.49 103.83,118.86 C452.2 102.56,119.45 U11.5 ; v1(101.42,124.69) 101.55,124.56 103.35,124.56 104.03,123.87 R25519.2 ; v1(142.48,68.41) 142.58,68.52 PR9088.1 ; v1(80.66,33.43) 80.51,33.28 R2603.1 ; R134.2 97.37,26.01 99.23,26.01 99.68,26.46 99.68,27.92 100.21,28.45 R2614.2 100.28,29.09 99.91,29.47 v1(99.91,30) 99.91,30.18 100.16,30.43 Q2026.5 ; v1(103.26,30.08) 102.91,30.43 Q2026.2 ; PR275.1 v1(119.75,40.68) ; R25548.2 83.63,92.73 v2(83.12,92.73) ; R2542.1 v1(93.28,31.61) 93.26,31.59 R2557.1 R2544.1
  BOTTOM w0.305: v2(201.92,29.17) 200.66,29.17 200.29,29.53 200.29,29.53 200.25,29.58 R452.2
  BOTTOM w0.381: R2549.2 74.62,33.06 74.95,33.39 v1(74.95,34.09) ; R732.2 205.56,27.16 205.07,27.65 v2(205.07,27.77) ; R641.2 135.37,20.84 v1(135.85,20.36) ; PR9075.1 75.37,103.21 76.08,103.91 v1(76.19,103.91) ; 130.49,15.35 v1(130.49,16.52) ; 130.49,15.35 130.95,14.9 136.94,14.9 138.06,16.01 138.85,16.01 139.46,16.62 v1(139.46,17.03) 139.46,18.6 140.13,19.27 R25475.2 ; 130.49,15.35 130.03,14.9 128.1,14.9 127.24,15.76 126.12,15.76 125.26,14.9 114.87,14.9 114.74,14.77 v1(114.21,14.77)
  BOTTOM w0.508: v1(19.21,74.59) 19.96,74.59 ; v1(45.07,29.07) 45.07,30.11 45.38,30.42 v1(45.38,31.53) ; v1(43.14,111.42) 42.51,112.05 42.33,112.05 41.55,112.82 40.64,112.82 v1(40.04,113.42) 39.08,114.39 R25486.2 ; v1(91.09,118.74) 91.15,118.69 91.79,118.69 R386.2
  vias: v1(19.59,87.21) v1(22.49,75.07) v1(23.06,74.77) v1(23.07,74.13) v1(23.51,73.67) v1(23.84,84.06) v1(23.93,8.71) v1(24.32,86.52) v1(24.32,85.89) v1(24.29,84.54) v1(24.56,9.35) v1(24.56,8.71) v1(25.2,9.35) v1(25.2,8.71) v1(28,30.82) v1(28.54,29.45) v1(28.64,31.38) v1(28.64,30.75) v1(28.64,30.08) v1(51.19,105.78) v1(53.38,104.63) v1(58.63,110.78) v1(59.02,103.34) v1(59.65,103.34) v1(83.57,97.62) v1(83.58,96.93) v1(84.16,97.19) v1(149.49,29.96) v1(149.49,29.32) v1(150.13,29.96) v1(150.13,29.32) v1(150.76,29.96) v1(150.76,29.32) v1(151.4,29.96) v1(151.4,29.32) v1(214.62,32.68) v1(215,32.07) v1(215.17,31.38) v1(215.25,32.65) v1(215.63,32.02) v2(178.72,28.05) v2(179.36,28.05) v2(195.49,28.34) v2(195.46,27.76) v2(209.69,26.86) v2(209.69,26.28)
+3V3_TPM: length 22.1
  TOP w0.254: U33.22 122.53,19.71 121.98,19.16 121.98,19.13 121.96,19.1 121.96,18.98 C741.1 C744.1
  TOP w0.381: v1(120.79,20.13) 120.79,19.18 C744.1
  TOP w0.508: C740.2 130.2,24.84 129.91,25.14 126.45,25.14 125.56,26.02 124.68,26.02
  IN2 w0.508: v1(120.79,20.13) 120.79,20.56 121.3,21.07 122.01,21.07 123.25,22.31 130.34,22.31 130.85,22.82 v1(130.85,23.07)
+3V3_TPM_VSB:
  vias: v1(131.61,17.97)
+3V3AUX: length 23.4
  TOP w0.381: C386.2 103.71,98.24 C380.2 C375.2 102.47,98.11 102.93,97.65 v2(102.93,97.52)
  IN1 w0.381: 102,93.89 102,92.24 102.78,91.46 v1(102.78,91.01)
  IN2 w0.381: v1(102.78,91.01) 103.25,91.01 106.06,88.21 108.42,88.21 108.98,87.65 112.9,87.65 114.46,86.09 114.46,85.76 v1(114.51,85.72)
  BOTTOM w0.381: L4.2 113.37,84.43 113.9,84.97 113.9,85.24 114.15,85.48 114.27,85.48 v1(114.51,85.72) ; U8.F11 102.93,97.45 v2(102.93,97.52)
+3V_DMIC: length 3.9
  BOTTOM w0.508: R25486.1 38.31,115.44 37.6,114.73 v1(37.25,114.73) 37.21,114.73 36.3,115.65 CN38.4
+3V_EC: length 6.3
  TOP w0.203: U37.11 182.31,24.18
  TOP w0.254: R25307.2 180.24,26.71 179.55,26.02 R25317.2 179.55,25.52 180.39,24.69 v1(180.6,24.69) 181.49,24.69 181.77,24.41 C1189.1 181.83,24.18 182.31,24.18
+3V_GFX_+1V8_GFX_MAIN: length 187.8
  TOP w0.203: v2(107.07,83.6) 107.05,83.58 105.84,83.58 R25581.2 105.84,84.06 107.76,84.06 108.01,84.31 108.77,84.31 109.29,84.83 R25576.2 R25575.1
  TOP w0.305: R25582.1 104.23,86.35 103.8,86.78 103.8,87.63 v2(103.99,87.82) 103.61,87.82 103.24,88.19 R25583.1
  TOP w0.381: v1(73.56,116.27) 73.29,116.27 72.89,116.67 PR25542.1
  TOP w0.508: v1(86.55,93.28) 85.4,93.28 84.79,93.89 84.14,93.89 83.15,94.88 82.74,94.88 82.36,95.26 v1(81.49,95.26)
  TOP w0.762: 95.61,125.1 95.25,124.74 95.25,121.36 v3(94.52,120.63) 94.79,120.36 94.79,119.47 94.29,118.96 93.89,118.96 92.54,117.61 92.54,114.28 89.87,111.61 88.51,111.61 87.68,110.78 87.68,109.62 87.54,109.49
  TOP w1.016: 86.57,103.72 85.51,102.65 82.51,102.65 81.49,101.64 81.49,96.46
  IN1 w0.305: v2(103.99,87.82) 103.85,87.68 103.85,86.56 105.6,84.81 106.29,84.81 107.07,84.03 v2(107.07,83.6) 107.35,83.6 107.66,83.3 107.66,82.39 107.04,81.77 105.94,81.77 104.77,82.94 100.45,82.94 98.09,85.3 97.89,85.3 97.49,85.69 v1(97.35,85.69)
  IN1 w0.762: v3(98.05,122.39) 98.05,122.46 98.11,122.51 98.11,123.91 96.36,125.66 v3(96.2,125.66)
  IN1 w1.016: 23.51,99.66 24.52,98.64 28.38,98.64 28.94,99.2 39.41,99.2 40.75,97.85 44.7,97.85 46.47,99.62 48.33,99.62 49,100.29 52.39,100.29 53.38,101.28 57.21,101.28 ; 63.23,100.9 63.87,100.27 67.63,100.27 68.58,99.31 74.31,99.31 74.98,98.64 78.61,98.64 80.68,96.57
  IN2 w0.508: v1(97.35,85.69) 97.02,85.69 96.06,86.65 94.74,86.65 92.68,88.72 89.13,88.72 v1(88.86,88.99) 88.61,88.99 88,89.59 88,91.83 v1(86.55,93.28)
  IN3 w0.508: v1(73.56,116.27) 73.56,114.05 74.39,113.22 74.86,113.22 75.76,112.31 75.76,108.41 76.59,107.58 77.47,107.58 79.35,105.71 83.17,105.71 83.6,105.28 83.6,103.77 83.99,103.38 85.98,103.38 86.42,103.81 87.83,103.81 v1(88.4,104.38)
  BOTTOM w0.305: R25588.1 86.25,92.98 v1(86.55,93.28) ; R25538.1 88.38,104.35 v1(88.4,104.38) ; L4.1 113.22,87.24 112.62,87.84 108.1,87.84 107.95,87.99 104.16,87.99 v2(103.99,87.82)
  BOTTOM w0.381: R25563.2 95.12,120.03 v3(94.52,120.63) ; v1(104.78,124.81) 105.01,124.81 105.25,124.56 R25564.2 ; R25522.1 98.12,122.46 v3(98.05,122.39)
  BOTTOM w0.508: R25566.1 96.3,86.24 96.86,85.69 v1(97.35,85.69) ; R25547.2 88.35,88.38 88.86,88.89 v1(88.86,88.99)
  vias: v1(22.06,100.34) v1(22.06,99.71) v1(81.01,95.74) v3(123.32,120.64)
+3V_LAN:
  vias: v1(41.84,107.33) v1(42.2,107.86) v1(43.67,102.37) v1(48.12,110.4) v1(48.75,110.32) v1(49.29,108.61)
+3V_LDO_EC: length 87.4
  TOP w0.254: R369.2 192.56,32.44 R361.2 192.57,33.41 v2(192.62,33.46)
  TOP w0.381: v1(163.94,34.48) 164.53,33.9 R2630.2 ; R25306.1 175.76,19.42 172.79,22.39 172.79,24.04 172.53,24.3 172.53,27.94 172.44,28.03 172.44,31.49 172.88,31.94 v1(172.88,32.5) ; v1(174.5,26.53) 174.88,26.15 R359.1 175.69,26.03 176.21,25.51 176.45,25.51 177.23,24.73 D63.1 177.23,23.98 R25300.2
  IN1 w0.381: v1(146.75,36.88) 146.75,36.1 147.17,35.69 147.85,35.69 148.52,36.36 149.01,36.36 149.68,35.69 153.97,35.69 154.52,36.23 159.35,36.23 159.96,35.62 162.09,35.62 162.81,34.9 163.52,34.9 v1(163.94,34.48) 165.48,34.48 166.57,33.39 172,33.39 v1(172.88,32.5) 173.77,33.39 182.92,33.39 185.53,33.74 187.16,34.02 189.06,34.43 191.65,34.43 v2(192.62,33.46) 193.08,33.46 v2(193.61,32.93)
  BOTTOM w0.254: 195.36,30.36 197.01,30.36 R25313.2
  BOTTOM w0.381: v1(146.75,36.88) PR6017.2 ; v1(172.88,32.5) 173.85,31.53 173.85,29.86 174.5,29.21 v1(174.5,26.53)
+3V_MAIN_1V8_AON: length 142.7
  TOP w0.203: PR9009.1 73.85,105.82 v1(73.74,105.71)
  TOP w0.254: 108.19,82.1 108.44,81.84 109.1,81.84 109.27,82.02 R25574.1 R25577.2 ; 108.19,82.1 108.19,83.09 108.53,83.43 R25322.2 ; 108.19,82.1 108.18,82.1 108.03,81.94 107.34,81.94 107.19,82.09 107.19,82.9 v2(107.07,83.02) ; R25567.1 88.67,103.03 v2(89.28,103.03) ; v2(103.84,88.39) 104.06,88.39 104.47,87.99 R365.1 105.47,87.99 R25580.2 106.11,87.35 106.11,86.59 105.88,86.35 R362.1
  IN1 w0.254: v2(103.84,88.39) 103.8,88.39 103.32,87.91 103.32,86.34 105.38,84.28 106.07,84.28 106.46,83.88 106.46,83.48 ; 106.46,83.48 100.76,83.48 97.76,86.47 v1(97.34,86.47) ; 106.46,83.48 106.46,83.31 106.75,83.02 v2(107.07,83.02)
  IN1 w0.508: 68.01,101.71 69.4,100.32 74.73,100.32 75.4,99.66 79.34,99.66 80.02,98.97 84.03,98.97 84.65,98.35 86.5,98.35 v1(87.08,97.78)
  IN1 w1.016: 40.8,99.71 43.75,99.71 45.65,101.61 45.65,101.73 46.94,103.01 48.72,103.01 49.1,103.4 51.84,103.4 52.55,102.68 56.63,102.68 57.64,103.69
  IN2 w0.508: v1(97.34,86.47) 96.4,87.41 v1(95.44,87.41) 95.06,87.41 92.99,89.48 90.17,89.48 89.34,90.31 89.34,91.6 87.95,93 87.95,96.91 v1(87.08,97.78)
  IN2 w1.016: 71.5,116.81 71.5,120.09 73.06,121.65 84.95,121.65 88.5,118.1 89.14,118.1
  BOTTOM w0.254: PR9076.2 86.42,88.28 86.96,87.74 89.77,87.74 90.52,86.99 91.76,86.99 92.02,87.24 R25540.2 ; v2(89.28,103.03) 89.55,103.03 90.23,102.35 90.23,100.96 R25535.1 90.1,100.6 89.31,99.81 89.14,99.81 88.89,99.55 88.89,99.4 88.63,99.15 88.17,99.15 87.81,98.78 R25579.1
  BOTTOM w0.381: R25579.1 87.08,97.91 v1(87.08,97.78) ; R297.2 96.63,122.46 97.22,122.46 v1(97.28,122.52) 97.28,122.19 97.73,121.74 99.77,121.74 100.51,122.48 R25520.2
  BOTTOM w0.508: v1(73.74,105.71) 73.74,105.86 72.9,106.7 68.01,106.7 ; R330.2 98.23,86.98 97.72,86.47 v1(97.34,86.47) 97.27,86.55 97.27,87.1 R25565.1 ; R25540.2 93.03,87.49 R25553.1 R364.1 94.66,87.73 94.98,87.41 v1(95.44,87.41)
  vias: v1(26.85,99.81) v1(27.34,100.37) v1(67.12,113.09) v1(67.3,102.35) v1(67.63,112.71) v1(67.93,102.35) v1(97.31,123.21)
+3V_PCH_ME: length 0.9
  TOP w0.254: R2620.1 158.89,29.84 159.26,30.22 v1(159.26,30.47)
  vias: v1(163.09,31.12) v1(163.72,31.12) v1(164.11,33.22)
+3V_RTC: length 179.8
  TOP w0.635: v1(50.75,25.16) 50.65,25.06 R2360.1 50.65,23.72 51.27,23.1 54.29,23.1 v1(55.09,23.9) 55.73,24.55 56.09,24.55 56.53,24.98 56.83,24.98 56.86,25.01 57.03,25.01 57.52,25.49 57.52,28.36 58.16,29.01 58.16,32.08 59.13,33.05 59.13,39.62 60.34,40.83 61.31,40.83 ; R2359.1 53.61,26.2 53.57,26.16 52.49,26.16
  IN2 w0.381: v1(65.24,108.83) 64.95,109.11 61.25,109.11 60.79,109.57 55.5,109.57 54.62,110.45 52.96,110.45 52.77,110.64 50.92,110.64 49.4,109.12 47.03,109.12 46.32,108.41 41.55,108.41 40.73,107.58
  IN2 w0.762: 19.98,28 19.21,28.77 19.21,32.88 19.82,33.49 19.82,36.61 18.22,38.21 18.22,43.67 17.11,44.79 17.11,45.67 16.33,46.44 16.33,49.76 16.88,50.3 16.88,51.35 16.42,51.81 16.42,52.54 17.94,54.07 17.94,55.71 18.58,56.35 19.87,56.35 20.28,56.76 20.28,56.78 21.32,57.82 21.32,62.29 22.36,63.33 22.36,69.77 21.75,70.38 21.75,70.77 19.51,73.02 19.28,73.17 19.11,73.17 17.33,74.94 17.33,80.86 17.99,81.52 17.99,83.73 17.33,84.39 17.33,89.18 17.19,89.33 17.19,90.46 19.18,92.45 19.18,93.66 21.28,95.76 21.28,97.26 20.56,97.98 20.56,101.98 24.97,106.39 37.6,106.39 38.38,107.17 ; 36.6,27.75 43.75,27.75 45.03,26.47 49.98,26.47 50.75,25.7 v1(50.75,25.16)
  BOTTOM w0.381: R25310.1 64.86,105.24 64.2,105.9 64.2,106.44 65.52,107.76 65.52,108.55 v1(65.24,108.83)
+3V_RTC_1: length 2.2
  TOP w0.102: 49.49,24.54 v1(49.51,24.52)
  TOP w0.508: 49.49,24.54 49.29,24.73 R2378.2 48.7,25.43 D2012.1
+3V_RTC_2: length 3.1
  TOP w0.508: R2357.1 47.98,26.21 47.99,26.22 R2358.2 ; v1(47.16,26.8) 47.97,26.8 R2358.2 ; R2358.2 48.34,26.82 48.69,27.18 D2012.2
+3V_S5: length 384
  TOP w0.254: 91.13,26.7 Q27.2 ; v1(74.43,81.04) 71.79,83.68 68.77,83.68 66.99,85.46 66.99,91.41 68.51,92.94 68.51,96.76 v1(68.46,96.81) ; R25415.1 94.3,30.15 94.3,27.89 94.6,27.59 v1(94.6,26.75) 94.55,26.7 Q27.5 ; R2595.2 90.38,29.35 90.1,29.06 R2594.2 90.1,27.95 ; 99.25,29.6 99.25,30.09 99.33,30.17 R2589.2 R2590.2 ; R383.2 R25304.2 189.98,32.73 189.71,32.99 v2(189.71,33.28) ; v2(69.28,39.32) 67.23,39.32 v2(66.51,38.59) 65.96,38.59 R2225.1 65.4,39.15 v2(64.96,39.15) ; v1(101.2,29.11) 101.14,29.17 101.14,32.49 99.43,34.19 98.22,34.19 R2607.1 ; v1(27.16,15.52) 26.93,15.74 R25586.1 ; v2(65.73,41.53) 64.73,40.53 64.35,40.53 64.02,40.2 62.78,40.2 62.65,40.07 61.33,40.07 61.06,39.8 R38.2
  TOP w0.381: v1(99.62,28.75) 99.25,29.13 99.25,29.6 98.2,29.6 R2598.2 97.34,29.75 R2562.2 ; v1(177.46,25.46) 177.86,25.87 R25317.1 177.4,26.82 R25330.1 ; 85.61,24.17 84.42,24.17
  TOP w0.508: v1(62.33,28.37) 63.04,27.66 R2303.1
  IN1 w0.508: v1(22.49,20.25) 22.49,17.69 22.82,17.36 v1(22.86,17.36)
  IN2 w0.254: v1(27.98,91.38) 30.2,93.6 30.2,95.1 31.33,96.23 37.32,96.23 38.37,95.19 45.5,95.19 46.14,95.82 46.14,96.61 46.9,97.37 49.16,97.37 50,98.21 51.68,98.21 52.54,99.07 61.5,99.07 61.52,99.09 65.6,99.09 67.88,96.81 v1(68.46,96.81) ; v1(99.62,28.75) 100.85,28.75 v1(101.2,29.11)
  IN2 w0.381: 24.19,12.94 24.9,12.94 26.03,14.08 26.03,14.71 26.85,15.52 v1(27.16,15.52) ; 24.19,12.94 23.19,13.94 23.19,16.56 22.86,16.89 v1(22.86,17.36) ; 24.19,12.94 24.19,11.42 24.82,10.79 v1(25.35,10.79)
  IN2 w0.508: v1(9.55,23.18) 10.05,23.68 11.95,23.68 12.08,23.56 12.79,23.56 14.53,21.81 17.51,21.81 17.83,21.49 21.24,21.49 v1(22.49,20.25) 22.49,20.6 23.5,21.62 24.84,21.62 25.07,21.84 25.95,21.84 26.6,21.19 v1(26.6,21.04) 27.19,21.04 28,21.84 30.64,21.84 31.19,22.39 v1(33.49,22.39) ; v1(45.83,27.55) 46.34,28.05 47.74,28.05 48.73,29.04 52.17,29.04 52.54,29.41 53.31,29.41 53.76,29.86 54.59,29.86 55.87,28.59 58.46,28.59 58.84,28.21 61.48,28.21 61.64,28.37 v1(62.33,28.37) 62.61,28.09 64.93,28.09 66.37,29.53 66.82,29.53 68.11,30.82 v1(68.11,31.58)
  IN3 w0.254: v1(103.26,39.05) 103.26,37.75 v1(103.27,37.74) 103.29,37.73 103.29,37.3 103.29,35.87 104.33,34.83 v1(104.33,33.4)
  IN3 w0.381: v1(162.06,22.21) 162.22,22.06 176.13,22.06 177.01,22.93 177.01,25.02 v1(177.46,25.46)
  IN3 w0.762: 33.23,33.95 30.8,36.39 30.8,36.43 29.4,37.83 28.81,37.83 23.89,42.74 23.89,52.51 22.65,53.75 22.65,55.11 24.18,56.64 24.18,59.52 24.85,60.19 24.85,63.31 24.21,63.95 24.21,71.92 21.75,74.38 21.75,75.88 21.19,76.44 20.43,76.44 19.26,77.6 19.26,80.68 20.41,81.82 20.41,83.22 19.81,83.82 19.81,86.03 21.12,87.34 21.12,89.98 21.8,90.66 21.8,92 20.74,93.06 v1(20.74,93.28) 20.74,93.98 21.37,94.61 21.37,95.98 21.96,96.57 21.96,98.21 22.7,98.95 23.89,98.95 28.26,103.31 29.12,103.31 29.88,104.07 32.85,104.07 34.11,105.33 35.9,105.33 40.09,109.52 40.09,110.91
  BOTTOM w0.203: v1(68.11,31.58) 68.51,31.99 R2551.2
  BOTTOM w0.254: v1(22.86,17.36) 22.32,17.89 R6510.1 22.3,18.01 21.52,18.79 R6508.1 ; v1(26.6,21.04) 27.78,21.04 28,20.81 28,20.31 28.13,20.18 28.13,19.54 27.88,19.3 R6505.1 27.88,18.42 R6504.1 ; v2(65.73,41.53) 65.62,41.42 65.62,40.46 R2516.1 ; R2573.2 R2574.2 90.28,29.04 90.38,28.94 90.38,28.89 90.41,28.87 90.41,26.48 v2(90.51,26.38) ; v1(27.98,91.38) 26.4,92.95 21.07,92.95 v1(20.74,93.28) ; 103.03,32.39 102.92,32.5 101.54,32.5 R2571.1 ; R2516.1 66.4,39.69 R2519.2 ; R2516.1 65.37,39.15 v2(64.96,39.15) 63.87,38.06 63.87,34.42 63.94,34.35 63.94,31.19 64.22,30.91 64.22,29.58 63.79,29.15 63.1,29.15 v1(62.33,28.37) ; R2448.2 71.64,80.86 72.3,81.52 73.95,81.52 v1(74.43,81.04) ; R2605.1 102.64,27.76 v1(102.36,27.49) ; R2536.1 67.28,35.48 67.93,36.13 67.93,36.28 69.28,37.63 v2(69.28,39.32) ; v1(177.46,25.46) 176.9,26.02 175.58,26.02 175.07,26.53 175.07,29.45 174.59,29.93 174.59,31.53 176.69,33.64 186.5,33.64 186.57,33.72 188.38,33.72 188.96,34.3 189.39,34.3 189.65,34.04 189.65,33.34 v2(189.71,33.28) ; v1(99.62,28.75) 99.45,28.93 99.45,29.72 99.3,29.87 R2606.1 ; R2518.2 v2(66.51,38.59) ; CN33.1 v1(76.32,20.14)
  BOTTOM w0.381: R6515.1 25.82,11.25 v1(25.35,10.79) 24.78,10.79 R6516.1
  BOTTOM w0.508: v1(26.6,21.04) 26.82,20.81 R6506.1 ; Q6505.2 v1(9.55,23.18)
  vias: v1(34.4,33.13) v1(34.86,32.68) v1(40.68,112.18) v1(40.7,111.52) v1(45.2,27.55) v1(47.33,113.47) v1(47.33,112.84) v1(49.64,113.65) v1(64.53,123.23) v1(64.94,24.75) v1(68.62,20.13) v1(69.25,20.13) v1(92.01,25.46) v1(99.17,22.57) v1(99.53,23.13) v1(99.81,22.54) v1(103.92,32.9) v1(159.32,22.37) v1(159.95,22.37) v1(162.1,23.06) v2(86.17,27.62) v2(86.73,27.8) v2(195.43,15.94) v2(196.02,15.94)
+3V_SSD: length 10.8
  BOTTOM w0.305: CN16.12 37.1,3.28 37.1,3.29 ; CN16.72 22.1,2.89 v1(21.88,3.29) 21.6,2.83 CN16.74 ; 36.13,3.24 36.1,3.21 CN16.16 ; CN16.2 39.6,3.27 39.58,3.29 ; CN16.4 39.1,3.16 39.08,3.19 ; v1(22.64,3.31) 22.6,3.09 CN16.70 ; CN16.18 35.6,3.22 35.62,3.24 ; 36.59,3.19 36.6,3.17 CN16.14
  vias: v1(22.24,3.9) v1(22.57,4.51) v1(22.9,3.9) v1(35.19,3.69) v1(35.93,3.69) v1(36.66,3.67) v1(38.44,3.29) v1(39.08,3.64)
+3V_WLAN_P: length 22.4
  TOP w0.254: C804.1 195.41,12.35 v2(195.63,12.13) v2(196.21,12.13)
  IN3 w0.254: 195.06,20.53 196.68,20.53 196.94,20.28 197.7,20.28 198.04,20.63 198.04,22.01 198.13,22.1 198.13,22.41 199.63,23.91 v2(200.06,23.91)
  BOTTOM w0.305: R672.2 194.35,19.56 194.35,20.31 R671.2 194.38,20.79 v2(194.7,20.79)
  BOTTOM w0.381: R652.1 R651.1 173.14,14.64 171.33,16.45 v1(171.33,17.13)
  vias: v2(194.09,26.61) v2(194.68,26.61) v2(200.62,13.27) v2(201.1,12.94)
+3VLCD_CON:
  vias: v1(62.22,106.21) v1(62.85,106.18) v1(63.49,106.21) v1(63.94,105.12) v1(82.66,101.43) v1(82.86,96.18) v1(83.3,101.43) v1(83.35,95.69) v1(83.95,101.42)
+3VLCD_CON_R:
  vias: v1(60.23,106.18) v1(60.76,105.52) v1(60.89,106.18) v1(61.53,106.18)
+3VLCD_CON_R_C:
  vias: v1(61.23,107.96) v1(61.86,107.96) v1(62.52,107.96)
+3VPCU: length 440.9
  TOP w0.254: R25323.2 181.1,32.16 v2(181.61,32.16)
  TOP w0.381: R25368.2 54.81,109.15 54.81,110.07 R25370.1 53.83,111.05 v1(53.83,111.29)
  TOP w0.508: v1(47.03,10.22) 47.03,13.52 46.34,14.21 46.34,16.62 46.58,16.86 v1(46.58,20.56) ; v1(65.7,18.02) 65.7,18.07 62.26,21.51 R25295.1 62.26,22.97 R2291.2 ; PR18.2 96.28,21.7 95.17,20.59 v1(95.17,19.4) ; R2357.2 47.2,25.07 47.05,24.93 v1(47.05,24.19)
  TOP w0.635: v1(36.49,121.31) 35.85,121.95 HE1.2
  IN1 w0.381: v1(148.68,34.39) 148.68,34.56 149.01,34.89 154.15,34.89 154.85,35.58 159.1,35.58 159.93,34.76 159.93,34.53 160.18,34.27 163.25,34.27 163.68,33.84 165.22,33.84 166.37,32.69 169.33,32.69 170.55,31.48 172.81,31.48 174.08,32.75 181.28,32.75 181.61,32.42 ; 181.61,32.42 v2(181.61,32.16) ; 181.61,32.42 181.94,32.75 185.13,32.75 185.47,33.09 185.63,33.11 186.07,33.19 188.85,33.19 189.67,32.37 190.31,32.37 190.64,32.7 191.5,32.7 v1(191.7,32.9) 192.06,32.9 192.4,32.56 192.95,32.56 193.22,32.29 194.36,32.29 194.77,32.7 194.77,33.88 194.63,34.02 v2(194.63,34.78) 195.6,34.78 197.34,33.03 197.34,32.06 197.03,31.74 197.03,30.91 198.51,29.42 199.05,29.42 199.26,29.63 200.34,29.63 201.11,28.85 201.44,28.85 201.71,28.58 202.5,28.58 203.6,29.68 208.08,29.68 208.59,29.16 210.46,29.16 211.36,30.07 211.36,31.57 211.98,32.18 213.18,32.18 214.01,31.36 v1(214.51,31.36)
  IN1 w0.508: v1(46.58,20.56) 46.58,22.99 47.05,23.46 v1(47.05,24.19)
  IN2 w0.381: v1(46.58,20.56) 46.21,20.19 46.21,17.66 43.85,15.29 43.25,15.29 37.91,9.96 31.98,9.96 30.67,11.26 30.67,13.12 29.71,14.07 29.71,16.94 28.44,18.22 27.75,18.22 27.37,18.6 27.37,18.88 26.94,19.3 26.24,19.3 25.79,18.85 25.79,18.31 25.41,17.93 24.66,17.93 23.79,18.8 23.25,18.8 23.18,18.72 21.78,18.72 21.37,19.14 20.05,19.14 19.64,18.72 17.28,18.72 16.86,19.14 v1(14.24,19.14) ; v1(148.68,34.39) 146.46,34.39 145.27,35.58 143.63,35.58 v1(143.13,35.09)
  IN2 w0.508: v1(46.58,20.56) 47.25,19.89 47.25,19.49 48.53,18.22 65.49,18.22 v1(65.7,18.02) 67.14,16.57 78.61,16.57 83.71,21.68 88.86,21.68 89.55,20.99 90.75,20.99 92.4,19.33 93.43,19.33 93.84,19.75 93.84,19.84 94.2,20.19 94.7,20.19 95.17,19.73 v1(95.17,19.4)
  IN2 w0.635: v1(18.46,87.86) 18.29,87.68 18.29,85.14 20.18,83.25 20.18,82.36 18.29,80.47 18.29,76.49 24.36,70.42 24.36,68.03 23.84,67.51 23.84,65.79 24.36,65.27 24.36,51.92 22.32,49.88 19.35,49.88 17.46,47.99 v1(17.46,47.48)
  IN3 w0.381: v1(53.83,111.29) 53.61,111.06 53.02,111.06 52.67,110.7 50.86,110.7 49.34,112.23 48.45,112.23 48.09,112.58 48.09,113.8 47.51,114.39 41.51,114.39 v1(40.68,115.23) ; v2(197.12,25.84) 197.12,27.78 196.51,28.39 196.51,29.77 196.03,30.25 196.03,31.07 195.27,31.83 193.77,31.83 193.36,32.23 192.38,32.23 v1(191.7,32.9)
  IN3 w0.508: v1(95.17,19.4) 95.17,18.73 95,18.56 95,17.24 95.51,16.73 96.47,16.73 97.83,18.09 103.2,18.09 103.97,18.86 118.57,18.86 120.47,20.76 121.14,20.76 121.58,21.2 122.87,21.2 123.91,22.24 126.89,22.24 127.53,21.6 132.33,21.6 v1(133.28,20.64)
  IN3 w0.635: v1(14.24,19.14) 15.22,20.13 15.22,24.28 15.54,24.6 15.54,26.48 15.74,26.68 15.74,41.66 14.88,42.52 14.88,46.61 15.76,47.48 v1(17.46,47.48) ; 18.78,95.2 18.99,95.2 19.65,95.85 19.65,96.48 20.75,97.58 20.75,100.25 21.71,101.21 24.81,101.21 25.63,102.03 25.63,104.94 25.95,105.27 32.7,105.27 33.71,106.28 35.51,106.28 39.14,109.91 39.14,113.17 39.11,113.2 39.11,114.59 39.75,115.23 v1(40.68,115.23) ; 18.68,94.32 18.68,92.58 17.2,91.1 17.2,89.06 18.4,87.86 v1(18.46,87.86)
  BOTTOM w0.203: v1(143.13,35.09) 143.25,35.21 143.25,36.49 PR6003.1
  BOTTOM w0.254: R25505.2 198.77,22.51 198.77,24.83 198.56,25.03 197.75,25.03 197.12,25.67 v2(197.12,25.84)
  BOTTOM w0.305: v1(214.51,31.36) 214.46,31.41 214.46,32.11 214.17,32.4 CN35.32
  BOTTOM w0.381: R736.2 195.07,34.38 194.68,34.78 v2(194.63,34.78) ; PR15.2 138.36,27.94 138.36,27.32 137.88,26.83 PR9.2 137.46,26.44 137.19,26.17 136.17,26.17 v1(135.85,26.48)
  BOTTOM w0.635: v1(40.68,115.23) 40.5,115.4 40.5,119.33 C842.1 39.08,119.38 38.16,120.3 37.5,120.3 v1(36.49,121.31)
  vias: v1(18.02,95.35) v1(18.02,94.71) v1(152.77,28.96) v1(153.41,28.96)
+3VPCU_EC: length 95.2
  TOP w0.178: U37.26 182.32,18.18
  TOP w0.203: 200.05,26.34 199.81,26.58 U37.92 ; U37.121 187.65,30.64 187.44,30.85 186.86,30.85 186.6,31.11 C6574.1 ; v2(191.96,12.43) 191.65,12.74 U37.50 ; C6575.1 191.18,31.08 190.94,30.85 190.57,30.85 190.45,30.72 U37.114
  TOP w0.254: 200.05,26.34 200.06,26.33 200.06,26.26 200.09,26.24 200.09,26.21 200.2,26.1 200.2,25.75 200.45,25.49 C6565.1 200.67,25.13 200.58,25.04 200.58,24.68 201.04,24.22 201.7,24.22 202.17,24.68 v2(202.17,24.7) ; v2(202.07,13.32) 202.26,13.51 202.26,15.78 202.25,15.79 L29.1 ; L30.2 184.02,32.25 184.8,33.03 186.55,33.03 186.96,32.63 v2(186.96,32.6) 186.96,32.21 187.05,32.12 187.05,31.52 186.78,31.26 C6574.1 ; C6575.1 190.77,31.36 190.74,31.38 190.71,31.38 v2(190.68,31.41) ; v2(191.96,12.43) 192.13,12.25 C6569.1 C6570.1 192.45,10.7 v2(192.28,10.53) ; 182.32,18.18 182.23,18.27 C6578.1 C6577.1 180.48,18.27 180.22,18.53 179.39,18.53 179.16,18.76 178.34,18.76 177.68,19.42 R25306.2 177.57,18.84 178.42,17.99 178.42,17.16 178.79,16.79 v2(179.14,16.79)
  IN1 w0.254: v2(191.96,12.43) 191.42,12.43 191.25,12.6 190.36,12.6 189.26,13.7 186.07,13.7 185.68,14.09 183.75,14.09 182.6,15.24 179.98,15.24 179.14,16.07 v2(179.14,16.79) ; v2(186.96,32.6) 186.96,32.57 187.1,32.43 187.1,31.72 188.04,30.78 189.91,30.78 190.51,31.38 190.61,31.38 190.64,31.41 v2(190.68,31.41)
  IN2 w0.254: v2(206.07,17) 205.9,17 205.65,17.26 205.65,18.01 203.9,19.76 203.9,24.28 203.36,24.81 203.36,25.06 202.86,25.56 202.5,25.56 ; 202.5,25.56 202.17,25.23 v2(202.17,24.7) ; 202.5,25.56 202.35,25.72 202.35,26.63 202.11,26.87 201.51,26.87 200.88,27.49 199.12,27.49 196.12,30.49 192.05,30.49 191.13,31.41 v2(190.68,31.41) 190.7,31.43
  IN3 w0.254: v2(206.07,17) 205.75,17 v2(202.07,13.32) 202.07,12.6 200.48,11.02 192.54,11.02 192.28,10.76 v2(192.28,10.53)
+3VPCU_ECPLL: length 3.3
  TOP w0.203: U37.127 185.25,30.72 185.2,30.77 185.2,31
  TOP w0.254: L30.1 184.29,31.83 C6573.1 185,31.83 185.2,31.64 185.2,31
+3VSPI: length 2.3
  TOP w0.203: R586.2 121.58,20.46 v1(121.83,20.46)
  TOP w0.254: R583.2 122.08,17.74 122.29,17.54 v1(122.29,17.18)
+5V: length 180.5
  TOP w0.381: v1(174.36,32.07) 173.76,31.47 173.76,30.58 174.09,30.25 R25373.1 174.36,29.49 174.37,29.48 R575.1 ; v1(112.45,14.99) 112.45,15.25 112.6,15.39 v1(112.6,21.12)
  TOP w0.508: v1(20,88.38) 19.88,88.5 18.1,88.5 17.7,88.1 Q6508.3 17.21,87.13 16.94,87.4 v1(15.48,87.4)
  IN1 w0.381: v2(204.1,27.57) 203.87,27.57 203.39,27.09 202.75,27.09 202.65,26.99 200.77,26.99 200.67,27.09 199.86,27.09 198.13,28.82 198.13,28.9 195.87,31.17 195.82,31.17 195.33,31.66 191.74,31.66 190.29,30.21 186.2,30.21 185.53,30.87 185.53,31.79 185.2,32.12 182.96,32.12 182.37,31.52 181.09,31.52 180.49,32.12 177.74,32.12 176.89,31.27 176.35,31.27 175.55,32.07 v1(174.36,32.07)
  IN1 w0.508: v1(18.05,61.07) 18.05,60.34 16.88,59.17 16.88,55.84 16.14,55.1 16.14,54.14 16.39,53.89 16.39,53.21 15.84,52.66 15.84,51.87 16.67,51.04 16.67,50.58 16.22,50.13 16.22,45.38 18.01,43.58 18.01,33.25 v1(17.16,32.4)
  IN2 w0.381: v1(101.95,25.11) 102.75,25.11 103.9,23.96 105.42,23.96 108.26,21.12 v1(112.6,21.12)
  IN2 w0.508: v1(18.05,61.07) 18.05,62.37 18.65,62.98 19.04,62.98 21.47,65.41 21.47,69.41 20.86,70.01 20.86,70.4 19.05,72.22 17.79,72.22 16.44,73.57 16.44,81.23 17.11,81.89 17.11,83.36 16.28,84.19 15.74,84.19 15.35,84.57 15.35,87.27 v1(15.48,87.4) ; v1(61.56,100.47) 60.79,99.71 52.28,99.71 51.42,98.84 49.74,98.84 48.9,98 45.02,98 44.64,97.62 29.96,97.62 29.56,97.23 29.56,93.9 27.24,91.58 27.24,90.94 27.57,90.61 v1(27.95,90.61)
  BOTTOM w0.381: PR126.1 v1(101.95,25.11)
  BOTTOM w0.508: v1(20,88.38) 20.59,88.38 21.15,88.93 21.15,89.45 24.01,92.32 25.94,92.32 27.65,90.61 v1(27.95,90.61)
  vias: v1(16.52,32.4) v1(16.52,31.76) v1(16.52,31.13) v1(16.52,30.49) v1(16.85,29.93) v1(17.16,31.76) v1(17.16,31.13) v1(17.16,30.49) v1(123.61,16.24) v1(124.24,16.24) v1(124.88,16.22) v1(125.51,16.19) v1(209.11,19.11) v1(209.08,18.48) v1(213.17,19.44) v1(213.45,26.25) v1(213.93,26.73) v2(197.93,14.08) v2(198.52,14.31) v2(204.1,28.15)
+5V_FAN:
  vias: v1(175.7,26.81) v1(176.36,26.78) v1(177.51,26.44)
+5V_HDMIC: length 23.6
  TOP w0.508: D14.3 26.49,71.09 25.59,72 25.59,73.95 25.31,74.23 24.55,74.23 v1(23.1,75.68)
  IN3 w0.508: v1(18.76,75.04) 17.93,75.87 17.93,78.47 17.44,78.96 17.44,83.07 16.55,83.96 15.71,83.96
  BOTTOM w0.508: v1(18.76,75.04) 19.54,75.83 22.95,75.83 v1(23.1,75.68)
  vias: v1(13.24,85.81) v1(13.24,85.15) v1(13.18,80.66) v1(13.88,85.79) v1(13.88,85.15)
+5V_KB:
  vias: v1(203.74,18.62)
+5V_PVDD: length 2.9
  BOTTOM w0.203: U20.46 208.35,31.22 208.99,30.58 208.99,30.25 v1(208.99,30.25) ; v1(208.8,33.26) 208.76,33.22 U20.41
+5V_S5: length 85.2
  TOP w0.254: v1(72.78,105.65) 72.78,106.15 PR9013.1 ; v1(141.62,71.31) 140.53,70.22 140.53,69.18 141.06,68.65 141.06,67.98 140.88,67.8 PR9091.2
  TOP w0.381: v1(132.17,53.17) 132.17,53.14 132.92,52.39 133.6,52.39 133.66,52.33 PR7064.1
  TOP w0.508: v1(62.94,123.21) 62.67,123.48 PR256.2 ; v1(132.01,78.83) 132.24,79.06 PR9100.1
  IN2 w0.508: 134.94,50.02 136.54,50.02 138.16,51.65 140.81,51.65 141.38,52.22 141.38,56.89 140.79,57.48 140.79,58.6 141.34,59.14 141.34,62.62 139.44,64.51 139.44,69.82 140.93,71.31 v1(141.62,71.31) 141.69,71.39 141.69,77.04 139.9,78.83 v1(132.01,78.83) ; 134.94,50.02 133.62,51.34 131.99,51.34 131.44,51.89 131.44,52.45 v1(132.17,53.17) ; 134.94,50.02 v1(134.94,47.26) 134.94,47.1 135.49,46.54 139.1,46.54 140.8,44.84 v1(140.8,43.94)
  BOTTOM w0.254: v1(115.43,69.94) 115.89,69.48 115.89,69.39 PR7108.1
  BOTTOM w0.305: PR9074.1 74.49,105.02 76.16,106.69 PR9001.1
  BOTTOM w0.381: v1(72.78,105.65) 72.97,105.65 73.59,105.02 PR9074.1 ; v1(140.8,43.94) 140.8,44.12 141.03,44.35 PR7065.1 141.38,44.55 141.53,44.71 PR7069.1 142.21,44.55 142.21,43.94 PR7116.1
  BOTTOM w0.508: v1(134.94,47.26) 135.09,47.41 PR7080.1 ; v1(132.01,78.83) 132.01,78.61 130.92,77.52 PR7112.1 ; v1(141.62,71.31) 142.2,70.73 PR9087.1 ; PR7103.2 v1(132.17,53.17)
  vias: v1(20.23,38.75) v1(20.25,40.07) v1(20.25,39.43) v1(20.81,39.76) v1(23.48,18.25) v1(23.97,19.6) v1(24.6,20.01) v1(24.61,19.34) v1(28,16.19) v1(28,15.53) v1(28.51,14.87) v1(28.66,16.24) v1(28.66,15.58) v1(203.54,21.47) v1(205.83,22.21) v2(204.99,21.27) v2(205.52,21.57)
+5VA: length 2.8
  BOTTOM w0.203: 202.64,36.45 202.67,36.45 202.86,36.26 U20.26
  BOTTOM w0.254: C569.1 201.31,37.06 201.61,36.77 202.32,36.77 202.64,36.45
  vias: v1(199.55,35.82) v1(199.58,35.19)
+5VPCU: length 345.9
  TOP w0.203: PU9002.4 22.54,91.03 PC9059.1
  TOP w0.254: v1(172.02,32.52) 172.02,31.94 171.18,31.1 171.18,27.07 170.47,26.36 v1(170.47,26.12) ; v1(145.91,37.71) 145.91,36.81 146.98,35.75 146.98,29.6 v1(146.7,29.32) ; v1(23.84,88.45) 23.79,88.45 23.4,88.84 23.4,90.18 22.91,90.67 PC9059.1 ; PR6023.2 27.16,27.57 27.06,27.67 v1(26.07,27.67)
  IN1 w0.508: v1(76.82,97.62) 76.47,97.27 73.47,97.27 73.11,97.62 68.87,97.62 v1(68.24,98.26)
  IN2 w0.254: v1(146.7,29.32) 145.98,28.61 145.95,28.61 142.52,25.17 133.38,25.17 130.49,28.06 130.49,30.6 129.91,31.18 129.52,31.18 128.64,32.06 127.42,32.06 122.17,37.31 122.17,38.44 121.42,39.18 121.42,39.81 v1(122.11,40.5) ; v1(145.91,37.71) 146.58,37.71 146.66,37.63 147.13,37.2 148.37,36.46 148.84,36.3 149.06,36.22 149.74,35.98 151.1,35.78 151.39,35.78 152.62,35.84 154.03,36.2 154.21,36.28 154.66,36.5 159.17,36.5 160.12,35.54 162.01,35.54 163.68,33.88 165.3,33.88 165.95,33.22 171.32,33.22 v1(172.02,32.52) 173.01,33.51 187.11,33.51 187.72,34.12 188.76,34.12 189.14,34.5 192.59,34.5 194.02,35.93 195.8,35.93 v1(195.94,36.06)
  IN2 w0.508: v1(18.73,46.6) 19.49,46.6 19.96,47.06 20.67,47.06 25.69,52.08 25.69,86.35 27.95,88.61 v1(27.95,89.67) 27.21,89.67 26.48,90.41 26.48,91.93 28.8,94.26 28.8,98.3 29.61,99.11 38.3,99.11 38.8,99.6 51.1,99.6 53.86,102.37 61.28,102.37 63.33,100.32 66.13,100.32 68.18,98.26 v1(68.24,98.26) 69.07,98.26 71.47,95.86 74.54,95.86 76.81,93.59 77.56,93.59 79.87,91.27 81.43,91.27 85.15,87.56 87.67,87.56 88.17,87.05 92.06,87.05 94.69,84.42 97.81,84.42 98.58,83.65 99.1,83.65 100.8,81.95 100.8,80.25 100.34,79.79 100.34,78.23 100.8,77.78 100.8,74.34 101.33,73.81 101.33,67.24 102.44,66.13 104.06,66.13 104.77,65.42 107.48,65.42 108.58,66.52 112.32,66.52 113.45,65.39 113.45,62.75 113.09,62.39 113.09,54.33 114.67,52.76 114.67,47.15 116.88,44.94 121.4,44.94 121.78,44.56 121.78,42.12 121.42,41.77 121.42,40.96 121.88,40.5 v1(122.11,40.5)
  BOTTOM w0.203: PR98.2 v1(122.11,40.5)
  BOTTOM w0.254: R737.2 195.18,35.65 195.46,35.93 195.8,35.93 v1(195.94,36.06) ; v1(27.95,89.67) 27.04,88.76 25.61,88.76 25.31,88.45 v1(23.84,88.45) ; v1(170.47,26.12) 168.73,26.12 165.88,28.97 162.67,28.97 162.39,29.25 160.87,29.25 160.69,29.07 158.35,29.07 158.21,28.93 158.21,28.35 157.58,27.72 PR6013.1
  vias: v1(17.46,46.6) v1(18.1,46.6) v1(18.1,45.96) v1(18.73,47.23) v1(18.73,45.96) v1(22.31,24.88) v1(22.64,25.53) v1(22.95,24.92) v1(23.18,28.99) v1(23.28,25.53) v1(23.58,24.92) v1(23.58,24.29) v1(23.56,22.31) v1(23.81,30.03) v1(23.79,29.4) v1(23.79,28.76) v1(23.79,28.13) v1(23.91,25.54) v1(24.45,30.26) v1(24.42,29.63) v1(24.42,28.99) v1(30.26,16.14) v1(30.26,15.51) v1(30.9,16.19) v1(30.9,15.53) v1(31.43,16.88) v1(31.53,16.17) v1(31.56,15.53) v1(32.19,16.22) v1(32.19,15.53)
+A3VPCU: length 4.8
  TOP w0.203: U37.74 199.69,19.38 199.78,19.29 200.3,19.29 v1(200.8,18.79)
  TOP w0.254: L29.2 201.6,17.39 C6566.1 201.59,17.76 201.59,18 v1(200.8,18.79)
+V3A_LX_R: length 1.5
  BOTTOM w0.508: PR6001.2 143.67,28.92 143.47,28.71 PC6006.1
+V3A_OUT:
  vias: v1(149.42,34.32) v1(150.08,34.32) v1(150.72,34.32) v1(151.43,34.3) v1(152.06,34.3) v1(152.72,34.27) v1(153.35,34.3) v1(153.99,34.3)
+V5P5A_LX: length 4.1
  TOP w0.508: v1(38.48,18.81) v1(39.17,18.81) 39.45,18.81 39.89,19.26 PR6019.1 40.37,18.53 39.59,17.75 PR6018.1
+V5P5A_LX_R: length 3.1
  TOP w0.508: PR6019.2 v1(42.56,19.26) 42.56,18.5 43.26,17.8 PC6038.1
+V5P5A_OUT: length 11.1
  BOTTOM w0.152: PC6046.1 35.9,13.88 38.94,13.88 39.09,13.73 39.09,12.81 39.43,12.48 43.41,12.48 44.36,13.42 PR6026.2
  vias: v1(31.78,17.58) v1(35.65,18.97) v1(35.67,17.35) v1(35.67,16.71) v1(36.3,18.98) v1(36.32,17.38) v1(36.32,16.74) v1(36.94,18.97) v1(36.96,17.38) v1(37,16.74)
+VCC_CORE: length 35.3
  BOTTOM w0.127: 93.66,55.72 U2030.G35 ; U2030.G35 93.35,55.41 ; U2030.G35 93.05,55.72 ; 81.42,54.81 U2030.AM33 ; U2030.AM33 80.81,54.81 ; U2030.AM33 81.11,55.11 ; U2030.AM33 81.11,54.5 ; U2030.AK33 82.36,54.81 ; U2030.AK33 81.75,54.81 ; U2030.AK33 82.05,54.5 ; 93.21,57.27 93.35,57.42 U2030.G38 93.06,57.55 ; U2030.K40 92.12,58.46 ; U2030.K40 92.42,58.16 ; U2030.K40 92.73,58.46 ; U2030.K40 92.42,58.77 ; U2030.AL37 81.59,56.48 ; U2030.AL37 81.89,56.18 ; U2030.AL37 81.28,56.18 ; U2030.AL37 81.59,55.87 ; 93.05,59.38 U2030.G42 93.35,59.07 ; U2030.AM35 81.11,55.41 ; U2030.AM35 80.81,55.72 ; U2030.AM35 81.42,55.72 ; U2030.AM35 81.11,56.03 ; 82.36,56.63 U2030.AK37 ; U2030.AK37 82.05,56.33 ; U2030.AK37 81.75,56.63 ; U2030.J37 93.19,57.09 ; U2030.J37 92.89,56.79 ; U2030.J37 92.89,57.4 ; U2030.J37 92.58,57.09 ; 81.11,54.2 U2030.AM32 81.42,53.89 ; U2030.J33 92.89,54.96 ; U2030.J33 92.89,55.57 ; U2030.J33 92.58,55.26 ; U2030.J33 93.19,55.26 ; U2030.AL40 81.89,58.01 ; U2030.AL40 81.28,58.01 ; U2030.AL40 81.59,57.7 ; U2030.AL40 81.59,58.31 ; 92.58,53.43 U2030.J30 ; U2030.J30 92.89,53.13 ; U2030.J30 92.89,53.74 ; U2030.J30 93.19,53.43 ; 92.89,59.23 U2030.J40 ; U2030.J40 92.58,58.92 ; U2030.J40 92.89,58.61 ; U2030.J40 93.19,58.92 ; 92.42,59.68 U2030.K42 ; U2030.K42 92.73,59.38 ; U2030.K42 92.42,59.07 ; U2030.K42 92.12,59.38 ; U2030.K35 92.42,56.03 ; U2030.K35 92.42,55.41 ; U2030.K35 92.73,55.72 ; U2030.K35 92.12,55.72 ; 93.05,52.98 U2030.G30 ; U2030.G30 93.66,52.98 ; U2030.G30 93.35,53.28 ; 93.13,56.86 U2030.G37 93.01,56.63 ; U2030.K37 92.42,56.94 ; U2030.K37 92.73,56.63 ; U2030.K37 92.12,56.63 ; U2030.K37 92.42,56.33 ; U2030.K43 92.42,59.99 ; U2030.K43 92.73,60.29 ; U2030.K43 92.12,60.29 ; U2030.AK38 81.75,57.55 ; U2030.AK38 82.05,57.85 ; U2030.AK38 82.36,57.55 ; U2030.AM38 80.81,57.55 ; U2030.AM38 81.11,57.85 ; U2030.AM38 81.11,57.24 ; U2030.AM38 81.42,57.55 ; 82.36,58.46 U2030.AK40 ; U2030.AK40 81.75,58.46 ; U2030.AK40 82.05,58.16 ; U2030.AK40 82.05,58.77 ; 92.42,54.5 U2030.K33 ; U2030.K33 92.42,55.11 ; U2030.K33 92.73,54.81 ; U2030.AM37 81.42,56.63 ; U2030.AM37 81.11,56.94 ; U2030.AM37 80.81,56.63 ; U2030.AM37 81.11,56.33 ; 82.05,56.03 U2030.AK35 ; U2030.AK35 81.75,55.72 ; U2030.AK35 82.36,55.72 ; U2030.K38 92.42,57.85 ; U2030.K38 92.42,57.24 ; U2030.K38 92.12,57.55 ; U2030.K38 92.73,57.55 ; 93.05,58.46 U2030.G40 93.35,58.77 ; 93.05,53.89 U2030.G32 93.35,53.59 ; 81.89,54.35 U2030.AL33 ; U2030.AL33 81.59,54.65 ; U2030.AL33 81.59,54.04 ; U2030.AL33 81.28,54.35 ; 93.05,54.81 U2030.G33 93.35,55.11
  BOTTOM w0.203: v4(97.59,60.7) 97.18,60.7 U2030.A44
  BOTTOM w0.254: U2030.A39 97.11,58.42 97.85,58.42 97.89,58.39 v1(98.23,58.39) ; U2030.A34 98.07,55.88 v4(98.07,55.87)
  vias: v1(82.54,58.99) v1(82.48,58) v1(82.92,58.48) v1(82.87,57.49) v1(82.89,56.7) v1(82.96,55.85) v1(82.99,55.21) v1(83.2,54.6) v1(84.28,55.1) v1(86.83,55.36) v1(86.88,54.72) v1(88.12,54.24) v1(91.96,55.13) v1(98.56,53.4) v1(98.92,53.96) v1(101.38,54.47) v1(101.38,53.83) v1(102.02,54.47) v1(102.02,53.83) v1(105.45,54.01) v1(105.45,53.38) v1(105.9,52.77) v1(106.26,53.96) v1(106.28,53.33) v1(106.92,53.96) v1(106.92,53.33) v1(106.97,52.69) v1(107.61,54.01) v1(107.55,53.38) v1(107.63,52.74) v1(107.58,52.11) v1(110.63,64.55) v1(110.88,63.94) v1(111.01,56.22) v1(111.28,64.59) v1(111.41,65.23) v1(111.64,56.25) v1(111.67,60.13) v1(111.67,59.5) v1(111.67,58.86) v1(111.67,58.23) v1(111.67,57.59) v1(111.67,56.96) v1(111.83,65.72) v1(111.77,64.15) v1(112,64.81) v1(112.04,52.54) v1(112.31,60.11) v1(112.31,59.47) v1(112.31,58.84) v1(112.31,58.2) v1(112.31,57.57) v1(112.31,56.93) v1(112.28,56.25) v1(112.25,51.9) v1(112.41,65.42) v1(112.48,64.27) v1(112.5,63.63) v1(112.48,62.95) v1(112.68,52.5) v1(112.76,64.88) v1(113.02,51.93) v1(113.32,52.51) v1(113.65,51.88) v1(113.96,52.49) v1(115.68,63.46) v1(115.71,62.8) v1(115.72,62.17) v1(115.72,61.53) v1(116.29,63.26) v1(116.35,62.17) v1(116.35,61.53) v1(116.72,62.75) v1(116.68,58.37) v1(116.72,57.73) v1(117.35,58.37) v1(117.35,54.7) v1(117.33,54.06) v1(117.37,59.05) v1(117.37,57.74) v1(117.46,61.69) v1(117.46,61.05) v1(117.46,60.38) v1(117.48,57) v1(118.04,60.8) v1(118.07,61.48) v1(118.06,60.17) v1(118.15,56.86) v1(118.15,56.09) v4(80.79,57.01) v4(80.79,56.18) v4(80.8,55.25) v4(80.77,54.39) v4(91.66,60.32) v4(91.93,59.76) v4(91.93,58.92) v4(91.93,57.12) v4(91.92,56.45) v4(91.91,55.79) v4(97.91,54.15)
+VCC_V3A: length 1.8
  BOTTOM w0.203: PU6000.9 145.05,33.48 144.84,33.69 144.84,34.02 144.48,34.38 PC6022.1
+VCC_V5P5A: length 1.8
  BOTTOM w0.229: PU6003.11 43.32,15.91 PC6058.1
+VCCATS_1P8: length 9.8
  TOP w0.381: R2298.1 88.83,28.7 89.74,29.62 89.74,30.16 C2352.1 89.4,30.98 89.83,31.41 89.83,31.91 89.57,32.17 89.08,32.17 88.83,32.42 88.83,33.27 v1(88.53,33.57) 87.94,34.16 87.94,34.25 87.15,35.05 v1(86.84,35.05)
  BOTTOM w0.203: U2030.AA1 86.61,35.98 86.61,35.29 v1(86.84,35.05)
+VCCDSW: length 20.6
  TOP w0.254: R2291.1 63.43,25.35 v1(63.88,25.35) 64.24,25.71 R2303.2 64.94,26.38 65.45,26.89 C2347.2 65.45,29.14 65.29,29.3 65.29,30.64 68.48,33.84 71.03,33.84 72.19,35 72.19,35.2 v1(73.65,36.66)
  BOTTOM w0.254: U2030.AD17 85.13,45.21 85.04,45.21 v4(84.81,45.44) 85.14,45.76 U2030.AD18
  BOTTOM w0.279: v4(83.14,45.44) 83.05,45.44 U2030.AJ17
+VCCDSW_1P0: length 6.4
  BOTTOM w0.102: C2602.1 82.23,31.05 81.84,31.05 81.57,31.32 81.57,33.91 81.06,34.42 81.06,35.81 U2030.AL1
+VCCGT: length 17.4
  BOTTOM w0.127: 88.94,70.34 U2030.T62 89.25,70.64 ; 89.4,71.46 U2030.R64 89.4,72.08 ; 91.23,70.81 U2030.L63 91.53,71.11 ; 86.66,70.81 U2030.AA63 86.96,71.11 ; 93.19,68.98 U2030.J58 92.89,68.67 ; 92.73,69.44 U2030.K60 92.42,69.13 ; 91.23,71.46 U2030.L64 91.23,72.09 ; 92.89,65.93 U2030.J53 92.58,66.24 ; 91.99,70.64 U2030.L62 91.68,70.34 ; 90.31,71.46 U2030.N64 90.01,71.76 ; 93.19,69.89 U2030.J60 92.89,69.59 ; U2030.AC64 85.74,72.09 ; 92.42,66.39 U2030.K55 92.73,66.69 ; 93.19,68.06 U2030.J56 92.89,67.76 ; U2030.K53 92.42,66.08 ; 90.77,70.34 U2030.M62 91.08,70.64 ; 93.19,67.15 U2030.J55 92.89,66.84 ; 92.42,67.3 U2030.K56 92.73,67.61 ; 92.42,68.22 U2030.K58 92.73,68.52 ; 86.66,72.08 U2030.AA64 86.96,71.76 ; 87.57,71.46 U2030.W64 ; 89.4,70.81 U2030.R63 89.7,71.11 ; 87.26,71.11 U2030.W63 87.57,70.81 ; 90.62,71.11 U2030.N63 90.31,70.81
  BOTTOM w0.178: U2030.A58 97.05,68.27 97.99,68.27 v4(98.06,68.34)
  BOTTOM w0.203: U2030.A66 97.81,73.23 v4(97.88,73.29) ; v4(98.52,71.23) 98.37,71.23 97.88,70.75 U2030.A62
  vias: v1(84.96,86.32) v1(85.48,85.94) v1(86.2,71.44) v1(87.06,69.94) v1(87.51,86.63) v1(87.74,86.02) v1(87.93,80.71) v1(87.92,80.04) v1(87.93,79.39) v1(87.93,78.75) v1(87.93,78.07) v1(87.93,77.43) v1(88.1,69.99) v1(90.78,78.6) v1(90.78,77.96) v1(90.79,76) v1(91.58,69.83) v1(91.58,69.17) v1(91.86,79.02) v1(91.86,78.39) v1(93.99,82.05) v1(93.96,81.42) v1(93.97,80.75) v1(97.47,83.55) v1(97.95,83.09) v1(98.46,82.58) v1(99.1,82.61) v1(99.2,81.95) v1(99.22,81.32) v1(99.35,72.07) v1(99.86,81.8) v1(99.86,81.15) v1(102.08,79.13) v1(102.19,79.78) v1(104.41,78.4) v1(104.38,77.76) v1(104.89,77.1) v1(105.01,77.72) v4(87.93,76.8) v4(90.78,77.33) v4(90.78,76.64) v4(91.58,68.51) v4(91.58,67.85) v4(91.58,67.19) v4(91.58,66.47) v4(91.58,65.84)
+VCCGT_+VCORE: length 8.6
  BOTTOM w0.127: 92.73,63.95 U2030.K50 ; U2030.K50 92.12,63.95 ; U2030.K50 92.42,63.64 ; U2030.K50 92.42,64.25 ; U2030.J46 92.89,62.27 ; U2030.J46 92.58,62.58 ; U2030.J46 92.89,62.88 ; 92.58,60.75 U2030.J43 92.89,61.05 ; 92.89,64.1 U2030.J50 ; U2030.J50 92.89,64.71 ; U2030.J50 92.58,64.41 ; 92.89,65.02 U2030.J52 92.58,65.32 ; 92.89,61.97 U2030.J45 ; U2030.J45 92.58,61.66 ; U2030.J45 92.89,61.36 ; U2030.J48 92.89,63.19 ; U2030.J48 92.89,63.8 ; U2030.J48 92.58,63.49 ; 92.12,63.03 U2030.K48 ; U2030.K48 92.73,63.03 ; U2030.K48 92.42,63.34 ; U2030.K48 92.42,62.73
  BOTTOM w0.152: U2030.A48 97.25,63.52 v4(97.53,63.52)
  BOTTOM w0.254: v4(97.68,65.55) 97.29,65.55 97.05,65.79 U2030.A53
  vias: v1(91.35,64) v1(91.37,63.28) v1(91.37,62.56) v1(91.38,61.78) v1(91.93,64.31) v1(91.93,63.62) v1(91.92,62.93) v1(91.91,61.41) v1(106.1,69.56) v4(91.9,62.17)
+VCCGTX_1: length 22.4
  TOP w0.102: v1(82.34,65.36) 81.97,65.36 TP2024.1
  BOTTOM w0.127: 82.43,66.69 U2030.AK55 ; U2030.AK55 81.67,66.69 ; U2030.AK55 82.05,67.07 ; U2030.AK55 82.05,66.31 ; 81.59,66.77 U2030.AL56 ; U2030.AL56 81.97,67.15 ; U2030.AL56 81.59,67.53 ; U2030.AK53 81.67,65.78 ; U2030.AK53 82.05,66.16 ; U2030.AK53 82.43,65.78 82.43,65.45 v1(82.34,65.36) 82.31,65.32 U2030.AL53 81.59,65.7 ; U2030.AK56 81.67,67.61 ; U2030.AK56 82.05,67.99 ; U2030.AK56 82.43,67.61 ; U2030.AK56 82.05,67.23 ; 81.2,68.98 U2030.AL60 ; U2030.AL60 81.59,69.36 ; U2030.AL60 81.59,68.6 ; U2030.AL60 81.97,68.98 ; U2030.AK60 81.67,69.44 ; U2030.AK60 82.05,69.05 ; U2030.AK60 82.43,69.44 ; 81.49,68.52 U2030.AM58 ; U2030.AM58 80.81,68.52 ; U2030.AM58 81.11,68.9 ; U2030.AK58 82.05,68.14 ; U2030.AK58 82.43,68.52 ; U2030.AK58 81.67,68.52 ; U2030.AK58 82.05,68.9 ; U2030.AM56 81.49,67.61 ; U2030.AM53 81.49,65.78
  BOTTOM w0.152: v1(82.34,65.36) 82.34,65.03 82.17,64.86 U2030.AK52
  BOTTOM w0.178: U2030.AK70 82.23,77.52 v2(82.34,77.63)
  BOTTOM w0.254: U2030.BB57 74.96,68.05 v2(74.45,68.05) ; U2030.AU58 78.2,68.19 v4(78.2,68.06) ; 73.5,74.19 73.5,74.05 73.96,73.59 74.24,73.59 74.49,73.34 74.95,73.34 U2030.BB66
  BOTTOM w0.305: U2030.AU63 78.33,71.73 v4(78.85,71.73)
  BOTTOM w0.381: v1(73.54,75.55) 73.5,75.51 73.5,74.19
  vias: v1(82.34,66.23) v1(82.41,68.92) v1(82.41,68.11) v1(82.39,67.14) v1(82.95,69.3) v1(83.63,69.12)
+VCCGTX_+VCORE: length 15.6
  TOP w0.254: v1(83.02,62.09) 83.02,60.49 v1(82.41,59.88)
  BOTTOM w0.102: U2030.AM52 81.11,65.03 81.25,65.16
  BOTTOM w0.127: U2030.AK46 82.05,62.43 ; U2030.AK46 81.75,62.12 ; U2030.AK46 82.36,62.12 ; U2030.AK46 82.05,61.82 ; 82.36,59.38 U2030.AK42 ; U2030.AK42 81.75,59.38 ; U2030.AK42 82.05,59.68 ; U2030.AM48 81.11,63.34 ; U2030.AM48 81.11,62.73 ; U2030.AM48 80.81,63.03 ; U2030.AM48 81.42,63.03 ; U2030.AL46 81.89,61.66 ; U2030.AL46 81.59,61.97 ; U2030.AL46 81.59,61.36 ; U2030.AL46 81.28,61.66 ; U2030.AK48 82.05,63.34 ; U2030.AK48 81.75,63.03 ; U2030.AK48 82.05,62.73 ; U2030.AK48 82.36,63.03 ; 81.28,63.49 U2030.AL50 ; U2030.AL50 81.89,63.49 ; U2030.AL50 81.59,63.8 ; U2030.AL50 81.59,63.19 ; 80.81,64.86 U2030.AM52 81.42,64.86 ; 82.05,63.64 U2030.AK50 ; U2030.AK50 81.75,63.95 ; U2030.AK50 82.36,63.95 ; U2030.AK50 82.05,64.25 ; U2030.AL43 81.89,59.83 ; U2030.AL43 81.59,60.14 ; U2030.AL43 81.28,59.83 ; U2030.AL43 81.59,59.53 ; U2030.AM50 81.11,63.64 ; U2030.AM50 80.81,63.95 ; U2030.AM50 81.42,63.95 ; 82.36,60.29 U2030.AK43 ; U2030.AK43 81.75,60.29 ; U2030.AK43 82.05,59.99 ; 82.36,61.21 U2030.AK45 ; U2030.AK45 81.75,61.21 ; U2030.AK45 82.05,61.51
  vias: v1(80.82,65.32) v1(80.79,63.49) v1(81.6,63.71) v1(82.52,64.42) v1(82.53,63.49) v1(82.52,62.56) v1(82.98,67.49) v1(83.02,66.77) v1(83.01,66.03) v1(83.04,65.02) v1(83.08,63.98) v1(83.06,63)
+VCCHDA: length 20.1
  TOP w0.254: v1(73.57,35.52) 71.54,33.49 68.63,33.49 65.64,30.5 65.64,29.52 C2348.2 66.28,28.88 v1(66.28,27.64) 66.28,26.86 65.56,26.14 R2282.2 65.56,23.16 R2280.1
  BOTTOM w0.305: U2030.AJ19 82.39,46.74 v4(82.3,46.74)
+VCCIO: length 150.4
  TOP w0.254: R2171.2 94.4,63.47 v1(94.4,63.48)
  IN1 w0.254: v1(107.3,64.04) 106.48,64.87 106.15,64.87 103.15,67.87 101.05,67.87 99.31,66.13 97.52,66.13 94.87,63.48 v1(94.4,63.48)
  IN1 w0.508: v1(121.37,63.23) 121.22,63.38 120.79,63.38 118.75,65.42 116.05,65.42 113.77,67.71 107.13,67.71 106.69,67.27 106.69,66.4 107.3,65.79 v1(107.3,64.04) ; v1(99.48,80.2) 101.08,80.2 101.36,80.48 v1(102.2,80.48)
  IN2 w0.381: v1(138.77,31.46) 139.79,31.46 142.48,34.15 142.48,35.34 143.37,36.22 143.37,38.89 143.69,39.21 143.69,41.79 143.31,42.17 139.96,42.17 139.1,43.03 139.1,43.42 137.43,45.1 135.62,45.1 135.32,44.79 134.63,44.79 134.24,45.19 134.24,49.03 133.78,49.49 131.28,49.49 130.74,50.02 130.74,55.71 131.74,56.7 131.74,59.75 v1(131.79,59.8)
  IN3 w0.381: v1(121.37,63.23) 121.44,63.17 121.44,59.76 122.26,58.94 130.03,58.94 130.9,59.8 v1(131.79,59.8)
  IN3 w0.508: v1(106.98,41.73) 106.98,40.86 107.22,40.62 107.22,32.8 v1(107.1,32.68) v1(106.54,32.12) ; v1(104.2,53.66) 104.2,54.65 104.46,54.9 107.71,54.9 110.2,57.38 110.2,60.41 107.3,63.31 v1(107.3,64.04) 106.56,64.78 106.56,66.31 105.69,67.19 105.69,67.47 104.76,68.4 104.76,68.42 104.74,68.45 104.23,68.45 103.37,69.31 103.37,70.36 103.55,70.54 103.55,76.12 102.91,76.76 102.91,80.05 102.47,80.48 v1(102.2,80.48)
  BOTTOM w0.127: 81.11,52.37 U2030.AM28 81.42,52.06 ; 81.59,52.21 U2030.AL30 ; U2030.AL30 81.28,52.52 ; U2030.AL30 81.59,52.82 ; U2030.AL30 81.89,52.52 ; U2030.AK28 82.05,52.37 ; U2030.AK28 82.36,52.06 ; U2030.AK28 81.75,52.06 ; U2030.AM30 81.11,52.67 ; U2030.AM30 81.11,53.28 ; U2030.AM30 81.42,52.98 ; 81.75,52.98 U2030.AK30 82.05,52.67
  BOTTOM w0.254: v1(138.39,60.44) 138.72,60.11 PR7011.2
  BOTTOM w0.305: U2030.AL42 81.5,59 81.38,59.13 81.36,59.13 U2030.AM42 80.82,59.67 v4(80.82,59.88)
  BOTTOM w0.508: v1(107.3,64.04) 107.3,64.55 107.45,64.7 107.45,65.91 C2562.2
  vias: v1(82.34,52.51) v1(82.97,52.59) v1(106.82,42.35) v1(107.45,42.38) v1(107.65,41.73) v1(107.83,42.91) v1(108.2,42.38) v1(108.28,41.74) v4(80.79,53.45) v4(80.79,52.52)
