# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Nets (continued)
GND: C347.1 C348.1 C349.1 C350.1 C351.1 C352.1 C353.1 C354.2 C355.1 C356.1 C357.1 C359.1 C360.1 C362.2 C363.1 C364.2 C365.1 C366.2 C367.1 C368.1 C369.1 C371.2 C372.1 C373.1 C374.1 C375.1 C376.2 C377.1 C378.2 C379.1 C380.1 C381.1 C383.1 C385.2 C386.1 C387.1 C388.1 C389.1 C391.1 C392.2 C393.1 C394.2 C395.2 C396.1 C397.1 C398.2 C399.2 C400.1 C401.2 C402.2 C403.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.2 C414.2 C415.1 C416.2 C417.2 C418.1 C419.2 C420.2 C421.1 C422.1 C423.1 C424.1 C425.1 C426.1 C427.1 C428.1 C429.1 C430.1 C431.1 C432.1 C438.1 C439.1 C440.1 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.2 C457.1 C458.1 C459.1 C460.1 C461.2 C462.2 C463.2 C464.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.1 C478.1 C479.1 C480.1 C481.1 C482.1 C483.1 C484.2 C485.2 C486.2 C487.2 C488.2 C489.2 C490.2 C491.1 C492.1 C493.1 C494.1 C495.1 C496.1 C497.1 C498.1 C499.1 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C508.2 C509.1 C510.1 C511.1 C512.2 C513.1 C514.1 C515.1 C516.1 C517.1 C518.1 C521.2 C522.2 C523.1 C524.2 C525.1 C526.1 C527.1 C528.1 C529.1 C532.2 C533.2 C536.2 C537.2 C542.2 C543.1 C544.1 C545.2 C546.1 C547.2 C548.2 C550.2 C558.2 C559.2 C560.2 C561.2 C562.2 C565.2 C567.2 C574.2 C575.2 C576.2 C577.2 C578.2 C580.2 C581.2 C583.1 C584.2 C585.2 C586.2 C587.1 C588.2 C595.2 C596.2 C597.1 C601.2 C602.2 C603.2 C604.2 C613.2 C614.2 C616.2 C618.1 C619.2 C628.1 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C638.1 C639.1 C641.2 C642.2 C643.2 C644.2 C645.2 C646.1 C664.1 C665.2 C675.1 C676.1 C691.1 C692.1 C695.2 C696.2 C697.2 C698.2 C699.2 C706.2 C707.2 C708.2 C709.2 C711.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C736.2 C737.1 C740.1 C741.2 C742.2 C743.2 C744.2 C745.1 C749.1 C750.1 C752.1 C753.1 C770.2 C771.2 C772.2 C773.1 C774.1 C775.1 C776.1 C777.2 C778.2 C779.2 C780.2 C785.1 C786.1 C800.2 C801.2 C802.2 C804.2 C805.1 C841.2 C842.2 C844.1 C1044.2 C1189.2 C1190.2 C1208.1 C1210.2 C1687.2 C1688.2 C1689.2 C1690.2 C1691.2 C1692.2 C1693.2 C2063.2 C2064.2 C2065.2 C2066.2 C2079.2 C2080.2 C2081.2 C2082.2 C2085.2 C2086.1 C2087.2 C2088.2 C2089.2 C2090.1 C2091.2 C2092.1 C2093.2 C2094.2 C2095.1 C2097.2 C2100.2 C2101.1 C2102.2 C2104.1 C2105.2 C2106.2 C2107.1 C2108.1 C2109.1 C2110.2 C2111.1 C2112.1 C2113.1 C2115.1 C2119.1 C2120.1 C2121.1 C2122.1 C2124.2 C2126.1 C2127.1 C2128.1 C2130.1 C2131.2 C2132.2 C2133.2 C2134.2 C2135.2 C2136.1 C2137.2 C2138.2 C2139.2 C2140.1 C2141.2 C2142.1 C2143.1 C2144.1 C2145.1 C2146.1 C2147.1 C2148.1 C2149.1 C2150.1 C2151.1 C2152.1 C2153.2 C2154.2 C2155.1 C2156.2 C2157.2 C2158.1 C2159.2 C2160.2 C2161.2 C2162.2 C2163.1 C2164.1 C2165.1 C2166.2 C2167.1 C2168.1 C2169.2 C2170.2 C2171.2 C2172.2 C2174.1 C2175.1 C2176.1 C2177.1 C2178.1 C2179.2 C2180.1 C2181.1 C2182.1 C2183.1 C2184.1 C2185.1 C2186.1 C2187.2 C2188.2 C2189.1 C2190.1 C2191.1 C2192.1 C2193.1 C2194.1 C2195.1 C2196.2 C2197.2 C2198.1 C2199.1 C2200.1 C2201.1 C2202.1 C2203.1 C2204.2 C2205.2 C2206.2 C2207.1 C2208.1 C2209.2 C2210.1 C2211.1 C2212.1 C2213.1 C2214.2 C2215.2 C2216.1 C2217.1 C2218.1 C2219.1 C2220.1 C2221.2 C2222.1 C2223.1 C2224.2 C2225.1 C2226.1 C2227.1 C2228.1 C2229.1 C2230.1 C2231.1 C2232.2 C2233.2 C2234.1 C2235.1 C2236.1 C2237.2 C2238.2 C2239.2 C2240.2 C2241.2 C2242.2 C2243.2 C2244.2 C2245.2 C2246.1 C2247.1 C2248.2 C2249.1 C2251.2 C2252.2 C2253.2 C2254.1 C2255.1 C2256.2 C2257.2 C2258.1 C2259.1 C2260.1 C2261.1 C2262.1 C2263.1 C2264.1 C2265.1 C2266.1 C2267.2 C2268.1 C2269.2 C2270.1 C2271.2 C2272.2 C2273.2 C2274.1 C2275.1 C2276.1 C2277.2 C2278.2 C2279.2 C2280.1 C2281.1 C2282.1 C2283.2 C2284.2 C2285.1 C2286.1 C2287.2 C2288.2 C2289.2 C2290.1 C2291.1 C2292.1 C2293.2 C2294.2 C2295.2 C2296.1 C2297.2 C2298.2 C2299.1 C2300.2 C2301.1 C2302.2 C2305.2 C2306.2 C2307.2 C2308.1 C2309.1 C2310.2 C2311.2 C2312.1 C2313.2 C2314.2 C2315.2 C2316.2 C2317.2 C2318.2 C2319.1 C2320.2 C2321.1 C2322.2 C2334.2 C2335.1 C2336.2 C2337.2 C2339.2 C2342.2 C2343.2 C2344.2 C2345.2 C2346.2 C2347.1 C2348.1 C2349.2 C2350.2 C2351.2 C2352.2 C2353.2 C2354.1 C2355.1 C2357.2 C2358.2 C2359.2 C2360.2 C2361.2 C2362.2 C2363.1 C2369.1 C2374.2 C2418.2 C2419.2 C2420.2 C2531.2 C2532.2 C2533.2 C2534.2 C2535.2 C2536.2 C2537.2 C2538.1 C2539.1 C2540.1 C2541.1 C2542.1 C2543.2 C2544.1 C2545.1 C2546.2 C2559.1 C2562.1 C2563.1 C2564.1 C2565.1 C2566.1 C2567.1 C2568.1 C2569.1 C2570.1 C2573.1 C2575.1 C2577.1 C2578.2 C2579.1 C2580.1 C2581.2 C2582.2 C2583.2 C2584.1 C2586.1 C2587.2 C2588.2 C2589.2 C2590.1 C2591.2 C2592.1 C2593.1 C2594.1 C2595.2 C2596.1 C2598.2 C2599.2 C2601.1 C2602.2 C2603.2 C2606.2 C2607.2 C2608.1 C2609.2 C2610.2 C2611.2 C2612.2 C2616.1 C6502.2 C6503.2 C6504.2 C6505.1 C6544.2 C6545.2 C6546.2 C6547.2 C6548.2 C6549.2 C6560.2 C6562.1 C6563.2 C6565.2 C6568.1 C6569.2 C6570.2 C6571.2 C6572.2 C6573.2 C6574.2 C6575.2 C6577.2 C6578.2 C6580.1 C6581.2 C6582.1 C6583.1 C6584.1 C6598.2 C6599.2 C6600.2 C6601.2 C6602.2 C6603.2 C6604.2 C6605.2 C6606.1 C6607.2 C6608.2 C6610.1 C6615.1 C6616.1 C6617.1 C6624.1 C6625.1 C20000.2 C20002.1 C20003.1 C20004.2 C20005.1 C20006.1 C20016.1 C20017.2 C20020.2 C20021.2 C20022.1 C20023.1 C20024.2 C20025.1 C20026.1 CN1.2 CN2.4 CN2.7 CN2.10 CN2.11 CN2.12 CN2.13 CN3.4 CN3.7 CN3.10 CN3.11 CN3.12 CN3.13 CN8.9 CN8.10 CN8.11 CN8.12(GND#4) CN10.1 CN10.2 CN10.3 CN10.4 CN10.5 CN10.6 CN10.7 CN10.8 CN10.9 CN10.10 CN10.A1 CN10.A12 CN10.B1 CN10.B12 CN13.1 CN13.5 CN13.6 CN14.5 CN14.9 CN14.10 CN15.1 CN15.4 CN15.7 CN15.17 CN15.18 CN15.19 CN15.20 CN16.1 CN16.3 CN16.9 CN16.15 CN16.21 CN16.27 CN16.33 CN16.39 CN16.45 CN16.51 CN16.57 CN16.71 CN16.73 CN16.75 CN16.76 CN16.77 CN17.1 CN17.7 CN17.13 CN17.18 CN17.19 CN17.33 CN17.39 CN17.45 CN17.51 CN17.57 CN17.63 CN17.69 CN17.75 CN17.76 CN17.77 CN18.2 CN18.29 CN18.30 CN19.2 CN19.29 CN19.30 CN24.1 CN24.5 CN24.6 CN29.3 CN29.6 CN29.9 CN29.12 CN29.15 CN29.18 CN29.21 CN29.41 CN29.42 CN33.4 CN33.9 CN33.10 CN35.14 CN35.17 CN35.20 CN35.27 CN35.41 CN35.42 CN36.5 CN36.6 CN37.2 CN37.5 CN37.8 CN37.11 CN37.17 CN37.20 CN37.21 CN37.22 CN37.23 CN38.1 CN38.5 CN38.6 D16.1 D17.1 D18.1 D19.1 D22.1 D33.1 D50.1 D65.2 D6541.2 D6542.2 D13081.1 D13082.1 D13083.1 D13084.1 D13085.1 D13086.1 D13087.1 D13088.1 D13089.1 D13090.1 EC7.1 EC8.2 EC9.1 EC10.2 EC11.2 EC12.2 EC13.2 EC6500.2 FAN3.4 FAN3.5 FAN3.6 HD1.6 HD1.9 HD1.12 HD1.13 HD1.14 HE1.3 HOLE1.1 HOLE1.2 HOLE1.3 HOLE1.4 HOLE1.5 HOLE1.6 HOLE1.7 HOLE1.8 HOLE1.9 HOLE2.1 HOLE2.2 HOLE2.3 HOLE2.4 HOLE2.5 HOLE2.6 HOLE2.7 HOLE2.8 HOLE2.9 HOLE3.1 HOLE3.2 HOLE3.3 HOLE3.4 HOLE3.5 HOLE3.6 HOLE3.7 HOLE3.8 HOLE3.9 HOLE4.1 HOLE4.2 HOLE4.3 HOLE4.4 HOLE4.5 HOLE4.6 HOLE4.7 HOLE4.8 HOLE4.9 HOLE5.1 HOLE6.1 HOLE7.1 HOLE8.1 HOLE9.1 HOLE11.1 HOLE11.2 HOLE11.3 HOLE11.4 HOLE11.5 HOLE11.6 HOLE11.7 HOLE11.8 HOLE11.9 HOLE13.1 HOLE13.2 HOLE13.3 HOLE13.4 HOLE13.5 HOLE13.6 HOLE13.7 HOLE13.8 HOLE13.9 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 HOLE18.1 HOLE19.1 HOLE20.1 J2000.2 JDIM2000.1 JDIM2000.2 JDIM2000.5 JDIM2000.6 JDIM2000.9 JDIM2000.10 JDIM2000.14 JDIM2000.15 JDIM2000.18 JDIM2000.19 JDIM2000.22 JDIM2000.23 JDIM2000.26 JDIM2000.27 JDIM2000.30 JDIM2000.31 JDIM2000.35 JDIM2000.36 JDIM2000.39 JDIM2000.40 JDIM2000.43 JDIM2000.44 JDIM2000.47 JDIM2000.48 JDIM2000.51 JDIM2000.52 JDIM2000.56 JDIM2000.57 JDIM2000.60 JDIM2000.61 JDIM2000.64 JDIM2000.65 JDIM2000.68 JDIM2000.69 JDIM2000.72 JDIM2000.73 JDIM2000.77 JDIM2000.78 JDIM2000.81 JDIM2000.82 JDIM2000.85 JDIM2000.86 JDIM2000.89 JDIM2000.90 JDIM2000.93 JDIM2000.94 JDIM2000.98 JDIM2000.99 JDIM2000.102 JDIM2000.103 JDIM2000.106 JDIM2000.107 JDIM2000.167 JDIM2000.168 JDIM2000.171 JDIM2000.172 JDIM2000.175 JDIM2000.176 JDIM2000.180 JDIM2000.181 JDIM2000.184 JDIM2000.185 JDIM2000.188 JDIM2000.189 JDIM2000.192 JDIM2000.193 JDIM2000.196 JDIM2000.197 JDIM2000.201 JDIM2000.202 JDIM2000.205 JDIM2000.206 JDIM2000.209 JDIM2000.210 JDIM2000.213 JDIM2000.214 JDIM2000.217 JDIM2000.218 JDIM2000.222 JDIM2000.223 JDIM2000.226 JDIM2000.227 JDIM2000.230 JDIM2000.231 JDIM2000.234 JDIM2000.235 JDIM2000.238 JDIM2000.239 JDIM2000.243 JDIM2000.244 JDIM2000.247 JDIM2000.248 JDIM2000.251 JDIM2000.252 JDIM2000.261 JDIM2000.262 L11.2 PC4.1 PC5.2 PC6.1 PC7.2 PC8.1 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC16.2 PC18.1 PC19.2 PC20.1 PC35.2 PC36.1 PC37.1 PC51.2 PC81.2 PC82.2 PC83.1 PC152.2 PC162.2 PC164.2 PC165.2 PC166.2 PC167.1 PC168.2 PC170.2 PC172.2 PC217.2 PC218.2 PC219.2 PC220.2 PC221.2 PC222.2 PC224.2 PC227.2 PC229.2 PC230.2 PC231.2 PC233.2 PC234.2 PC236.1 PC242.2 PC268.1 PC276.2 PC280.2 PC283.2 PC285.1 PC288.2 PC289.2 PC290.1 PC292.1 PC293.2 PC294.2 PC295.2 PC296.2 PC297.2 PC298.2 PC299.2 PC300.1 PC302.2 PC304.2 PC305.2 PC306.2 PC423.2 PC551.1 PC561.2 PC562.2 PC563.2 PC571.2 PC572.2 PC581.2 PC756.2 PC6000.2 PC6002.1 PC6003.1 PC6004.2 PC6005.2 PC6006.2 PC6007.1 PC6008.2 PC6009.2 PC6010.2 PC6011.2 PC6012.2 PC6013.2 PC6014.2 PC6015.2 PC6016.2 PC6017.1 PC6018.2 PC6019.2 PC6020.2 PC6021.2 PC6022.2 PC6023.2 PC6025.2 PC6026.2 PC6027.2 PC6028.2 PC6029.2 PC6030.2 PC6031.1 PC6032.2 PC6033.2 PC6034.1 PC6036.2 PC6037.2 PC6038.2 PC6039.1 PC6040.2 PC6041.2 PC6042.2 PC6043.2 PC6044.2 PC6045.2 PC6046.2 PC6047.2 PC6048.2 PC6049.2 PC6050.2 PC6051.2 PC6052.2 PC6053.2 PC6054.2 PC6055.1 PC6056.2 PC6057.2 PC6058.2 PC6228.2 PC6229.1 PC6230.2 PC6231.2 PC7000.1 PC7001.2 PC7003.1 PC7004.2 PC7005.2 PC7006.2 PC7007.2 PC7009.2 PC7012.2 PC7013.2 PC7015.2 PC7018.2 PC7019.2 PC7023.2 PC7024.2 PC7025.1 PC7026.2 PC7027.1 PC7029.1 PC7030.1 PC7031.2 PC7032.2 PC7033.2 PC7034.2 PC7035.1 PC7036.2 PC7037.2 PC7038.2 PC7039.1 PC7040.2 PC7041.2 PC7042.2 PC7043.2 PC7044.2 PC7045.2 PC7046.1 PC7049.2 PC7050.2 PC7051.2 PC7052.2 PC7053.2 PC7054.1 PC7055.2 PC7057.1 PC7058.2 PC7059.2 PC7060.2 PC7061.2 PC7062.2 PC7063.2 PC7064.1 PC7066.2 PC7067.2 PC7068.2 PC7069.1 PC7070.2 PC7072.2 PC7073.2 PC7074.2 PC7075.2 PC7076.2 PC7077.2 PC7078.1 PC7080.2 PC7081.2 PC7082.2 PC7083.2 PC7084.2 PC7085.1 PC7086.2 PC7087.1 PC7088.2 PC7089.2 PC7090.2 PC7091.2 PC7092.2 PC7093.2 PC7094.2 PC7095.2 PC7096.1 PC7102.2 PC7104.2 PC7106.2 PC9000.2 PC9001.2 PC9002.2 PC9003.2 PC9004.2 PC9005.2 PC9006.2 PC9007.2 PC9009.2 PC9010.2 PC9011.2 PC9012.2 PC9013.2 PC9014.1 PC9015.2 PC9016.2 PC9017.2 PC9018.2 PC9019.2 PC9021.2 PC9022.2 PC9023.2 PC9024.2 PC9025.2 PC9026.2 PC9027.2 PC9029.2 PC9030.2 PC9053.2 PC9054.2 PC9055.2 PC9056.2 PC9057.2 PC9058.2 PC9059.2 PC9060.2 PC9062.2 PC9063.2 PC9064.2 PC9065.2 PC9066.2 PC9067.2 PC9068.2 PC9069.2 PC9071.2 PC9072.2 PC9073.2 PC9074.2 PC9075.2 PC9076.2 PC9077.2 PC9078.2 PC9080.2 PC9081.2 PC9082.2 PC9083.2 PC9084.2 PC9085.2 PC9086.2 PC9087.2 PC9088.2 PC9098.2 PD2.2 PD3.2 PD4.2 PJ1.1 PJ1.2 PJ1.9 PJ1.10 PJ2.2 PJ2.4 PJ2.5(SPRING & SHELL(-) #3) PQ6.1(S) PQ7.1(EMITTER) PQ10.1(S) PQ12.1(S) PQ14.1(S) PQ16.1(EMITTER) PQ17.1(S) PQ19.1(S) PQ25.1(S) PQ29.1 PQ29.2 PQ29.3(S3) PQ6000.1(S) PQ6001.1(S) PQ7000.10(S2) PQ7001.10(S2) PQ7003.1 PQ7003.2 PQ7003.3(S3) PQ7004.10(S2) PQ9000.10(S2) PQ9001.10(S2) PQ9009.1(S) PQ9010.1(S) PQ9011.1(S) PQ9050.1(S) PQ9083.1(EMITTER) PQ9084.1(S) PQ9085.1(S) PQ9086.1(S) PR10.2 PR23.2 PR40.2 PR80.2 PR118.2 PR120.2 PR205.1 PR206.2 PR207.2 PR211.1 PR230.2 PR253.1 PR273.2 PR283.2 PR567.1 PR3021.2 PR6007.2 PR6012.2 PR6014.1 PR6024.2 PR6031.1 PR7033.2 PR7034.2 PR7038.2 PR7040.2 PR7041.1 PR7042.1 PR7045.2 PR7052.2 PR7061.2 PR7104.1 PR9011.2 PR9022.1 PR9030.1 PR9031.1 PR9032.1 PR9034.2 PR9077.2 PR9082.1 PR9098.1 PR9101.2 PR9104.2 PR9105.2 PR9274.2 PU1.22 PU1.29 PU1.30 PU1.31 PU1.32 PU1.33 PU1.34 PU1.35 PU1.36 PU1.37 PU1.38 PU16.12 PU16.13 PU16.14 PU16.15 PU16.19 PU26.13 PU26.14 PU26.15 PU26.16 PU26.17 PU26.18 PU26.26 PU26.28 PU3002.2 PU3002.4 PU3003.2 PU3004.4 PU3004.8 PU3004.9 PU6000.4 PU6000.8 PU6001.11 PU6001.15 PU6002.11 PU6002.15 PU6003.4 PU6003.8 PU7000.49 PU7001.6 PU7001.9 PU7002.6 PU7002.9 PU7003.6 PU7003.9 PU7004.6 PU7004.9 PU9000.25 PU9002.11 PU9002.15 PU9003.2 PU9004.12 PU9004.13 PU9004.14 PU9004.15 PU9004.19 Q14.1(S) Q16.1(S) Q20.1(S) Q31.1(EMITTER) Q34.1(S) Q81.1(S) Q2013.1(S) Q2014.1(S) Q6508.2 Q6509.1(S) Q6515.1(S) Q6519.1(S) Q6519.4 Q6521.1(S) Q6521.4 Q6522.1(EMITTER) Q6533.1(S) Q6550.1(EMITTER) Q6551.1(EMITTER) Q6554.1(E2) Q6555.1(S) R183.2 R306.1 R311.2 R312.1 R313.2 R315.1 R317.2 R319.1 R320.2 R325.1 R326.2 R331.2 R332.2 R350.1 R351.1 R352.1 R353.1 R354.1 R355.1 R356.1 R357.1 R358.1 R394.2 R396.2 R398.1 R405.1 R406.1 R410.1 R414.2 R415.1 R416.2 R442.2 R446.1 R463.2 R464.2 R465.2 R467.2 R469.2 R470.2 R479.2 R497.2 R499.2 R504.2 R506.2 R507.2 R508.1 R510.1 R589.1 R654.1 R676.2 R677.2 R678.2 R679.1 R734.2 R748.2 R749.2 R890.2 R1234.2 R1235.2 R1236.2 R1250.2 R2132.2 R2134.2 R2138.2 R2142.2 R2158.2 R2159.2 R2160.1 R2161.1 R2163.1 R2164.1 R2166.1 R2186.2 R2190.2 R2191.2 R2192.1 R2194.2 R2197.1 R2199.2 R2200.2 R2201.1 R2202.1 R2203.2 R2204.2 R2205.1 R2206.2 R2207.1 R2213.2 R2219.2 R2221.2 R2222.2 R2223.2 R2227.2 R2275.2 R2279.2 R2302.2 R2309.1 R2358.1 R2449.2 R2450.1 R2453.2 R2455.1 R2457.2 R2480.1 R2481.1 R2485.1 R2488.2 R2492.2 R2502.2 R2505.2 R2510.1 R2524.2 R2532.1 R2537.1 R2541.2 R2543.1 R2545.1 R2558.2 R2559.2 R2560.1 R2561.2 R2563.1 R2564.1 R2565.1 R2566.1 R2567.1 R2577.1 R2580.1 R2581.1 R2582.1 R2583.1 R2584.1 R2585.1 R2587.2 R2609.1 R2649.2 R2651.1 R2660.2 R25270.2 R25272.1 R25275.1 R25277.1 R25279.1 R25282.1 R25298.2 R25303.2 R25311.2 R25316.2 R25320.2 R25369.2 R25485.2 R25492.2 R25495.2 R25506.1 R25511.1 R25539.2 R25546.2 R25551.1 R25552.1 R25587.1 RV1.3 RV2.3 RV2.8 RV3.3 RV3.8 SW1.3 SW1.4 SW3.1 SW3.2 SW3.5 SW3.6 TP9052.1 TP9054.1 TP9056.1 TP9057.1 TP9060.1 TP9062.1 TP9063.1 TP9066.1 TP9068.1 TP9069.1 TP9072.1 TP9074.1 U8.A2 U8.A26 U8.AA7 U8.AB7 U8.AB11 U8.AB14 U8.AB17 U8.AB20 U8.AB24 U8.AC2 U8.AC5 U8.AC8 U8.AC22 U8.AC26 U8.AD12 U8.AD13 U8.AD15 U8.AD16 U8.AD18 U8.AD19 U8.AD21 U8.AD22 U8.AE11 U8.AE14 U8.AE17 U8.AE20 U8.AF1 U8.AF5 U8.AF8 U8.AF11 U8.AF14 U8.AF17 U8.AF20 U8.AF23 U8.AG2 U8.AG26 U8.B1 U8.B5 U8.B8 U8.B11 U8.B14 U8.B17 U8.B20 U8.B23 U8.B27 U8.E2 U8.E5 U8.E8 U8.E11 U8.E14 U8.E17 U8.E20 U8.E22 U8.E25 U8.H2 U8.H5 U8.H23 U8.H25 U8.K11 U8.K13 U8.K15 U8.K17 U8.L2 U8.L5 U8.L10 U8.L12 U8.L14 U8.L16 U8.L18 U8.L23 U8.L25 U8.M11 U8.M13 U8.M15 U8.M17 U8.N10 U8.N12 U8.N14 U8.N16 U8.N18 U8.P2 U8.P5 U8.P11 U8.P13 U8.P15 U8.P17 U8.P23 U8.P26 U8.R10 U8.R12 U8.R14 U8.R16 U8.R18 U8.T11 U8.T13 U8.T15 U8.T17 U8.U2 U8.U5 U8.U10 U8.U12 U8.U14 U8.U16 U8.U18 U8.U23 U8.U26 U8.V11 U8.V13 U8.V15 U8.V17 U8.Y2 U8.Y5 U8.Y23 U8.Y26 U11.3 U14.14 U14.17 U15.2 U16.3 U16.8 U16.9 U16.11 U17.3 U17.8 U17.9 U17.11 U18.2 U19.2 U20.49 U23.17 U23.33 U23.34 U23.35 U23.36 U23.37 U24.33 U25.25 U32.5 U32.10 U32.12 U32.13 U32.15 U32.16 U33.16 U33.23 U33.33 U35.3 U36.3 U37.1 U37.27 U37.49 U37.91 U37.104 U42.3 U42.13 U42.18 U42.21 U42.22 U42.23 U42.24 U42.25 U42.26 U2009.A2 U2009.A8 U2009.B2 U2009.C9 U2009.D2 U2009.D8 U2009.E1 U2009.E3 U2009.E8 U2009.F1 U2009.G8 U2009.H1 U2009.H9 U2009.K1 U2009.K9 U2009.N1 U2009.N9 U2009.T1 U2010.A2 U2010.A8 U2010.B2 U2010.C9 U2010.D2 U2010.D8 U2010.E1 U2010.E3 U2010.E8 U2010.F1 U2010.G8 U2010.H1 U2010.H9 U2010.K1 U2010.K9 U2010.N1 U2010.N9 U2010.T1 U2011.A2 U2011.A8 U2011.B2 U2011.C9 U2011.D2 U2011.D8 U2011.E1 U2011.E3 U2011.E8 U2011.F1 U2011.G8 U2011.H1 U2011.H9 U2011.K1 U2011.K9 U2011.N1 U2011.N9 U2011.T1 U2012.A2 U2012.A8 U2012.B2 U2012.C9 U2012.D2 U2012.D8 U2012.E1 U2012.E3 U2012.E8 U2012.F1 U2012.G8 U2012.H1 U2012.H9 U2012.K1 U2012.K9 U2012.N1 U2012.N9 U2012.T1 U2014.3 U2015.3 U2019.3 U2029.3 U2030.A5 U2030.A67 U2030.A70 U2030.AA2 U2030.AA4 U2030.AA65 U2030.AA68 U2030.AB8 U2030.AB15 U2030.AB16 U2030.AB18 U2030.AB21 U2030.AD8 U2030.AD13 U2030.AD16 U2030.AD19 U2030.AD20 U2030.AD21 U2030.AD62 U2030.AE64 U2030.AE65 U2030.AE66 U2030.AE67 U2030.AE68 U2030.AE69 U2030.AF1 U2030.AF2 U2030.AF4 U2030.AF10 U2030.AF15 U2030.AF17 U2030.AF63 U2030.AG16 U2030.AG17 U2030.AG18 U2030.AG19 U2030.AG20 U2030.AG21 U2030.AG71 U2030.AH6 U2030.AH13 U2030.AH63 U2030.AH64 U2030.AH67 U2030.AJ4 U2030.AJ15 U2030.AJ18 U2030.AJ20 U2030.AK8 U2030.AK11 U2030.AK16 U2030.AK18 U2030.AK21 U2030.AK22 U2030.AK27 U2030.AK63 U2030.AK68 U2030.AK69 U2030.AL2 U2030.AL4 U2030.AL28 U2030.AL32 U2030.AL35 U2030.AL38 U2030.AL45 U2030.AL48 U2030.AL52 U2030.AL55 U2030.AL58 U2030.AL64 U2030.AL65 U2030.AL66 U2030.AM8 U2030.AM13 U2030.AM21 U2030.AM25 U2030.AM27 U2030.AM43 U2030.AM45 U2030.AM46 U2030.AM55 U2030.AM60 U2030.AM61 U2030.AM68 U2030.AM71 U2030.AN20 U2030.AN23 U2030.AN28 U2030.AN30 U2030.AN32 U2030.AN33 U2030.AN35 U2030.AN37 U2030.AN38 U2030.AN40 U2030.AN42 U2030.AN58 U2030.AN63 U2030.AP10 U2030.AP18 U2030.AP20 U2030.AP23 U2030.AP28 U2030.AP32 U2030.AP35 U2030.AP38 U2030.AP42 U2030.AP58 U2030.AP63 U2030.AP68 U2030.AP70 U2030.AR5 U2030.AR8 U2030.AR11 U2030.AR15 U2030.AR16 U2030.AR20 U2030.AR23 U2030.AR28 U2030.AR35 U2030.AR42 U2030.AR43 U2030.AR45 U2030.AR46 U2030.AR48 U2030.AR50 U2030.AR52 U2030.AR53 U2030.AR55 U2030.AR58 U2030.AR63 U2030.AT2 U2030.AT4 U2030.AT20 U2030.AT23 U2030.AT28 U2030.AT35 U2030.AT42 U2030.AT56 U2030.AT58 U2030.AT63 U2030.AT68 U2030.AT71 U2030.AU10 U2030.AU15 U2030.AU20 U2030.AU32 U2030.AU38 U2030.AV1 U2030.AV68 U2030.AV69 U2030.AV70 U2030.AV71 U2030.AW6 U2030.AW8 U2030.AW10 U2030.AW12 U2030.AW14 U2030.AW16 U2030.AW18 U2030.AW21 U2030.AW23 U2030.AW26 U2030.AW28 U2030.AW30 U2030.AW32 U2030.AW34 U2030.AW36 U2030.AW38 U2030.AW41 U2030.AW43 U2030.AW45 U2030.AW47 U2030.AW49 U2030.AW51 U2030.AW53 U2030.AW55 U2030.AW57 U2030.AW60 U2030.AW62 U2030.AW64 U2030.AW66 U2030.AY66 U2030.B10 U2030.B14 U2030.B18 U2030.B22 U2030.B30 U2030.B34 U2030.B39 U2030.B44 U2030.B48 U2030.B53 U2030.B58 U2030.B62 U2030.B66 U2030.B71 U2030.BA1 U2030.BA2 U2030.BA6 U2030.BA10 U2030.BA14 U2030.BA18 U2030.BA23 U2030.BA28 U2030.BA32 U2030.BA36 U2030.BA41 U2030.BA45 U2030.BA49 U2030.BA53 U2030.BA57 U2030.BA62 U2030.BA66 U2030.BA71 U2030.BB6 U2030.BB18 U2030.BB26 U2030.BB30 U2030.BB34 U2030.BB38 U2030.BB43 U2030.BB55 U2030.BB60 U2030.BB64 U2030.BB67 U2030.BB70 U2030.C1 U2030.C5 U2030.C25 U2030.D6 U2030.D10 U2030.D11 U2030.D14 U2030.D18 U2030.D22 U2030.D25 U2030.D26 U2030.D30 U2030.D34 U2030.D39 U2030.D44 U2030.D45 U2030.D47 U2030.D48 U2030.D53 U2030.D58 U2030.D62 U2030.D66 U2030.D69 U2030.E6 U2030.E11 U2030.E15 U2030.E18 U2030.E21 U2030.E46 U2030.E50 U2030.E53 U2030.E56 U2030.E65 U2030.E71 U2030.F1 U2030.F2 U2030.F4 U2030.F8 U2030.F13 U2030.F22 U2030.F23 U2030.F27 U2030.F28 U2030.F32 U2030.F33 U2030.F35 U2030.F37 U2030.F38 U2030.F40 U2030.F42 U2030.F68 U2030.G5 U2030.G6 U2030.G10 U2030.G22 U2030.G43 U2030.G45 U2030.G48 U2030.G52 U2030.G55 U2030.G58 U2030.G60 U2030.G63 U2030.G66 U2030.H15 U2030.H18 U2030.H71 U2030.J8 U2030.J11 U2030.J13 U2030.J25 U2030.J28 U2030.J32 U2030.J35 U2030.J38 U2030.J42 U2030.K16 U2030.K18 U2030.K22 U2030.K61 U2030.K63 U2030.K64 U2030.K65 U2030.K66 U2030.K67 U2030.K68 U2030.K70 U2030.K71 U2030.L2 U2030.L4 U2030.L8 U2030.L11 U2030.L16 U2030.L17 U2030.L18 U2030.L20 U2030.N6 U2030.N10 U2030.N13 U2030.N19 U2030.N21 U2030.N65 U2030.N68 U2030.P17 U2030.P19 U2030.P20 U2030.P21 U2030.R6 U2030.R13 U2030.T2 U2030.T4 U2030.T15 U2030.T17 U2030.T18 U2030.T21 U2030.U10 U2030.U63 U2030.U64 U2030.U66 U2030.U67 U2030.U69 U2030.U70 U2030.V16 U2030.V17 U2030.V18 U2030.W6 U2030.W9 U2030.W13 U2030.Y17 U2030.Y19 U2030.Y20 U2030.Y21 U2031.4 U6502.3 U6502.19 U6503.12 U6503.21 U6503.22 U6503.23 U6503.24 U6503.25 U6503.26 U6503.27 U6504.3 U6505.3 VC2.2 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.J1 VRAM1.J10 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM2.A1 VRAM2.A3 VRAM2.A12 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C3 VRAM2.C4 VRAM2.C11 VRAM2.C12 VRAM2.C14 VRAM2.D10 VRAM2.E1 VRAM2.E3 VRAM2.E12 VRAM2.E14 VRAM2.F5 VRAM2.F10 VRAM2.G5 VRAM2.G10 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.J1 VRAM2.J10 VRAM2.K1 VRAM2.K2 VRAM2.K13 VRAM2.K14 VRAM2.L5 VRAM2.L10 VRAM2.M5 VRAM2.M10 VRAM2.N1 VRAM2.N3 VRAM2.N12 VRAM2.N14 VRAM2.P10 VRAM2.R1 VRAM2.R3 VRAM2.R4 VRAM2.R11 VRAM2.R12 VRAM2.R14 VRAM2.T5 VRAM2.T10 VRAM2.U1 VRAM2.U3 VRAM2.U12 VRAM2.U14 Y3.2 Y3.4 Y4.2 Y4.4 Y2002.2 Y2002.4 Y2003.2 Y2003.4
V0P85A_VID0: TP2044.1 U2030.AN11
V3A_BOOT: PR6000.2 PU6000.1
V3A_BOOT_R: PC6001.1 PR6000.1
V3A_EN: PC6007.2 PR6002.1 PR6006.2 PU6000.6
V3A_PWRGD: PR6005.1 PU6000.7
V3A_VBYP: PC6023.1 PR6009.2 PR6017.1 PU6000.11
V3A_VOUT: PC6017.2 PR6008.2 PR6010.2 PR6011.2 PU6000.10(VOUT)
V5P5A_BOOT: PC6035.1 PU6003.1
V5P5A_BOOT_R: PC6035.2 PR6018.2
V5P5A_EN: PC6039.2 PR6020.1 PR6021.2 PU6003.6
V5P5A_PWRGD: PR6022.1 PU6003.7
V5P5A_VOUT: PC6055.2 PR6026.1 PR6029.2 PR6030.2 PU6003.10(VOUT)
VCC1_CORE: PC7106.1 PR7108.2 PU7002.8(VCC)
VCC2_CORE: PC7063.1 PR7080.2 PU7001.8(VCC)
VCC_GT: PC7102.1 PR7112.2 PU7003.8(VCC)
VCC_SA: PC7104.1 PR7116.2 PU7004.8(VCC)
VCCGT_SENSE: PR7050.1 PR7051.1 R2456.2 U2030.J70
VCCSA_SENSE: PR7057.1 PR7058.1 R2193.2 U2030.H20
VCCST_PWRGD: C2312.2 C2542.2 R2228.1 U2030.B65
VCCST_PWRGD_EN: R2252.2 R2256.1 R2257.1 U2014.2
VCCST_PWRGD_EN_L: C2336.1 C2337.1 R2252.1 U2014.4 U2015.2
VCCST_PWRGD_R: R2228.2 R2229.1 U2015.4(Y)
VSSGT_SENSE: PR7052.1 PR7053.1 R2455.2 U2030.J69
VSSSA_SENSE: PR7061.1 PR7062.1 R2194.1 U2030.H21
1.03_GFX_PGD: PR9076.1 PR9078.2 PR9096.1
2ND_MBCLK: Q13.3 R383.1 R740.2 R2538.1 U37.115
2ND_MBDATA: Q13.6 R739.2 R2539.1 R25304.1 U37.116
27M_XTAL_IN: C463.1 U8.C11 Y3.3
27M_XTAL_OUT: C464.1 U8.B10 Y3.1
3602_ALERT#: PR7020.1 PU7000.33
3602_CLK: PR7015.2 PU7000.34
3602_DRON: PR7079.1 PR7107.1 PR7111.1 PR7115.1 PU7000.35
3602_PSYS: PC7006.1 PR7039.2 PR7042.2 PU7000.46
3602_SET1: PR7027.2 PR7035.2 PU7000.2
3602_SET2: PR7028.2 PR7036.1 PU7000.5
3602_SET3: PR7029.2 PR7037.1 PU7000.6
3602_TSENSE_CORE: PR7026.2 PR7032.1 PU7000.11
3602_TSENSE_GT: PR7018.2 PR7021.1 PU7000.23
3602_VCC: PC7026.1 PR7064.2 PU7000.13
3602_VDIO: PR7019.2 PU7000.32
3602_VIN: PC7000.2 PR7000.1 PU7000.12
3602_VREF: PR7004.1 PR7005.1 PR7006.2 PR7008.1 PR7009.1 PR7010.1 PR7013.1 PR7022.2 PR7023.2 PR7024.2 PU7000.42
3602_VRHOT: PR7011.1 PR7012.1 PU7000.31(V\R\H\O\T\)
5213EN_1.8V: PC581.1 PR566.1 PU3004.7
5213FB_1.8V: PC574.2 PR567.2 PR568.2 PU3004.1
5213FB_1.8V_S: PC574.1 PR568.1 PR569.1
5213LX_1.8V: PL551.1 PR551.1 PU3004.6
5213PG_1.8V: PR9256.2 PU3004.2
5416_VCC: PC268.2 PR256.1 PU26.7
5447_CC1_CON: C691.2 CN10.A5 D16.2 U6503.11
5447_CC2_CON: C692.2 CN10.B5 D17.2 U6503.13
8813BOOT1: PC9008.2 PU9000.1
8813BOOT2: PC9020.2 PU9000.18
8813EN: PC9013.1 PR9012.1 PR9278.2 PR25542.2 PU9000.3
8813ILIM: PC9030.1 PR9032.2 PU9000.12
8813ISEN1: PC9014.2 PR9013.2 PU9000.15
8813ISEN2: PR9025.2 PU9000.14
8813LGAT1: PQ9000.8 PR9011.1 PU9000.23
8813LGAT2: PQ9001.8 PU9000.20
8813PG: PR9008.2 PR9009.2 PR9283.2 PU9000.16
8813PHASE1: PC9008.1 PL9001.1 PQ9000.5 PQ9000.6 PQ9000.7 PR9004.2 PU9000.24
8813PHASE2: PC9020.1 PL9000.1 PQ9001.5 PQ9001.6 PQ9001.7 PR9019.2 PU9000.19
8813PSI: PR9016.2 PR9018.2 PR9022.2 PU9000.4
8813PVCC: PC9000.1 PR9001.2 PU9000.21
8813REFADJ: PR9023.2 PU9000.6
8813REFIN: PC9026.1 PR9024.2 PR9027.1 PU9000.7
8813RGN: PC9028.2 PC9029.1 PR9029.1 PU9000.10
8813TON: PR9002.2 PU9000.9
8813UGATE1: PR9006.1 PU9000.2
8813UGATE1_1: PQ9000.1 PR9006.2
8813UGATE2: PR9014.1 PU9000.17
8813UGATE2_1: PQ9001.1 PR9014.2
9336ADJ: PR9081.2 PR9082.2 PU9003.5
9336DRV: PD9001.1(CATHODE) PQ9008.4 PR9080.1 PU9003.6
24780_ACDET: PQ17.3 PR31.2 PR211.2 PU1.6
24780_ACDRV: PR29.2 PU1.4
24780_ACN: PC25.2 PC35.1 PR2.2 PU1.1
24780_ACP: PC25.1 PC36.2 PR1.2 PU1.2
24780_BATDRV: PR4.2 PU1.18
24780_BATSRC: PR7.2 PU1.17
24780_BM#: PR9.1 PU1.16
24780_BST: PR11.1 PU1.25
24780_CMPIN: PR207.1 PU1.13
24780_CMPOUT: PR15.1 PU1.14
24780_CMSRC: PR28.2 PU1.3
24780_DH: PQ30.4 PU1.26
24780_DL: PQ29.4 PU1.23
24780_ILIM: PC8.2 PR204.1 PR206.1 PU1.21
24780_LX: PC15.1 PL5.1 PQ29.5 PQ30.1 PQ30.2 PQ30.3(S3) PR33.1 PU1.27
24780_SRN: PC3.1 PC4.2 PR6.2 PR208.1
24780_SRP: PC3.2 PC6.2 PR5.2 PR210.1
24780_VCC: PC16.1 PR16.1 PU1.28(VCC)
25810_AUO#: R6508.2 U6503.17
25810_DBG#: R6510.2 U6503.16
25810_FAULT#: R6504.2 U6503.1
25810_LD_DET#: R6505.2 U6503.20
25810_POL#: R6507.2 R9041.2 R25280.1 R25590.2 U6503.18
25810_REF: R6517.1 U6503.10
25810_REF_RTN: R6517.2 U6503.9
25810_UFP#: Q6505.3 Q6519.2 R6506.2 R25337.1 U6503.19
+1.03_GFX: C347.2 C348.2 C349.2 C350.2 C354.1 C363.2 C366.1 L31.1 L32.1 PJ9003.2 PR9081.1 R25509.1 R25510.1 R25515.1 TP63.1 U8.AA22 U8.AB23 U8.AC24 U8.AD25 U8.AE26 U8.AE27
+601_VCC: C6598.1 C6599.1 C6600.1 C6601.1 C6602.1 C6607.1 R495.1 R498.1 R500.1 R503.1 R505.1 R1237.1 R1238.1 R1239.1 U42.10 U42.20(VCC#2)
+AZA_VDD: C565.1 C580.1 C581.1 R455.2 R478.1 U20.1 U20.36
+FB_PLLAVDD: C453.2 C454.2 C455.2 C456.1 L5.2 U8.F16 U8.H22 U8.P22
+G_SEN_PW: C6603.1 C6608.1 R582.2 R25355.1 R25356.1 U32.1(VDD_IO) U32.8 U32.14
+PEX_IOVDDQ: C360.2 C362.1 C377.2 C379.2 C381.2 C383.2 C395.1 C399.1 C402.1 L5.1 R25507.2 R25508.2 R25509.2 R25510.2 U8.AA10 U8.AA12 U8.AA13 U8.AA16 U8.AA18 U8.AA19 U8.AA20 U8.AA21 U8.AB22 U8.AC23 U8.AD24 U8.AE25 U8.AF26 U8.AF27
+PEX_PLL_HVDD: C425.2 C429.2 C431.2 R299.1 R25562.1 U8.AA8 U8.AA9
+PEX_SVDD_3V3: R25562.2 U8.AB8
+SMDDR_VREF_DQ1_M1: C2085.1 C2086.2 C2104.2 C2105.1 C2163.2 C2164.2 C2165.2 C2236.2 C2247.2 R2132.1 R2135.2 R2136.2 R2140.2 U2009.M1 U2010.M1 U2011.M1 U2012.M1
+TP_PWR_C: C6624.2 C6625.2 CN29.30 CN29.31 R25462.2 R25465.2
+TYPEC_VBUS: C675.2 C676.2 C6582.2 CN10.A4 CN10.A9 CN10.B4 CN10.B9(VBUSB9) D6541.1 Q6516.1 Q6516.2 Q6516.3(S3) Q6518.1 R25339.2 R25340.1 R25342.1
+TYPEC_VBUS_C: C6505.2 C6581.1 Q6516.5 U6503.14 U6503.15
+USBPWR0: C509.2 C510.2 C511.2 C514.2 CN2.1(VBUS) R25363.1 R25364.1 U14.12(VOUT) U16.2(VDD)
+USBPWR1: C515.2 C516.2 C517.2 C525.2 CN3.1(VBUS) R25363.2 R25364.2 U15.1(OUT) U17.2(VDD)
+VGPU_CORE: C351.2 C352.2 C353.2 C355.2 C356.2 C357.2 C359.2 C365.2 C367.2 C368.2 C369.2 C372.2 C373.2 C374.2 C385.1 C387.2 C388.2 C389.2 C391.2 C393.2 C396.2 C397.2 C400.2 C403.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.1 C414.1 C415.2 C416.1 C417.1 C418.2 C419.1 C420.1 C421.2 C422.2 C423.2 C424.2 C426.2 C427.2 C428.2 C430.2 C432.2 PC9009.1 PC9010.1 PC9011.1 PC9021.1 PC9022.1 PL9000.2 PL9001.2 PR9026.1 U8.K10 U8.K12 U8.K14 U8.K16 U8.K18 U8.L11 U8.L13 U8.L15 U8.L17 U8.M10 U8.M12 U8.M14 U8.M16 U8.M18 U8.N11 U8.N13 U8.N15 U8.N17 U8.P10 U8.P12 U8.P14 U8.P16 U8.P18 U8.R11 U8.R13 U8.R15 U8.R17 U8.T10 U8.T12 U8.T14 U8.T16 U8.T18 U8.U11 U8.U13 U8.U15 U8.U17 U8.V10 U8.V12 U8.V14 U8.V16 U8.V18
+VREF_CA_CPU: C2250.1 R2195.1 U2030.AY67
+VREF_CA_DIMM0: C2288.1 C2289.1 JDIM2000.164 R2195.2 R2196.2 R2198.2 R2200.1
+VREFDQ_SA_M3: TP2022.1 U2030.AY68
+VREFDQ_SB_M3: C2103.1 R2136.1 U2030.BA67
A3_A5: R25505.1 R25506.2 U37.83
AC_PRESENT_EC: R2515.2 U37.84
ACCEL_INT2: D21.1(CATHODE) R25483.2
ACCEL_INT2_R: D21.2 U32.9
ACCEL_INTA: C6606.2 D20.1(CATHODE) R25474.2 U2030.AB1
ACCEL_INTA_R: D20.2 U32.11
ACIN: PR30.1 PR39.2 PR40.1 U37.72
ACZ_SPKR: D11.2 R2541.1 R2555.2 U2030.AW5
ADOGND: C563.1 C564.2 C568.2 C569.2 C572.1 C573.2 C586.1 C588.1 C590.1 C591.1 C592.1 C593.1 C598.1 C599.2 C845.2 CN35.1 CN35.3 CN35.5 CN35.12 R447.1 R463.1 R464.1 R465.1 R467.1 R469.1 R470.1 R474.2 R475.2 U20.25 U20.38
ADP_ID: PJ2.3 PQ17.2 PR230.1 PR235.2
ALERT: R397.1 U8.F8
AMP_MUTE#: D13.1(CATHODE) U37.108
AP_EQ: R25273.1 R25279.2 U6502.9
BAT-V: PC164.1 PC165.1 PC166.1 PC167.2 PC168.1 PD9002.2 PJ1.7 PJ1.8 PR208.2 PR209.2
BATLED0#: CN35.24 U37.29
BATLED1#: CN35.23 U37.25
BI: PJ1.6 PR10.1 R25321.2 SW2.1 SW2.2
BL#: Q6521.2 Q6521.3 R25368.1
BL_ON: CN29.26 D3.2 Q6521.6 Q6522.3 R25367.1
BOARD_ID0: R2582.2 R2601.1 U2030.AB11
BOARD_ID1: R2581.2 R2600.1 U2030.AB13
BOARD_ID2: R2583.2 R2602.1 U2030.AB12
BOARD_ID3: R2580.2 R2599.1 U2030.W12
BOARD_ID4: C20025.2 R2585.2 R2598.1 R25598.1 U2030.W11
BOARD_ID5: R2560.2 R2562.1 U2030.W10
BOARD_ID6: C20026.2 R2563.2 R2595.1 R25599.1 U2030.W8
BOARD_ID7: R2577.2 R2594.1 U2030.W7
BRIGHT: R439.2 R441.1 R443.2
BT_EN: CN17.54(W_DISABLE2#) R671.1 R960.2
BXTALOUT: R330.1 R332.1 U8.C10
C_IN_CLK: C1681.2 CN37.10 D13087.2 R489.1 R703.2 R706.1
C_IN_CLK#: C1679.2 CN37.12 D13088.2 R489.2 R702.2 R707.1
C_IN_CLK#_R: C847.2 U23.31
C_IN_CLK_R: C849.2 U23.32
C_TX0_HDMI+: C1684.2 CN37.7 D13085.2 R487.1 R697.2 R712.1
C_TX0_HDMI+_R: C852.2 U23.26
C_TX0_HDMI-: C1685.2 CN37.9 D13086.2 R487.2 R696.2 R713.1
C_TX0_HDMI-_R: C853.2 U23.25
C_TX1_HDMI+: C1683.2 CN37.4 D13083.2 R486.1 R699.2 R710.1
C_TX1_HDMI+_R: C851.2 U23.28
C_TX1_HDMI-: C1680.2 CN37.6 D13084.2 R486.2 R698.2 R711.1
C_TX1_HDMI-_R: C848.2 U23.27
C_TX2_HDMI+: C1686.2 CN37.1 D13081.2 R484.1 R701.2 R708.1
C_TX2_HDMI+_R: C854.2 U23.30
C_TX2_HDMI-: C1682.2 CN37.3 D13082.2 R484.2 R700.2 R709.1
C_TX2_HDMI-_R: C850.2 U23.29
CATERR#: R2479.2 TP2071.1 U2030.D63
CFG4: R2449.1 U2030.E70
CFG_RCOMP: R2166.2 U2030.E60
CHA_SA0: JDIM2000.256 R2273.2 R2279.1
CHA_SA1: JDIM2000.260 R2274.2 R2275.1
CHA_SA2: JDIM2000.166 R2206.1 R2208.2
CLK_24M_DEBUG: R655.1 R674.2 R2548.1
CLK_24M_DEBUG_R: CN17.60 R674.1
CLK_PCI_EC: R402.2 R2569.1 U37.13
CLK_PCI_EC_R: C2592.2 R2569.2 U2030.AW9
CLK_PCI_LPC_R: C2590.2 R2548.2 U2030.AY9
CLK_PCIE_LANN: U24.16 U2030.B40
CLK_PCIE_LANP: U24.15 U2030.A40
CLK_PCIE_REQ0#: R226.2 R2278.2 U2030.AR10
CLK_PCIE_REQ1#: R2281.2 R2285.2 U2030.AT7
CLK_PCIE_REQ2#: R2612.2 TP2088.1 U2030.AT8
CLK_PCIE_REQ3#: R2615.2 TP2089.1 U2030.AT10
CLK_PCIE_REQ4#: R2301.2 R2305.2 U2030.AU8
CLK_PCIE_REQ5#: R2286.2 R2307.2 U2030.AU7
CLK_PCIE_SSDN: R2658.1 U2030.B42
CLK_PCIE_SSDN_C: CN16.53 R2658.2
CLK_PCIE_SSDP: R2659.1 U2030.A42
CLK_PCIE_SSDP_C: CN16.55 R2659.2
CLK_PCIE_WLANN: CN17.49 U2030.E40
CLK_PCIE_WLANP: CN17.47 U2030.E38
CLK_PCIE_XDPN: TP2025.1 U2030.F43
CLK_PCIE_XDPP: TP2026.1 U2030.E43
CLK_VGA_N: U8.AD8 U2030.D42
CLK_VGA_P: U8.AE8 U2030.C42
CLKRUN#: R2536.2 U37.93 U2030.AW11
CLR_CMOS: Q2013.2 Q2014.2 R2203.1 U37.19
CNV_BRI_DT: CN17.36 R664.2
CNV_BRI_RSP: R665.2
CNV_BRI_RSP_L: CN17.22 R665.1
CNV_RF_RESET#: R677.1 U35.1 U35.2
CNV_RF_RESET#_L: CN17.10 R676.1 U35.4
CNV_RGI_DT: CN17.32 R180.2 R183.1
CNV_RGI_RSP: R667.2
CNV_RGI_RSP_L: CN17.34 R667.1
CNV_WR_CLK_DN: CN17.21
CNV_WR_CLK_DP: CN17.23
CNV_WR_LANE0_DN: CN17.15
CNV_WR_LANE0_DP: CN17.17
CNV_WR_LANE1_DN: CN17.9
CNV_WR_LANE1_DP: CN17.11
CNV_WT_CLK_DN: CN17.71
CNV_WT_CLK_DP: CN17.73
CNV_WT_LANE0_DN: CN17.65
CNV_WT_LANE0_DP: CN17.67
CNV_WT_LANE1_DN: CN17.59
CNV_WT_LANE1_DP: CN17.61
CODEC_VREF: C563.2 U20.28(VREF)
COMP_CORE: PC7011.1 PR7048.2 PU7000.4
COMP_GT: PC7017.1 PR7055.2 PU7000.26
COMP_SA: PC7021.1 PR7060.2 PU7000.43
CON_DE: R25275.2 R25278.1 U6502.15
CON_EQ: R25272.2 R25274.1 U6502.18
CPU_C10_GATE#_R: PQ35.4 PR2060.1 PR9272.2
CPU_DRAMRST#: R2526.2 R2528.1 U2030.AT13
CPU_THRMTRIP#: R2475.2 R2476.2 U2030.C63
CRT_CLK: R2590.1 U2030.N7
CRT_DATA: R2589.1 U2030.N8
CRT_HPD: R2559.1 U2030.L7
CTL2: R418.2 U14.7
CTL3: R417.2 U14.8
D/C#: PC20.2 PR26.1 TP9001.1
DC-DET: R732.1 R25495.1 U20.4
DCPRTC: C2598.1 U2030.BB10
DDCCLK_RIN: Q41.4 R775.2
DDCDATA_RIN: Q41.1(S) R777.2
DDR4_SUSON_2V5: PR9273.2 U37.122
DDR_DRAMRST#: C2180.2 C2588.1 JDIM2000.108 R2528.2 R2532.2 U2009.P1 U2010.P1 U2011.P1 U2012.P1
DDR_VTT_CTRL: Q2023.1(EMITTER) R2450.2 U2030.AW67
DDR_VTTT_PG_CTRL_R: Q2023.3 R2448.1 TP2093.1
DE1: R503.2 R1235.1 U42.9
DE2: R504.1 R505.2 U42.8
DEVSLP0: R2544.2 R25484.2 U2030.J1
DEVSLP0_R: HD1.5 R25484.1
DEVSLP1: R2557.2 U2030.J2
DEVSLP2: R645.2 R2542.2 U2030.J3
DEW1: R499.1 R500.2 U42.16
DEW2: R506.1 R1237.2 U42.6
DGPU_EDIDCLK: R363.1 U8.A9
DGPU_EDIDDATA: R366.1 U8.B9
DGPU_HOLD_RST#: R2288.1 U2030.AP7 U6504.1
DGPU_OPP#: Q6512.3 R378.1 U37.71
DGPU_OVT#_EC: Q15.3 R340.1 R385.2 U37.68
DGPU_PGOK-1: C20020.1 Q6554.6 Q6555.2 R25548.1
DGPU_POK2: C20021.1 Q6554.2 R25549.1
DGPU_PROCHOT_EC#: Q6512.1(S) R25322.1 R25576.1 U8.D7
DGPU_PSI: PR9016.1 R376.2 R391.1 R25570.2
DGPU_PW_CTRL#: R2537.2 R2549.1 U2030.BA5
DGPU_PWR_EN: PR9070.2 PR9277.1 R323.1 R2648.1 R2649.1 U2030.AP8
DGPU_PWROK: Q6555.3 R2613.1 R25546.1 R25547.1 R25550.2 U2030.AM5
DISP_ON: R445.1 R446.2 U19.3
DMIC-DATA34: R453.1 TP9024.1
DMIC_CLK: R461.2 U20.3
DMIC_CLK_2: CN38.3 R25498.1
DMIC_CLK_2_R: C6617.2 R25498.2 U2030.H5
DMIC_CLK_L: C583.2 L12.2 R461.1
DMIC_CLK_L_C: C548.1 CN29.1 L12.1
DMIC_DAT: R459.1 U20.2
DMIC_DAT_2: CN38.2 R25497.1
DMIC_DAT_2_R: R25497.2 U2030.D7
DMIC_DAT_L: L13.2 R459.2
DMIC_DAT_L_C: C547.1 CN29.2 L13.1
DNBSWON#: R2523.2 U37.123
DP_UTIL: R2488.1 R2489.1 U2030.B52
DPWROK_R: R2503.1 U2030.BB20
DRVEN_SET: PR7103.1 PR7104.2 PU7000.18
EC_FPBACK#: Q6522.2 U37.86
EC_ODD_EJ#: CN15.16 R638.1 R25328.1
EC_ODD_EJ_R#: C2607.1 R25328.2 U37.94
EC_PECI: R380.2 U2030.A54
EC_PECR_R: R380.1 U37.117
EC_PWROK: R2500.1 R2510.2 R2511.1 R2512.1 U37.33
EC_PWROK_R: R2500.2 R2507.2 U2030.BA20
EC_RCIN#: R2518.1 R2521.2 U2030.AW13
EC_TYPEC_CHG: R6515.2 U6503.7
EC_TYPEC_CHG_HI: R6516.2 U37.3 U6503.8
EC_TYPEC_EN: R2356.1 U37.80
EC_TYPEC_EN_R: R2356.2 R25586.2 U6503.6
ECAGND: C6564.1 C6566.2 L11.1 U37.75
EDP_RCOMP: R2171.1 U2030.E52
EDRAM_OPIO_RCOMP: R2160.2 U2030.H66
EMMC_RCOMP: R2584.2 U2030.AT1
EN: R1236.1 R1238.2 U42.7
EN1_CORE: PR7107.2 PU7002.1
EN2_CORE: PR7079.2 PU7001.1
EN_GT: PR7111.2 PU7003.1
EN_SA: PR7115.2 PU7004.1
EOPIO_RCOMP: R2161.2 U2030.H65
EQ1: R497.1 R498.2 U42.17
EQ2: R495.2 R1234.1 U42.19
FAN1_RPM: FAN3.2 R25372.2 U37.47
FAN_PWM: Q6523.1(EMITTER) U37.32
FAN_PWM_C: FAN3.3 Q6523.3 R25373.2
FB_CAL_PD_VDDQ: R318.2 U8.D22
FB_CAL_PU_GND: R319.2 U8.C24
FB_CAL_TERM_GND: R320.1 U8.B25
FB_CORE: PC7010.2 PC7011.2 PR7047.1 PR7048.1 PR7049.2 PU7000.3
FB_GT: PC7016.1 PC7017.2 PR7054.1 PR7055.1 PR7056.2 PU7000.24
FB_SA: PC7020.2 PC7021.2 PR7059.1 PR7060.1 PR7063.1 PU7000.45
FBA_CMD0: U8.C27 VRAM1.G12
FBA_CMD1: U8.C26 VRAM1.H10
FBA_CMD2: U8.E24 VRAM1.H11
FBA_CMD3: U8.F24 VRAM1.K11
FBA_CMD4: U8.D27 VRAM1.K10
FBA_CMD5: U8.D26 VRAM1.L12
FBA_CMD6: U8.F25 VRAM1.K4
FBA_CMD7: U8.F26 VRAM1.K5
FBA_CMD8: U8.F23 VRAM1.J4
FBA_CMD9: U8.G22 VRAM1.J5
FBA_CMD10: U8.G23 VRAM1.H4
FBA_CMD11: U8.G24 VRAM1.H5
FBA_CMD12: U8.F27 VRAM1.G3
FBA_CMD13: R315.2 U8.G25 VRAM1.J2
FBA_CMD14: R316.2 U8.G27 VRAM1.J3
FBA_CMD15: U8.G26 VRAM1.L3
FBA_CMD16: U8.M24 VRAM2.G12
FBA_CMD17: U8.M23 VRAM2.H10
FBA_CMD18: U8.K24 VRAM2.H11
FBA_CMD19: U8.K23 VRAM2.K11
FBA_CMD20: U8.M27 VRAM2.K10
FBA_CMD21: U8.M26 VRAM2.L12
FBA_CMD22: U8.M25 VRAM2.K4
FBA_CMD23: U8.K26 VRAM2.K5
FBA_CMD24: U8.K22 VRAM2.J4
FBA_CMD25: U8.J23 VRAM2.J5
FBA_CMD26: U8.J25 VRAM2.H4
FBA_CMD27: U8.J24 VRAM2.H5
FBA_CMD28: U8.K27 VRAM2.G3
FBA_CMD29: R317.1 U8.K25 VRAM2.J2
FBA_CMD30: R314.1 U8.J27 VRAM2.J3
FBA_CMD31: U8.J26 VRAM2.L3
FBA_DBI0: U8.D19 VRAM1.D2
FBA_DBI1: U8.D14 VRAM1.D13
FBA_DBI2: U8.C17 VRAM1.P13
FBA_DBI3: U8.C22 VRAM1.P2
FBA_DBI4: U8.P24 VRAM2.P13
FBA_DBI5: U8.W24 VRAM2.P2
FBA_DBI6: U8.AA25 VRAM2.D2
FBA_DBI7: U8.U25 VRAM2.D13
FBA_EDC0: U8.E19 VRAM1.C2
FBA_EDC1: U8.C15 VRAM1.C13
FBA_EDC2: U8.B16 VRAM1.R13
FBA_EDC3: U8.B22 VRAM1.R2
FBA_EDC4: U8.R25 VRAM2.R13
FBA_EDC5: U8.W23 VRAM2.R2
FBA_EDC6: U8.AB26 VRAM2.C2
FBA_EDC7: U8.T26 VRAM2.C13
FBA_VREFC_1: C505.1 R407.2 R410.2 R411.2 VRAM1.J14
FBA_VREFC_2: C506.1 R25282.2 R25283.2 R25284.2 VRAM2.J14
FBVDD_EN: R325.2 R25469.1 U11.4(Y)
FBVDDQ_EN: PR9095.2 R25469.2
G5335-AGND-1: PC228.2 PC232.2 PR270.2 PR272.2 PR273.1 PU16.4
G5335-AGND-2: PC9090.2 PC9091.2 PR9093.2 PR9097.2 PR9098.2 PU9004.4
G5335-BST-1: PR277.2 PU16.20
G5335-BST-2: PR9089.2 PU9004.20
G5335-EN-1: PC228.1 PR274.1 PU16.2
G5335-EN-2: PC9090.1 PQ9086.2 PR9095.1 PR9096.2 PU9004.2
G5335-FB-1: PC225.1 PR269.2 PR270.1 PU16.5
G5335-FB-2: PC9089.1 PR9094.2 PR9097.1 PU9004.5
G5335-LX-1: PC235.1 PL12.1 PR99.1 PU16.10 PU16.11 PU16.16 PU16.17 PU16.18 PU16.25
G5335-LX-2: PC9079.1 PL9002.1 PR9092.1 PU9004.10 PU9004.11 PU9004.16 PU9004.17 PU9004.18 PU9004.25
G5335-PFM-1: PR98.1 PR272.1 PU16.3
G5335-PFM-2: PR9091.1 PR9093.1 PU9004.3
G5335-PWRGD-1: PR276.1 PU16.1
G5335-PWRGD-2: PR9090.1 PU9004.1
G5335-SS-1: PC232.1 PU16.23
G5335-SS-2: PC9091.1 PU9004.23
G5335-TON-1: PR268.1 PU16.6
G5335-TON-2: PR9086.1 PU9004.6
G5335-VCC-1: PC234.1 PR104.2 PU16.21(VCC)
G5335-VCC-2: PC9075.1 PR9087.2 PU9004.21(VCC)
G5719LX1.5V: PL14.1 PU3003.3
G_MBCLK_R: C6605.1 R591.2 R25356.2 U32.4
G_MBDATA_R: C6604.1 R590.2 R25355.2 U32.6
GC6_FB_EN: Q16.2 R372.2 R394.1 R25569.2
GC6_FB_EN_N17: R372.1 U8.B2
GC6_FB_EN_Q: Q14.3 R2650.1 R2651.2 U11.1 U2030.AN7
GC6FBEN_Q_EC: TP9021.1 U37.2
GPIO10_VREF: Q20.2 R398.2 U8.C5
GPU_CHOKE_THERMAL: PR9025.1 R25502.1 U37.126
GPU_EVENT#: R25482.2 R25573.2 U2030.AP5
GPU_EVENT#_GPU: D4.2 R373.2 R25490.1 R25572.2
GPU_EVENT#_R: D4.1(CATHODE) R25558.1 R25573.1
GPU_GPIO0: R370.1 R25569.1 U8.C6
GPU_GPIO2: R373.1 U8.D6
GPU_GPIO6: R376.1 R25572.1 U8.A4
GPU_GPIO16: R25589.1 U8.D5
GPU_GPIO21: R404.1 R25591.1 U8.C4
GPU_PEX_RST_HOLD#: R399.1 R25589.2 R25591.2 U6505.2
GPU_PWR_GD: PR9008.1 PR9079.2 R324.1
GPUT_CLK_L: Q13.4(S2) R365.2 R25583.2 U8.D9
GPUT_DATA_L: Q13.1 R362.2 R25582.2 U8.D8
GSPI0_MOSI: R2603.2 U2030.AR7
GSPI1_MOSI: R2287.2 U2030.AN5
H_CPU_SVIDART#: R2460.1 U2030.B63
H_CPU_SVIDCLK: PR7003.2 PR7015.1 U2030.A63
H_CPU_SVIDDAT: PR7001.2 PR7019.1 R2459.2 U2030.D64
H_PROCHOT#: PR22.1 PR7012.2 PU1.10 Q6509.3 R2451.2 R2452.1
H_PROCHOT#_R: R2452.2 U2030.C65
HDA_BCLK_R: R2496.2 U2030.AY22
HDA_RST#_R: R2498.2 U2030.AW22
HDA_SDO_R: C2575.2 R2494.1 R2495.2 U2030.BB22
HDA_SYNC_R: C2577.2 R2497.2 U2030.BA22
HDMI_EQ0: R746.1 R749.1 U23.8
HDMI_EQ1: R747.1 R748.1 U23.2
HDMI_HPD: Q6507.3 R1250.1 R25297.1 U23.21 VC2.1
HDMI_HPD_C: C616.1 CN37.19 R25297.2
HDMI_HPD_CON: R750.1 U2030.L9
HDMI_MB_HPD_R: Q6507.1(S) R750.2 R25294.2 U23.5
HDMI_SCLK: C614.1 CN37.15 D13089.2 Q41.3 R490.2 U23.19
HDMI_SDATA: C613.1 CN37.16 D13090.2 Q41.6 R491.2 U23.20
HP-L2: C589.2 R472.2 R474.1 R476.1 U20.32
HP-L3: C592.2 CN35.4 R472.1
HP-R2: C594.2 R473.2 R475.1 R477.1 U20.33
HP-R3: C593.2 CN35.2 R473.1
HP_JD#: CN35.13 R451.2
HWPG: D51.2 D60.2 D61.2 D62.2 D64.2 D2016.2 R2256.2 R25312.1 U37.21
HWPG_1.5V: D61.1(CATHODE) PR284.1 PR6416.2
HWPG_1.8VS5: D62.1(CATHODE) PR9255.2 PR9256.1
HWPG_1.35VGFX: PR9088.2 PR9090.2 R25549.2 R25550.1
HWPG_1VS5: D64.1(CATHODE) PR275.2 PR276.2
HWPG_2.5V: D2016.1(CATHODE)
HWPG_VDDR: D51.1(CATHODE) PR267.2 PR9265.1
I2CA_SCL: R326.1 R25540.1 U8.B7
I2CA_SDA: R25492.1 U8.A7
ICMNT: C6564.2 PC37.2 PR32.1 U37.67
ILIM_HI: R414.1 U14.16
ILIM_LO: R415.2 U14.15
IMON_CORE: PR7014.2 PU7000.1
IMON_GT: PC423.1 PR7004.2 PU7000.30
IMON_SA: PC7003.2 PR7005.2 PU7000.39
IMVP_PWRGD: PR7067.1 PR7068.2 R2466.1 U2029.2
IMVP_PWRGD_3V: Q2024.2 R2466.2 R2483.1 R2512.2 U2029.4(Y)
IN_CLK: C849.1 R1291.1 U2030.G56
IN_CLK#: C847.1 R1290.1 U2030.F56
IN_CLK#_R: C1679.1 R1290.2
IN_CLK_R: C1681.1 R1291.2
IN_D0: C852.1 R1285.1 U2030.G53
IN_D0#: C853.1 R1284.1 U2030.F53
IN_D0#_R: C1685.1 R1284.2
IN_D0_R: C1684.1 R1285.2
IN_D1: C851.1 R1287.1 U2030.F58
IN_D1#: C848.1 R1286.1 U2030.E58
IN_D1#_R: C1680.1 R1286.2
IN_D1_R: C1683.1 R1287.2
IN_D2: C854.1 R1289.1 U2030.F55
IN_D2#: C850.1 R1288.1 U2030.E55
IN_D2#_R: C1682.1 R1288.2
IN_D2_R: C1686.1 R1289.2
INT_AMIC-VREFO: C564.1 R447.2 U20.27
INT_EDP_AUXN: C556.2 U2030.E45
INT_EDP_AUXN_C: C556.1 CN29.22 R25271.1
INT_EDP_AUXP: C557.2 U2030.F45
INT_EDP_AUXP_C: C557.1 CN29.23 R25270.1
INT_EDP_TXN0: C553.2 U2030.C47
INT_EDP_TXN0_C: C553.1 CN29.19
INT_EDP_TXN1: C555.2 U2030.D46
INT_EDP_TXN1_C: C555.1 CN29.16
INT_EDP_TXN2: C1675.2 U2030.A45
INT_EDP_TXN2_C: C1675.1 CN29.13
INT_EDP_TXN3: C1678.2 U2030.A47
INT_EDP_TXN3_C: C1678.1 CN29.10
INT_EDP_TXP0: C552.2 U2030.C46
INT_EDP_TXP0_C: C552.1 CN29.20
INT_EDP_TXP1: C554.2 U2030.C45
INT_EDP_TXP1_C: C554.1 CN29.17
INT_EDP_TXP2: C1676.2 U2030.B45
INT_EDP_TXP2_C: C1676.1 CN29.14
INT_EDP_TXP3: C1677.2 U2030.B47
INT_EDP_TXP3_C: C1677.1 CN29.11
INT_HDMICLK+_OUT: R702.1 U23.10
INT_HDMICLK-_OUT: R703.1 U23.9
INT_HDMITX0N_OUT: R697.1 U23.15
INT_HDMITX0P_OUT: R696.1 U23.16
INT_HDMITX1N_OUT: R699.1 U23.13
INT_HDMITX1P_OUT: R698.1 U23.14
INT_HDMITX2N_OUT: R701.1 U23.11
INT_HDMITX2P_OUT: R700.1 U23.12
INTRUDER#: R2216.1 U2030.AP16
ISEN1N_CORE: PC7025.2 PC7047.2 PR7074.2 PR7075.2 PU7000.7
ISEN1N_GT: PC7030.2 PC7097.2 PC7100.2 PR7097.2 PR7100.2 PR7101.2 PU7000.28
ISEN1N_SA: PC7029.2 PC7079.2 PC7099.2 PR7089.2 PR7092.2 PR7093.2 PU7000.41
ISEN1P_CORE: PC7047.1 PR7075.1 PR7076.2 PU7000.10
ISEN1P_GT: PC7097.1 PC7100.1 PR7098.2 PR7099.1 PU7000.29
ISEN1P_SA: PC7079.1 PC7099.1 PR7090.1 PR7091.2 PU7000.40
ISEN2N_CORE: PC7027.2 PC7065.2 PR7066.1 PR7083.2 PR7085.1
ISEN2P_CORE: PC7065.1 PR7065.2 PR7084.2 PR7085.2 PU7000.9
ISOLATEB: R509.2 R510.2 U24.20
JTAG_TCK: TP70.1 U8.AE5
JTAG_TDI: TP72.1 U8.AE6
JTAG_TDO: TP73.1 U8.AF6
JTAG_TMS: TP71.1 U8.AD6
JTAG_TRST#: R396.1 U8.AG4
KB_BL_LED: Q31.2 U37.113
KL_NO_EC: PR9269.2 PR9271.2 U37.70
L_SPK+: R483.1 U20.42
L_SPK+_1: C604.1 CN36.4 R483.2
L_SPK-: R482.1 U20.43
L_SPK-_1: C603.1 CN36.3 R482.2
LAD0_R: CN17.58 R673.1
LAD1: CN17.66 R2662.1
LAD2: CN17.68 R2663.1
LAD3: CN17.70 R2664.1
LAN_AMBLED#: TP74.1 U24.27
LAN_LED1: TP75.1 U24.26
LAN_LED2: TP76.1 U24.25
LAN_MCTG0: R516.2 U25.24
LAN_MCTG1: R517.2 U25.21
LAN_MCTG2: R518.2 U25.18
LAN_MCTG3: R519.2 U25.15
LAN_WAKE#: R36.1 TP2033.1 U2030.AM15
LAN_XTAL1: C638.2 R511.1 Y4.1
LFRAME#_R: CN17.62 R675.1
LGATE1_CORE: PQ7000.8 PU7002.7
LGATE2_CORE: PQ7001.8 PU7001.7
LGATE_GT: PQ7004.8 PU7003.7
LGATE_SA: PQ7003.4 PU7004.7
LID#: C841.1 CN24.4 D3.1(CATHODE) HE1.1 R25315.2 R25370.2
LID#_C: C6572.1 D65.1 R25315.1 U37.118
LINE1-L: C589.1 U20.22
LINE1-R: C594.1 U20.21
LINE1-VREFO-L: R476.2 U20.31
LINE1-VREFO-R: R477.2 U20.30
LPC_LAD0: R673.2 R2527.2 U37.10
LPC_LAD1: R2525.2 R2662.2 U37.9
LPC_LAD2: R2529.2 R2663.2 U37.8
LPC_LAD3: R2531.2 R2664.2 U37.7
LPC_LFRAME#: R675.2 U37.6 U2030.BA12
M_A_A0: JDIM2000.144 U2030.AY50
M_A_A1: JDIM2000.133 U2030.BB50
M_A_A2: JDIM2000.132 U2030.AY51
M_A_A3: JDIM2000.131 U2030.BA50
M_A_A4: JDIM2000.128 U2030.BB52
M_A_A5: JDIM2000.126 U2030.BA51
M_A_A6: JDIM2000.127 U2030.BA52
M_A_A7: JDIM2000.122 U2030.AW52
M_A_A8: JDIM2000.125 U2030.AY52
M_A_A9: JDIM2000.121 U2030.BB54
M_A_A10: JDIM2000.146 U2030.AT50
M_A_A11: JDIM2000.120 U2030.BA54
M_A_A12: JDIM2000.119 U2030.AW54
M_A_A13: JDIM2000.158 U2030.AU46
M_A_ACT#: JDIM2000.114 U2030.BA55
M_A_ALERT#: JDIM2000.116 R2186.1 U2030.AW50
M_A_BA#0: JDIM2000.150 U2030.AU52
M_A_BA#1: JDIM2000.145 U2030.AT48
M_A_BG#0: JDIM2000.115 U2030.AY55
M_A_BG#1: JDIM2000.113 U2030.AY54
M_A_CAS#: JDIM2000.156 U2030.AU48
M_A_CB0: JDIM2000.92 R2172.2
M_A_CB1: JDIM2000.91 R2168.2
M_A_CB2: JDIM2000.101 R2176.2
M_A_CB3: JDIM2000.105 R2178.2
M_A_CB4: JDIM2000.88 R2167.2
M_A_CB5: JDIM2000.87 R2169.2
M_A_CB6: JDIM2000.100 R2179.2
M_A_CB7: JDIM2000.104 R2180.2
M_A_CKE0: JDIM2000.109 U2030.BA56
M_A_CKE1: JDIM2000.110 U2030.BB56
M_A_CLK0: JDIM2000.137 U2030.AT53
M_A_CLK0#: JDIM2000.139 U2030.AU53
M_A_CLK1: JDIM2000.138 U2030.AT55
M_A_CLK1#: JDIM2000.140 U2030.AU55
M_A_CS#0: JDIM2000.149 U2030.AU45
M_A_CS#1: JDIM2000.157 U2030.AU43
M_A_DQ0: JDIM2000.3 U2030.AL71
M_A_DQ1: JDIM2000.8 U2030.AL68
M_A_DQ2: JDIM2000.21 U2030.AN68
M_A_DQ3: JDIM2000.16 U2030.AN69
M_A_DQ4: JDIM2000.7 U2030.AL70
M_A_DQ5: JDIM2000.4 U2030.AL69
M_A_DQ6: JDIM2000.20 U2030.AN70
M_A_DQ7: JDIM2000.17 U2030.AN71
M_A_DQ8: JDIM2000.28 U2030.AR70
M_A_DQ9: JDIM2000.25 U2030.AR68
M_A_DQ10: JDIM2000.38 U2030.AU71
M_A_DQ11: JDIM2000.37 U2030.AU68
M_A_DQ12: JDIM2000.29 U2030.AR71
M_A_DQ13: JDIM2000.24 U2030.AR69
M_A_DQ14: JDIM2000.42 U2030.AU70
M_A_DQ15: JDIM2000.41 U2030.AU69
M_A_DQ16: JDIM2000.45 U2030.BB65
M_A_DQ17: JDIM2000.46 U2030.AW65
M_A_DQ18: JDIM2000.59 U2030.AW63
M_A_DQ19: JDIM2000.62 U2030.AY63
M_A_DQ20: JDIM2000.49 U2030.BA65
M_A_DQ21: JDIM2000.50 U2030.AY65
M_A_DQ22: JDIM2000.63 U2030.BA63
M_A_DQ23: JDIM2000.58 U2030.BB63
M_A_DQ24: JDIM2000.70 U2030.BA61
M_A_DQ25: JDIM2000.66 U2030.AW61
M_A_DQ26: JDIM2000.84 U2030.BB59
M_A_DQ27: JDIM2000.80 U2030.AW59
M_A_DQ28: JDIM2000.71 U2030.BB61
M_A_DQ29: JDIM2000.67 U2030.AY61
M_A_DQ30: JDIM2000.83 U2030.BA59
M_A_DQ31: JDIM2000.79 U2030.AY59
M_A_DQ32: JDIM2000.174 U2030.AY39
M_A_DQ33: JDIM2000.169 U2030.AW39
M_A_DQ34: JDIM2000.187 U2030.AY37
M_A_DQ35: JDIM2000.183 U2030.AW37
M_A_DQ36: JDIM2000.173 U2030.BB39
M_A_DQ37: JDIM2000.170 U2030.BA39
M_A_DQ38: JDIM2000.182 U2030.BA37
M_A_DQ39: JDIM2000.186 U2030.BB37
M_A_DQ40: JDIM2000.190 U2030.AY35
M_A_DQ41: JDIM2000.194 U2030.AW35
M_A_DQ42: JDIM2000.203 U2030.AY33
M_A_DQ43: JDIM2000.207 U2030.AW33
M_A_DQ44: JDIM2000.191 U2030.BB35
M_A_DQ45: JDIM2000.195 U2030.BA35
M_A_DQ46: JDIM2000.208 U2030.BA33
M_A_DQ47: JDIM2000.204 U2030.BB33
M_A_DQ48: JDIM2000.212 U2030.AY31
M_A_DQ49: JDIM2000.216 U2030.AW31
M_A_DQ50: JDIM2000.229 U2030.AY29
M_A_DQ51: JDIM2000.224 U2030.AW29
M_A_DQ52: JDIM2000.211 U2030.BB31
M_A_DQ53: JDIM2000.215 U2030.BA31
M_A_DQ54: JDIM2000.228 U2030.BA29
M_A_DQ55: JDIM2000.225 U2030.BB29
M_A_DQ56: JDIM2000.237 U2030.AY27
M_A_DQ57: JDIM2000.249 U2030.AW27
M_A_DQ58: JDIM2000.236 U2030.AY25
M_A_DQ59: JDIM2000.233 U2030.AW25
M_A_DQ60: JDIM2000.246 U2030.BB27
M_A_DQ61: JDIM2000.250 U2030.BA27
M_A_DQ62: JDIM2000.232 U2030.BA25
M_A_DQ63: JDIM2000.245 U2030.BB25
M_A_DQS0: JDIM2000.13 U2030.AM69
M_A_DQS1: JDIM2000.34 U2030.AT70
M_A_DQS2: JDIM2000.55 U2030.AY64
M_A_DQS3: JDIM2000.76 U2030.BA60
M_A_DQS4: JDIM2000.179 U2030.AY38
M_A_DQS5: JDIM2000.200 U2030.BA34
M_A_DQS6: JDIM2000.221 U2030.AY30
M_A_DQS7: JDIM2000.242 U2030.BA26
M_A_DQS8: JDIM2000.97 R2177.2
M_A_DQS#0: JDIM2000.11 U2030.AM70
M_A_DQS#1: JDIM2000.32 U2030.AT69
M_A_DQS#2: JDIM2000.53 U2030.BA64
M_A_DQS#3: JDIM2000.74 U2030.AY60
M_A_DQS#4: JDIM2000.177 U2030.BA38
M_A_DQS#5: JDIM2000.198 U2030.AY34
M_A_DQS#6: JDIM2000.219 U2030.BA30
M_A_DQS#7: JDIM2000.240 U2030.AY26
M_A_DQS#8: JDIM2000.95 R2173.2
M_A_EVENT#: JDIM2000.134 R2187.2
M_A_ODT0_DIMM: JDIM2000.155 U2030.AT45
M_A_ODT1_DIMM: JDIM2000.161 U2030.AT43
M_A_PARITY: JDIM2000.143 U2030.AT52
M_A_RAS#: JDIM2000.152 U2030.AU50
M_A_WE#: JDIM2000.151 U2030.AT46
M_B1_ZQ0: R2223.1 U2012.F9(ZQ)
M_B2_ZQ0: R2191.1 U2011.F9(ZQ)
M_B3_ZQ0: R2159.1 U2010.F9(ZQ)
M_B4_ZQ0: R2138.1 U2009.F9(ZQ)
M_B_A0: R2088.2 U2009.P3 U2010.P3 U2011.P3 U2012.P3 U2030.BA46
M_B_A1: R2118.2 U2009.P7 U2010.P7 U2011.P7 U2012.P7 U2030.AY46
M_B_A2: R2102.2 U2009.R3 U2010.R3 U2011.R3 U2012.R3 U2030.AY47
M_B_A3: R2114.2 U2009.N7 U2010.N7 U2011.N7 U2012.N7 U2030.BB46
M_B_A4: R2112.2 U2009.N3 U2010.N3 U2011.N3 U2012.N3 U2030.BA47
M_B_A5: R2117.2 U2009.P8 U2010.P8 U2011.P8 U2012.P8 U2030.AY48
M_B_A6: R2103.2 U2009.P2 U2010.P2 U2011.P2 U2012.P2 U2030.BA48
M_B_A7: R2124.2 U2009.R8 U2010.R8 U2011.R8 U2012.R8 U2030.AP48
M_B_A8: R2091.2 U2009.R2 U2010.R2 U2011.R2 U2012.R2 U2030.BB48
M_B_A9: R2119.2 U2009.R7 U2010.R7 U2011.R7 U2012.R7 U2030.AP50
M_B_A10: R2105.2 U2009.M3 U2010.M3 U2011.M3 U2012.M3 U2030.AW46
M_B_A11: R2092.2 U2009.T2 U2010.T2 U2011.T2 U2012.T2 U2030.AN48
M_B_A12: R2111.2 U2009.M7 U2010.M7 U2011.M7 U2012.M7 U2030.AN50
M_B_A13: R2121.2 U2009.T8 U2010.T8 U2011.T8 U2012.T8 U2030.BA43
M_B_A14: R2106.2 U2009.L2 U2010.L2 U2011.L2 U2012.L2 U2030.AY44
M_B_A15: R2130.2 U2009.M8 U2010.M8 U2011.M8 U2012.M8 U2030.AY43
M_B_A16: R2107.2 U2009.L8 U2010.L8 U2011.L8 U2012.L8 U2030.AW44
M_B_ACT#: R2110.2 U2009.L3 U2010.L3 U2011.L3 U2012.L3 U2030.AN53
M_B_ALERT#: R2219.1 R2220.1 U2009.P9 U2010.P9 U2011.P9 U2012.P9 U2030.AN43
M_B_BG#0: R2089.2 U2009.M2 U2010.M2 U2011.M2 U2012.M2 U2030.AP52
M_B_BG#1: R2137.2 R2224.1 U2030.AN52
M_B_BG#1_1: R2221.1 R2224.2 U2009.M9 U2010.M9 U2011.M9 U2012.M9
M_B_BS#0: R2090.2 U2009.N2 U2010.N2 U2011.N2 U2012.N2 U2030.BB44
M_B_BS#1: R2126.2 U2009.N8 U2010.N8 U2011.N8 U2012.N8 U2030.BA44
M_B_CKE0: R2101.2 U2009.K2 U2010.K2 U2011.K2 U2012.K2 U2030.AN56
M_B_CLK0: C2173.1 R2100.2 U2009.K7 U2010.K7 U2011.K7 U2012.K7 U2030.AP45
M_B_CLK0#: C2173.2 R2099.2 U2009.K8 U2010.K8 U2011.K8 U2012.K8 U2030.AN45
M_B_CS#0: R2109.2 U2009.L7 U2010.L7 U2011.L7 U2012.L7 U2030.BB42
M_B_DQ0: U2009.C2 U2030.AF65
M_B_DQ1: U2009.A3 U2030.AF64
M_B_DQ2: U2009.B8 U2030.AK65
M_B_DQ3: U2009.D7 U2030.AK64
M_B_DQ4: U2009.C3 U2030.AF66
M_B_DQ5: U2009.D3 U2030.AF67
M_B_DQ6: U2009.C7 U2030.AK67
M_B_DQ7: U2009.C8 U2030.AK66
M_B_DQ8: U2009.H3 U2030.AF70
M_B_DQ9: U2009.H2 U2030.AF68
M_B_DQ10: U2009.J7 U2030.AH71
M_B_DQ11: U2009.H7 U2030.AH68
M_B_DQ12: U2009.J3 U2030.AF71
M_B_DQ13: U2009.G2 U2030.AF69
M_B_DQ14: U2009.F7 U2030.AH70
M_B_DQ15: U2009.H8 U2030.AH69
M_B_DQ16: U2010.J7 U2030.AT66
M_B_DQ17: U2010.J3 U2030.AU66
M_B_DQ18: U2010.H8 U2030.AP65
M_B_DQ19: U2010.F7 U2030.AN65
M_B_DQ20: U2010.H2 U2030.AN66
M_B_DQ21: U2010.G2 U2030.AP66
M_B_DQ22: U2010.H7 U2030.AT65
M_B_DQ23: U2010.H3 U2030.AU65
M_B_DQ24: U2010.C3 U2030.AT61
M_B_DQ25: U2010.D3 U2030.AU61
M_B_DQ26: U2010.C7 U2030.AP60
M_B_DQ27: U2010.D7 U2030.AN60
M_B_DQ28: U2010.A3 U2030.AN61
M_B_DQ29: U2010.C2 U2030.AP61
M_B_DQ30: U2010.C8 U2030.AT60
M_B_DQ31: U2010.B8 U2030.AU60
M_B_DQ32: U2011.H3 U2030.AU40
M_B_DQ33: U2011.G2 U2030.AT40
M_B_DQ34: U2011.F7 U2030.AT37
M_B_DQ35: U2011.H8 U2030.AU37
M_B_DQ36: U2011.J3 U2030.AR40
M_B_DQ37: U2011.H2 U2030.AP40
M_B_DQ38: U2011.J7 U2030.AP37
M_B_DQ39: U2011.H7 U2030.AR37
M_B_DQ40: U2011.D3 U2030.AT33
M_B_DQ41: U2011.C3 U2030.AU33
M_B_DQ42: U2011.C8 U2030.AU30
M_B_DQ43: U2011.B8 U2030.AT30
M_B_DQ44: U2011.C2 U2030.AR33
M_B_DQ45: U2011.A3 U2030.AP33
M_B_DQ46: U2011.C7 U2030.AR30
M_B_DQ47: U2011.D7 U2030.AP30
M_B_DQ48: U2012.H3 U2030.AU27
M_B_DQ49: U2012.J3 U2030.AT27
M_B_DQ50: U2012.H7 U2030.AT25
M_B_DQ51: U2012.J7 U2030.AU25
M_B_DQ52: U2012.G2 U2030.AP27
M_B_DQ53: U2012.H2 U2030.AN27
M_B_DQ54: U2012.F7 U2030.AN25
M_B_DQ55: U2012.H8 U2030.AP25
M_B_DQ56: U2012.D3 U2030.AT22
M_B_DQ57: U2012.C3 U2030.AU22
M_B_DQ58: U2012.B8 U2030.AU21
M_B_DQ59: U2012.C7 U2030.AT21
M_B_DQ60: U2012.C2 U2030.AN22
M_B_DQ61: U2012.A3 U2030.AP22
M_B_DQ62: U2012.C8 U2030.AP21
M_B_DQ63: U2012.D7 U2030.AN21
M_B_DQS0: U2009.B7 U2030.AH65
M_B_DQS1: U2009.G3 U2030.AG70
M_B_DQS2: U2010.G3 U2030.AR65
M_B_DQS3: U2010.B7 U2030.AR60
M_B_DQS4: U2011.G3 U2030.AR38
M_B_DQS5: U2011.B7 U2030.AR32
M_B_DQS6: U2012.G3 U2030.AR27
M_B_DQS7: U2012.B7 U2030.AR21
M_B_DQS#0: U2009.A7 U2030.AH66
M_B_DQS#1: U2009.F3 U2030.AG69
M_B_DQS#2: U2010.F3 U2030.AR66
M_B_DQS#3: U2010.A7 U2030.AR61
M_B_DQS#4: U2011.F3 U2030.AT38
M_B_DQS#5: U2011.A7 U2030.AT32
M_B_DQS#6: U2012.F3 U2030.AR25
M_B_DQS#7: U2012.A7 U2030.AR22
M_B_ODT0_MD: R2104.2 U2009.K3 U2010.K3 U2011.K3 U2012.K3 U2030.BA42
M_B_PARITY: R2116.2 U2009.T3 U2010.T3 U2011.T3 U2012.T3 U2030.AP43
MAIND: PC51.1 PQ6.3 PQ9.2 PR59.2 PR2060.2
