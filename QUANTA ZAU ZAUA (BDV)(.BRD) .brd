# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_BG#1: length 60.2
  TOP w0.165: v1(28,61.28) 27.93,61.35 R2224.1 R2137.2
  IN3 w0.089: 77.15,65.97 77.52,65.86 78.89,65.72 v2(80.14,65.33)
  IN3 w0.14: 77.15,65.97 74.51,67.49 72.22,69.38 69.05,70.16 67.38,70.16 66.38,71.16 58.7,71.16 58.09,71.51 57.65,71.72 57.43,71.8 51.49,71.8 49.92,71.31 49.82,71.28 41.08,71.28 37.4,70.48 28.2,61.28 v1(28,61.28)
  BOTTOM w0.165: U2030.AN52 v2(80.14,65.33)
M_B_BG#1_1: length 98.2
  TOP w0.102: U2012.M9 37.91,36.27 37.95,36.13 38.06,35.77 38.36,34.82 38.39,34.67 R2221.1 37.57,34 v2(36.99,34.58) ; v2(28.69,50.13) 32.75,50.08 33.21,50.07 34.38,50.07 36.14,50.61 36.36,50.69 36.61,50.83 U2011.M9 ; U2010.M9 37.7,72.66 37.7,72.12 35.37,69.79 34.53,69.79 30.53,68.57 v2(28.15,68.03) ; U2009.M9 37.47,85.5 34.63,82.66 29.08,82.66 v1(28.45,82.03)
  TOP w0.165: R2224.2 27.93,63.16 v1(28.03,63.26)
  IN1 w0.089: v1(28.45,82.03) 28.45,79.88 28.37,79.79 27.66,79.79 27.6,79.73 27.6,79.61 27.71,79.5 28.37,79.5 28.45,79.41 28.45,79.29 28.37,79.21 27.66,79.21 27.6,79.15 27.6,79.03 27.71,78.92 28.37,78.92 28.45,78.83 28.45,78.71 28.37,78.62 28.19,78.62 28.1,78.54 28.1,78.42 28.19,78.33 28.37,78.33 28.45,78.25 28.45,78.07 28.35,77.97 28.06,77.97 27.93,77.84 27.93,77.67 27.85,77.58 27.47,77.58 27.38,77.5 27.38,77.37 27.47,77.29 27.85,77.29 27.93,77.2 27.93,77.08 27.85,77 27.44,77 27.38,76.94 27.38,76.82 27.49,76.7 27.85,76.7 27.93,76.62 27.93,76.5 27.85,76.41 27.56,76.41 27.48,76.33 27.48,76.21 27.56,76.12 27.85,76.12 27.93,76.03 27.93,75.57 27.85,75.49 27.74,75.49 27.66,75.4 27.66,75.28 27.74,75.19 27.85,75.19 27.93,75.11 27.93,74.99 27.85,74.9 27.74,74.9 27.66,74.82 27.66,74.7 27.74,74.61 27.85,74.61 27.93,74.53 27.93,74.4 27.85,74.32 27.74,74.32 27.66,74.23 27.66,74.11 27.74,74.03 27.85,74.03 27.93,73.94 27.93,69.91 27.99,69.42 v2(28.15,68.03) 28.24,66.79 28.35,65.21 28.35,64.06 28.03,63.74 v1(28.03,63.26) 28.43,62.86 28.43,60.97 28.35,60.88 28.35,56.68 28.59,52.97 28.59,51.39 v2(28.69,50.13) 28.63,48.25 28.54,47.44 28.24,45.01 28.21,43.85 28.21,42.47 28.26,42.21 28.7,41.26 29.06,40.75 29.92,39.53 30.14,39.25 30.53,38.96 35.68,35.14 35.96,35.05 v2(36.99,34.58)
M_B_BS#0: length 180.1
  TOP w0.102: U2012.N2 36.44,43.88 36.24,44.08 36.24,46.03 36.01,46.26 35.77,46.26 35.61,46.11 35.61,45.81 35.54,45.73 35.13,45.73 34.99,45.88 v2(34.99,46.3) ; v2(35,95.23) 35.06,95.29 36.11,95.29 36.27,95.13 36.27,94.41 36.22,94.35 36.22,93.62 36.27,93.57 36.27,92.42 36.67,92.02 U2009.N2 ; v2(33.36,80.12) 35.74,80.12 36.24,79.61 36.24,78.92 U2010.N2 ; v2(34.9,58.95) 35.16,59.22 35.42,59.22 35.49,59.14 35.49,58.89 35.57,58.81 35.8,58.81 35.98,58.99 36.1,58.99 36.22,58.88 36.22,58.67 35.95,58.41 35.95,58.29 36.24,58 36.24,57.2 36.35,57.09 U2011.N2
  TOP w0.165: R2090.2 33.67,100.95 v1(33.87,100.75)
  IN1 w0.089: v2(34.99,46.3) 34.73,46.3 34.41,46.63 34.41,47.47 34.49,47.56 35.22,47.56 35.3,47.64 35.3,47.84 35.21,47.93 34.5,47.93 34.41,48.02 34.41,48.14 34.49,48.22 35.23,48.22 35.32,48.31 35.32,48.43 35.22,48.54 34.5,48.54 34.41,48.63 34.41,49.14 34.5,49.23 34.64,49.23 34.73,49.32 34.73,49.44 34.64,49.53 34.5,49.53 34.41,49.62 34.41,49.75 34.5,49.84 34.64,49.84 34.73,49.92 34.73,51.88 34.64,51.97 34.45,51.97 34.36,52.06 34.36,52.19 34.45,52.27 34.64,52.27 34.73,52.36 34.73,52.49 34.64,52.58 34.45,52.58 34.36,52.67 34.36,52.82 34.43,52.89 34.71,52.89 34.78,52.97 34.78,53.11 34.69,53.2 34.44,53.2 34.35,53.29 34.35,53.45 34.43,53.53 34.66,53.53 34.73,53.61 34.73,53.83 34.46,54.1 34.46,57.47 34.54,57.55 34.97,57.55 35.07,57.65 35.07,57.82 34.98,57.91 34.46,57.91 34.39,57.99 34.39,58.14 34.46,58.22 34.93,58.22 35.02,58.31 35.02,58.43 34.93,58.52 34.5,58.52 34.4,58.62 34.4,58.86 34.49,58.95 v2(34.9,58.95) 34.04,59.81 34.04,64.04 34.45,64.44 34.45,69.18 34.04,69.59 34.04,71.32 33.46,71.89 33.46,72.43 33.97,72.94 33.97,73.34 34.11,73.48 34.11,76.49 34.4,76.77 34.4,78.52 33.85,79.07 33.85,79.63 v2(33.36,80.12) 33.83,80.12 34.02,80.31 34.02,82.2 34.09,82.26 34.09,85.12 34.65,85.68 34.65,86.27 34.3,86.62 34.3,88.33 35.22,89.25 35.22,90.49 35.93,91.2 35.93,92.46 35.37,93.02 35.37,94.34 35.16,94.55 34.12,94.55 34.01,94.66 34.01,94.86 34.1,94.96 34.72,94.96 v2(35,95.23)
  IN3 w0.102: v1(33.87,100.75) 33.87,100.67 32.88,99.68 32.88,97.94 35,95.82 v2(35,95.23)
  IN3 w0.14: v2(70.48,60.65) 70.48,60.36 70.36,60.24 69.73,60.24 69.52,60.45 69.35,60.45 69.15,60.24 68.93,60.24 68.01,61.16 66.35,61.16 65.8,60.61 63.34,60.61 63.33,60.61 62.97,60.61 62.87,60.71 62.87,61.47 62.55,61.79 56.83,61.79 56.68,61.64 56.68,61.13 55.65,60.1 55.36,60.1 55.11,59.85 51.23,59.85 49.91,61.17 49.3,61.17 47.81,62.66 41.05,62.66 36.88,58.49 36.88,56.79 36.98,56.69 36.98,56.54 36.88,56.44 36.24,56.44 35.85,56.04 35.85,55.66 35.79,55.61 35.79,54.72 35.67,54.6 34.35,54.6 34.25,54.49 34.25,54.35 34.42,54.18 36.29,54.18 36.41,54.05 36.41,53.88 36.29,53.76 34.87,53.76 34.75,53.63 34.75,53.49 34.9,53.34 36.25,53.34 36.37,53.22 36.37,53.04 36.25,52.92 34.71,52.92 34.28,53.35 34.13,53.35 34.01,53.22 34.01,53.01 34.52,52.5 36.25,52.5 36.37,52.38 36.37,52.2 36.25,52.08 34.21,52.08 34.09,51.96 34.09,51.78 34.21,51.66 35.82,51.66 35.94,51.54 35.94,51.37 35.82,51.24 34.57,51.24 34.44,51.12 34.44,50.95 34.57,50.82 35.87,50.82 35.99,50.7 35.99,50.53 35.87,50.4 34.14,50.4 34.02,50.28 34.02,50.11 34.14,49.99 35.46,49.99 35.58,49.86 35.58,49.69 35.46,49.57 34.14,49.57 34.02,49.44 34.02,49.27 34.14,49.15 35.46,49.15 35.58,49.02 35.58,48.85 35.46,48.73 34.73,48.73 34.61,48.61 34.61,48.43 34.73,48.31 35.31,48.31 35.44,48.19 35.44,48.01 35.31,47.89 34.75,47.89 34.63,47.77 34.63,47.59 34.75,47.47 35.28,47.47 35.4,47.35 35.4,46.56 35.15,46.3 v2(34.99,46.3)
  BOTTOM w0.076: U2030.BB44 74.6,60.43 74.53,60.51 74.09,60.51 73.43,59.85 72.59,59.85 72.34,60.11 70.49,60.11 70.26,59.88
  BOTTOM w0.102: v2(70.48,60.65) 70.06,60.23 69.35,60.23 69.12,60 68.81,60 68.68,60.13 68.68,60.13 68.58,60.23 67.75,60.23 67.65,60.13 67.65,59.71 67.75,59.61 69.99,59.61 70.26,59.88
M_B_BS#1: length 170.6
  TOP w0.102: v2(37.08,52.69) 36.68,52.29 U2011.N8 ; U2012.N8 36.73,39.02 37.02,39.02 37.14,38.89 37.14,38.73 37.07,38.65 36.55,38.65 36.28,38.91 36.28,39.35 36.15,39.48 v2(35.51,39.48) ; U2010.N8 37.06,73.3 37.11,73.3 v2(37.12,73.3) ; U2009.N8 v2(37.06,87.34)
  TOP w0.165: R2126.2 30.91,86.9 v2(30.91,86.89)
  IN1 w0.089: v2(37.06,87.34) 37.29,87.11 37.29,86.9 37.22,86.83 36.68,86.83 36.58,86.74 36.58,86.61 36.7,86.49 37.3,86.49 37.36,86.42 37.36,86.27 37.28,86.18 36.72,86.18 36.58,86.05 36.58,85.46 36.72,85.33 37.31,85.33 37.38,85.26 37.38,85.05 37.29,84.97 36.67,84.97 36.58,84.88 36.58,81.88 36.82,81.64 36.82,78.09 37.32,77.59 37.32,76.05 37.07,75.79 37.07,75.07 37.23,74.91 37.23,74.77 37.13,74.67 36.79,74.67 36.7,74.58 36.7,74.41 36.79,74.32 37.25,74.32 37.34,74.23 37.34,74.11 37.25,74.02 36.79,74.02 36.7,73.93 36.7,73.72 36.78,73.63 37.01,73.63 37.12,73.53 v2(37.12,73.3) 36.67,72.86 36.67,72.27 37.87,71.08 37.87,65.8 37.42,65.35 37.42,58.96 37.18,58.72 37.18,57.19 37.37,56.99 37.37,56.47 37.69,56.16 37.69,54.93 37.28,54.53 37.28,54.03 37.68,53.63 37.68,52.79 37.58,52.69 v2(37.08,52.69) 37.79,51.98 37.79,46.69 37.42,46.32 37.42,43.95 37.93,43.43 37.93,42.14 38.07,42 38.07,41.13 38.06,41.12 38.06,39.58 38.46,37.32 38.75,36.36 38.75,36.06 38.49,35.8 38.2,35.8 37.97,35.99 37.46,36.86 36.57,37.75 36.57,38.15 36.28,38.51 v2(35.51,39.48)
  IN3 w0.102: v2(30.91,86.89) 30.97,86.83 32.68,86.83 32.84,86.68 33.3,86.68 33.97,87.34 v2(37.06,87.34)
  IN3 w0.14: v2(71.06,60.69) 71.06,60.52 70.5,59.96 70.5,59.72 70.39,59.61 70.11,59.61 70.01,59.7 70.01,59.85 69.91,59.96 69.63,59.96 69.53,59.85 69.53,59.7 69.44,59.61 69.18,59.61 68.25,60.54 68.11,60.54 68.03,60.46 68.03,60.25 67.91,60.12 67.73,60.12 67.6,60.24 67.6,60.74 67.48,60.87 67.31,60.87 67.18,60.74 67.18,60.24 67.06,60.12 66.89,60.12 66.77,60.24 66.77,60.74 66.64,60.87 66.47,60.87 66.35,60.74 66.35,60.2 66.22,60.07 65.99,60.07 65.75,60.32 65.59,60.32 65.45,60.18 65.45,59.67 65.37,59.59 65.14,59.59 65.01,59.71 65.01,60.19 64.89,60.32 64.72,60.32 64.59,60.19 64.59,59.71 64.47,59.59 64.3,59.59 64.17,59.71 64.17,60.19 64.05,60.32 63.88,60.32 63.76,60.19 63.76,59.71 63.63,59.59 63.46,59.59 63.34,59.71 63.34,60.2 63.21,60.32 63.04,60.32 62.92,60.2 62.92,59.71 62.79,59.59 62.62,59.59 62.5,59.71 62.5,61.38 62.38,61.5 62.21,61.5 62.08,61.37 62.08,59.85 61.98,59.75 61.79,59.75 61.58,59.96 61.58,61.4 61.49,61.5 59.09,61.5 58.99,61.4 58.99,61.05 58.83,60.9 58.63,60.9 58.51,61.02 58.51,61.4 58.41,61.5 57.94,61.5 57.85,61.4 57.85,61.28 58.02,61.1 58.02,60.98 57.88,60.83 57.7,60.83 57.33,61.2 57.16,61.2 57.04,61.08 57.04,60.9 57.41,60.53 57.41,60.36 57.28,60.24 57.11,60.24 56.74,60.61 56.57,60.61 56.45,60.48 56.45,60.31 56.81,59.94 56.81,59.77 56.61,59.56 56.48,59.56 56.08,59.96 55.92,59.96 55.52,59.56 51.11,59.56 49.78,60.88 49.17,60.88 47.69,62.37 41.17,62.37 37.17,58.37 37.17,56.91 37.27,56.81 37.48,56.81 37.58,56.71 37.58,56.25 37.48,56.15 36.39,56.15 36.28,56.04 36.28,55.84 36.38,55.74 37.43,55.74 37.58,55.58 37.58,54.97 37.46,54.85 36.59,54.85 36.41,54.67 36.41,54.47 36.54,54.34 36.89,54.34 37.02,54.22 37.02,54.01 36.66,53.65 36.66,51.17 36.66,51.16 36.66,50.88 36.33,50.55 36.33,50.33 36.46,50.2 36.46,49.36 36.64,49.18 36.64,48.79 36.51,48.65 35.8,48.65 35.7,48.55 35.7,48.32 35.82,48.2 36.54,48.2 36.64,48.09 36.64,47.9 36.51,47.76 35.8,47.76 35.7,47.66 35.7,47.44 35.81,47.33 36.23,47.33 36.36,47.2 36.36,47 36.26,46.9 35.85,46.9 35.7,46.75 35.7,46.44 35.33,46.07 35.33,45.93 35.44,45.82 35.95,45.82 36.34,45.42 36.34,40.77 36.08,40.51 35.88,40.51 35.58,40.8 34.56,40.8 34.45,40.7 34.45,40.5 34.59,40.36 35.51,40.36 35.6,40.27 35.6,40.06 35.48,39.94 34.56,39.94 34.45,39.84 34.45,39.61 34.58,39.48 v2(35.51,39.48)
  BOTTOM w0.076: U2030.BA44 75.21,60.43 74.94,60.7 74.59,60.7 74.55,60.7 74.44,60.7 74.05,60.7 73.36,60.02 72.66,60.02 72.41,60.27 71.17,60.27 71.06,60.38 v2(71.06,60.69)
M_B_CKE0: length 160.7
  TOP w0.102: v2(39.44,91.34) 39.07,91.71 U2009.K2 ; v2(39.73,80.69) 39.45,80.69 38.68,79.91 38.68,78.89 U2010.K2 ; v2(39.49,57.5) 39.17,57.5 39.07,57.41 U2011.K2
  TOP w0.165: U2012.K2 39.07,44.03 38.71,44.39 38.71,45.12 39.74,46.16 v2(40.23,46.16) ; R2101.2 38.95,98.51 39,98.46 v1(39,98.26)
  IN1 w0.089: v2(39.44,91.34) 39.44,91.41 40.57,92.55 41.25,92.55 41.36,92.44 41.36,91.11 38.93,88.68 38.93,84.94 39.2,84.66 39.82,84.66 39.92,84.56 39.92,84.34 39.82,84.23 39.56,84.23 39.46,84.13 39.46,83.93 39.56,83.83 39.82,83.83 39.92,83.73 39.92,83.52 39.82,83.42 39.56,83.42 39.46,83.32 39.46,83.12 39.56,83.02 39.82,83.02 39.92,82.91 39.92,82.71 39.82,82.61 39.56,82.61 39.46,82.51 39.46,82.3 39.56,82.2 39.82,82.2 39.92,82.1 39.92,81.9 39.82,81.8 39.56,81.8 39.46,81.69 39.46,81.49 39.56,81.39 39.82,81.39 39.92,81.29 39.92,81.16 39.73,80.97 v2(39.73,80.69) 40.38,80.04 40.38,77 39.4,76.02 39.4,74.91 40.33,73.97 40.33,69.11 40.91,68.53 40.91,59.62 40.33,59.04 40.33,58.42 39.49,57.58 v2(39.49,57.5) 39.49,57.33 39.76,57.06 40.47,57.06 40.55,56.98 40.55,56.76 40.48,56.69 40.18,56.69 40.07,56.58 40.07,56.47 40.19,56.36 40.5,56.36 40.57,56.29 40.57,56.07 40.48,55.98 40.32,55.98 40.23,55.89 40.23,55.77 40.32,55.68 40.47,55.68 40.56,55.58 40.56,55.46 40.48,55.37 40.32,55.37 40.21,55.26 40.21,55.09 40.28,55.02 40.49,55.02 40.57,54.94 40.57,54.73 40.5,54.66 40.37,54.66 40.31,54.6 40.31,53.78 40.4,53.69 40.52,53.69 40.61,53.61 40.61,53.48 40.52,53.39 40.4,53.39 40.31,53.3 40.31,53.17 40.4,53.08 40.52,53.08 40.61,53 40.61,52.87 40.52,52.78 40.4,52.78 40.31,52.69 40.31,52.56 40.4,52.48 40.52,52.48 40.61,52.39 40.61,52.26 40.52,52.17 40.4,52.17 40.31,52.08 40.31,51.95 40.4,51.87 40.52,51.87 40.61,51.78 40.61,51.65 40.52,51.56 40.22,51.56 40.13,51.47 40.13,51.35 40.22,51.26 40.52,51.26 40.61,51.17 40.61,51.04 40.52,50.95 40.25,50.95 40.16,50.86 40.16,50.74 40.25,50.65 40.52,50.65 40.61,50.56 40.61,50.43 40.52,50.34 40.27,50.34 40.18,50.25 40.18,50.13 40.27,50.04 40.52,50.04 40.61,49.95 40.61,49.82 40.52,49.73 39.87,49.73 39.78,49.64 39.78,49.52 39.87,49.43 40.48,49.43 40.57,49.34 40.57,49.21 40.48,49.12 39.99,49.12 39.9,49.03 39.9,48.91 39.99,48.82 40.47,48.82 40.56,48.73 40.56,48.6 40.47,48.51 40.08,48.51 39.99,48.42 39.99,48.3 40.08,48.21 40.39,48.21 40.48,48.12 40.48,47.99 40.39,47.9 40.09,47.9 40,47.81 40,47.68 40.09,47.58 40.38,47.58 40.48,47.48 40.48,47.35 40.38,47.25 39.82,47.25 39.74,47.17 39.74,46.76 39.85,46.64 39.85,46.22 40.02,46.05 40.12,46.05 v2(40.23,46.16)
  IN3 w0.079: v2(80.11,67.21) 80.52,67.62 81.55,67.62 81.93,67.24 81.93,62.95 81.24,62.27 81.24,61.45 80.96,61.17 80.96,60.7 80.26,60 80.08,60 79.78,60.3 79.4,60.3 79.35,60.35 78.69,60.35 78.64,60.39 77.09,60.39 77.02,60.33
  IN3 w0.089: 74.81,59.27 75.57,60.03 76.73,60.03 77.02,60.33
  IN3 w0.102: v1(39,98.26) 39,98.11 38.84,97.94 38.84,96.95 39.12,96.68 39.12,93.35 39.02,93.26 39.02,91.76 v2(39.44,91.34)
  IN3 w0.14: 74.81,59.27 73.43,57.89 73.27,57.89 73.04,58.13 72.88,58.13 72.73,57.97 72.73,57.82 72.97,57.58 72.97,57.43 72.78,57.24 72.62,57.24 72.3,57.55 67.3,57.55 66.78,57.03 60.87,57.03 60.38,57.52 59.63,57.52 59.04,56.93 56.5,56.93 56.23,56.66 50.99,56.66 50.75,56.89 49.43,56.89 49.01,57.32 49.01,57.47 49.17,57.63 49.17,57.81 49.03,57.95 48.83,57.95 48.55,57.66 48.24,57.66 47.58,58.33 46.99,58.33 46.37,58.94 44.47,58.94 43.89,59.53 41.94,59.53 41.09,58.67 41.09,58.31 41.41,57.98 41.41,56.23 41.19,56 41.19,55.18 40.49,54.47 40.49,54.03 40.74,53.77 40.98,53.77 41.35,54.15 41.48,54.15 41.64,53.99 41.64,53.8 41.31,53.46 41.31,50.31 41.6,50.01 42.12,50.01 42.28,50.17 42.28,51.35 42.45,51.52 42.6,51.52 42.73,51.39 42.73,50.58 43.57,49.74 43.57,49.08 44.61,48.05 44.61,47.66 44.26,47.31 41.42,47.31 40.56,46.44 40.52,46.44 v2(40.23,46.16)
  BOTTOM w0.102: U2030.AN56 80.46,67.56 v2(80.11,67.21)
M_B_CLK0: length 171.4
  TOP w0.076: v2(39.68,88.24) 39.53,88.24 39.25,87.97 39.25,87.94 U2009.K7 ; v2(40.39,75.59) 40.37,75.61 39.72,75.61 39.26,75.15 39.26,74.91 39.2,74.84 38.9,74.84 38.82,74.76 38.82,74.59 38.91,74.5 U2010.K7 ; v2(41.31,54.73) 41.19,54.85 41.01,54.85 40.79,54.63 40.43,54.63 39.46,53.66 39.04,53.66 38.83,53.44 38.83,53.33 U2011.K7 ; U2012.K7 38.89,39.88 38.8,39.79 38.8,39.61 38.94,39.47 v2(39.47,39.47)
  TOP w0.165: C2173.1 79.44,61.76 v2(79.44,61.7) ; R2100.2 41.07,99.31 v1(41.07,98.82)
  IN1 w0.089: v2(39.68,88.24) 39.65,88.22 39.65,87.97 39.75,87.87 40.17,87.87 40.56,87.48 40.56,85.76 40.66,85.65 41.35,85.65 41.62,85.38 41.62,84.91 41.35,84.64 40.66,84.64 40.56,84.54 40.56,83.24 40.66,83.14 41.37,83.14 41.64,82.87 41.64,82.37 41.4,82.12 40.66,82.12 40.56,82.02 40.56,81.59 41.03,81.13 41.03,79.68 41.13,79.58 41.61,79.58 41.86,79.34 41.86,78.81 41.61,78.57 41.13,78.57 41.03,78.47 41.03,76.82 40.08,75.87 40.08,75.67 40.15,75.59 v2(40.39,75.59) 40.39,75.03 41.16,74.27 41.16,69.47 42.69,67.94 42.69,66.91 42.47,66.69 41.87,66.69 41.77,66.59 41.77,66.24 42.02,65.99 42.47,65.99 42.69,65.77 42.69,65.13 42.47,64.91 41.98,64.91 41.85,64.79 41.85,64.43 41.98,64.3 42.47,64.3 42.69,64.08 42.69,63.51 42.47,63.29 41.92,63.29 41.79,63.16 41.79,62.81 41.92,62.68 42.47,62.68 42.69,62.46 42.69,60.48 41.05,58.84 41.05,54.79 41.11,54.73 v2(41.31,54.73) 41.31,54.04 41.17,53.9 41.17,46.73 40.91,46.47 40.91,45.91 41.49,45.32 41.49,41.28 40.17,39.96 39.09,39.96 38.92,39.78 38.92,39.35 39.14,39.14 39.37,39.14 39.47,39.23 v2(39.47,39.47)
  IN3 w0.079: 77.02,62.04 77.04,62.04 77.1,62.1 79.62,62.1 79.69,62.03 79.69,61.94 v2(79.44,61.7)
  IN3 w0.102: v1(41.07,98.82) 41.07,92.79 40.58,92.31 40.58,91.04 40.22,90.68 40.22,88.13 39.95,87.85 39.75,87.85 39.65,87.95 39.65,88.22 v2(39.68,88.24)
  IN3 w0.14: v2(39.47,39.47) 39.47,39.31 39.31,39.16 38.93,39.16 37.2,37.43 34.19,37.43 33.51,38.11 33.51,42.2 33.16,42.56 33.16,43.21 32.15,44.22 32.15,45.21 31.33,46.03 31.33,53.81 31.53,54.01 31.53,55.3 31.25,55.59 31.25,56.67 34.61,60.03 35.24,60.03 38.21,63 38.73,63 40.21,64.48 46.39,64.48 46.69,64.77 46.69,64.95 46.83,65.09 47.18,65.09 47.32,64.95 47.32,64.77 47.61,64.48 48.27,64.48 48.52,64.73 48.52,64.95 48.66,65.09 48.96,65.09 49.1,64.95 49.1,64.75 49.36,64.48 49.96,64.48 50.3,64.81 50.3,65.09 50.43,65.22 50.75,65.22 50.9,65.08 50.9,64.8 51.31,64.39 53.24,64.39 53.52,64.67 53.52,65.33 53.66,65.47 53.93,65.47 54.55,64.86 56.55,64.86 56.92,64.49 65.31,64.49 66.75,63.05 68.11,63.05 69.4,61.76 72.94,61.76 73.77,62.58 75.18,62.58 75.72,62.04 77.02,62.04
  BOTTOM w0.102: v2(79.44,61.7) 79.57,61.7 79.65,61.62 79.65,61.48 79.5,61.34 79.5,61.18 79.58,61.1 79.71,61.1 U2030.AP45
M_B_CLK0#: length 170.5
  TOP w0.076: U2011.K8 39.07,52.55 39.49,52.97 39.49,53.45 40.5,54.47 40.78,54.47 40.89,54.36 v2(40.89,54.25) ; v2(39.87,75.2) 39.85,75.22 39.57,75.22 39.43,75.08 39.43,74.34 39.2,74.12 39.2,73.83 U2010.K8 ; U2009.K8 v2(39.47,87.36) ; v2(39.47,38.7) 39.45,38.7 U2012.K8
  TOP w0.165: v1(41.77,98.82) 41.74,98.84 41.74,99.29 R2099.2 ; C2173.2 80.15,61.69 v2(80.07,61.69)
  IN1 w0.089: v2(39.47,87.36) 39.47,87.44 39.7,87.67 40.09,87.67 40.36,87.4 40.36,85.67 40.58,85.45 41.26,85.45 41.42,85.3 41.42,84.99 41.26,84.84 40.58,84.84 40.36,84.62 40.36,83.15 40.58,82.93 41.29,82.93 41.44,82.78 41.44,82.45 41.31,82.32 40.58,82.32 40.36,82.1 40.36,81.5 40.82,81.04 40.82,79.6 41.04,79.38 41.53,79.38 41.65,79.25 41.65,78.9 41.53,78.77 41.04,78.77 40.82,78.55 40.82,76.91 39.87,75.96 v2(39.87,75.2) 39.93,75.2 40.95,74.18 40.95,69.39 42.49,67.86 42.49,66.99 42.39,66.89 41.79,66.89 41.57,66.67 41.57,66.12 41.9,65.79 42.39,65.79 42.49,65.68 42.49,65.22 42.39,65.12 41.9,65.12 41.65,64.87 41.65,64.35 41.9,64.1 42.39,64.1 42.49,64 42.49,63.59 42.39,63.49 41.84,63.49 41.59,63.24 41.59,62.72 41.84,62.47 42.39,62.47 42.49,62.37 42.49,60.57 40.84,58.92 40.84,54.29 v2(40.89,54.25) 40.96,54.17 40.96,46.81 40.7,46.56 40.7,45.83 41.29,45.24 41.29,41.36 40.09,40.16 39.01,40.16 38.72,39.87 38.72,39.27 39.05,38.94 39.24,38.94 v2(39.47,38.7)
  IN3 w0.079: v2(80.07,61.69) 79.85,61.92 79.85,62.09 79.69,62.25 77.09,62.25 77.03,62.31 77.02,62.31
  IN3 w0.102: 41.71,98.75 41.42,98.47 41.37,98.47 41.27,98.36 41.27,92.71 40.81,92.25 40.81,90.98 40.43,90.59 40.43,88.04 40.03,87.65 39.76,87.65 v2(39.47,87.36)
  IN3 w0.14: 41.71,98.75 v1(41.77,98.82) ; v2(39.47,38.7) 39.47,38.71 39.29,38.89 39.04,38.89 37.31,37.16 34.08,37.16 33.25,38 33.25,42.09 32.89,42.45 32.89,43.1 31.89,44.11 31.89,45.1 31.06,45.92 31.06,53.92 31.27,54.12 31.27,55.19 30.98,55.47 30.98,56.78 34.5,60.3 35.13,60.3 38.1,63.26 38.62,63.26 40.1,64.75 46.28,64.75 46.42,64.89 46.42,65.06 46.72,65.36 47.29,65.36 47.59,65.06 47.59,64.88 47.72,64.75 48.16,64.75 48.25,64.84 48.25,65.06 48.55,65.36 49.07,65.36 49.36,65.06 49.36,64.86 49.48,64.75 49.85,64.75 50.03,64.93 50.03,65.2 50.32,65.49 50.86,65.49 51.17,65.19 51.17,64.91 51.42,64.65 53.13,64.65 53.25,64.78 53.25,65.44 53.55,65.74 54.04,65.74 54.66,65.13 56.66,65.13 57.03,64.76 65.42,64.76 66.86,63.32 68.22,63.32 69.51,62.03 72.83,62.03 73.66,62.85 75.29,62.85 75.83,62.31 77.02,62.31
  BOTTOM w0.102: v2(80.07,61.69) 80.07,61.6 U2030.AN45
M_B_CS#0: length 159.7
  TOP w0.102: v2(39.22,40.61) 39.15,40.55 39.02,40.55 38.35,39.88 U2012.L7 ; v2(38.68,74.11) 38.59,74.03 38.06,74.03 38,74.08 38,74.43 38.07,74.5 U2010.L7 ; U2009.L7 38.27,88.42 38.37,88.52 38.63,88.52 38.75,88.63 38.75,88.83 38.66,88.92 38.29,88.92 38.21,89 38.21,89.38 38.29,89.46 v2(38.66,89.46) ; v2(39.29,54.36) 38.9,53.97 38.75,53.97 38.51,54.22 38.37,54.22 38.22,54.07 38.22,53.93 38.46,53.68 38.46,53.54 38.27,53.34 U2011.L7
  TOP w0.165: R2109.2 38.42,96.81 v2(38.42,96.1)
  IN1 w0.089: v2(38.66,89.46) 38.46,89.26 38.46,81.9 38.86,81.51 38.86,77.78 39.2,77.44 39.2,77.14 38.55,76.49 38.55,74.24 v2(38.68,74.11) 39.07,73.72 39.07,72.74 39.53,72.27 39.53,68.29 39.62,68.2 40.06,68.2 40.18,68.08 40.18,67.62 40.08,67.51 39.57,67.51 39.47,67.41 39.47,67.21 39.57,67.11 40.08,67.11 40.18,67.01 40.18,66.8 40.08,66.7 39.54,66.7 39.44,66.6 39.44,66.4 39.53,66.3 40.05,66.3 40.15,66.2 40.15,65.93 40.02,65.8 39.47,65.8 39.4,65.73 39.4,65.53 39.54,65.39 40.08,65.39 40.18,65.29 40.18,65.09 40.08,64.98 39.47,64.98 39.38,64.89 39.38,64.69 39.48,64.58 40.08,64.58 40.18,64.48 40.18,60.94 38.69,59.45 38.69,56.88 39.67,55.9 39.67,54.75 v2(39.29,54.36) 39.12,54.36 39.02,54.27 39.02,54.05 39.26,53.81 39.26,52.84 39.39,52.71 39.7,52.71 39.8,52.61 39.8,52.39 39.74,52.33 39.05,52.33 38.92,52.21 38.92,48.32 39.01,48.23 39.22,48.23 39.31,48.14 39.31,48.01 39.22,47.92 39.01,47.92 38.92,47.83 38.92,47.64 39.24,47.33 39.24,45.81 39.38,45.68 39.68,45.68 40.21,45.15 40.21,45.02 39.86,44.68 39.86,44.55 39.95,44.46 40.08,44.46 40.42,44.81 40.55,44.81 40.7,44.65 40.7,41.76 40.43,41.49 39.95,41.49 39.8,41.34 39.66,41.34 39.51,41.49 39.24,41.49 39.13,41.37 39.13,40.7 v2(39.22,40.61)
  IN3 w0.089: 67.9,57.89 68.03,57.76 72.16,57.76 72.79,58.39 v2(72.79,58.97)
  IN3 w0.102: v2(38.66,89.46) 38.66,89.74 37.9,90.5 37.9,95.58 v2(38.42,96.1)
  IN3 w0.14: v2(39.22,40.61) 39.3,40.7 39.3,41.21 39.48,41.39 40.05,41.39 40.19,41.25 40.19,37.63 40.98,36.84 43.9,36.84 44.49,37.43 44.49,39.89 43.92,40.46 43.92,44.6 43.74,44.77 43.38,44.77 42.39,45.76 39.96,45.76 39.74,45.98 39.74,46.9 40.46,47.62 43.98,47.62 44.16,47.81 44.16,48.15 43.33,48.98 43.33,49.4 43.11,49.62 41.4,49.62 40.9,50.12 40.9,53.16 40.07,54 40.07,54.49 40.83,55.26 40.83,56.12 41.01,56.3 41.01,57.91 40.72,58.2 40.72,58.75 42.03,60.06 44.38,60.06 44.55,59.89 44.55,59.64 44.67,59.51 44.91,59.51 45.04,59.63 45.04,60.14 45.16,60.26 45.33,60.26 45.46,60.14 45.46,59.6 45.56,59.49 46.6,59.49 47.21,58.88 48.88,58.88 49.72,58.04 49.72,57.77 49.94,57.55 52.97,57.55 53.07,57.45 53.07,57.31 53.17,57.21 54.46,57.21 54.56,57.31 54.56,57.45 54.66,57.55 56.32,57.55 56.4,57.48 58.82,57.48 59.41,58.07 60.6,58.07 61.09,57.58 66.56,57.58 67.08,58.1 67.69,58.1 67.9,57.89
  BOTTOM w0.076: v2(72.79,58.97) 72.89,59.07 73.73,59.07 73.79,59.01 74.64,59.01 U2030.BB42
M_B_DQ0: length 57.9
  TOP w0.102: v2(46.15,88.98) 46.15,89.71 45.1,90.77 45.1,91.33 U2009.C2
  IN3 w0.089: v2(84.37,72.09) 84.89,72.61 85.16,72.88 85.16,74.14 84.31,74.99 84.31,75.56 82.68,77.19 82.03,77.19 81.59,77.63 81.59,79.31 81.39,79.5 81.39,80.46 80.9,80.95 80.47,80.95 79.88,81.54 79.05,81.54 78.07,82.52 78.07,82.64 78.34,82.91 78.34,83.06 78.22,83.19 78.12,83.19 77.82,82.9 77.7,82.9 77.22,83.37 70.29,83.37 65,88.67 62.18,88.67 62.1,88.75 62.1,88.97 62.01,89.06 61.83,89.06 61.74,88.97 61.74,88.75 61.65,88.67 61.41,88.67 61.32,88.75 61.32,89.06 61.23,89.15 61.05,89.15 60.96,89.06 60.96,88.75 60.88,88.67 60.7,88.67 60.61,88.75 60.61,89.06 60.52,89.15 60.34,89.15 60.25,89.06 60.25,88.75 60.16,88.67 59.99,88.67 59.9,88.75 59.9,89.06 59.81,89.15 59.63,89.15 59.54,89.06 59.54,88.75 59.45,88.67 59.28,88.67 59.19,88.75 59.19,89.11 59.1,89.2 56.95,89.2 56.42,88.67 47.08,88.67 47.01,88.59 46.54,88.59 v2(46.15,88.98)
  BOTTOM w0.114: U2030.AF65 v2(84.37,72.09)
M_B_DQ1: length 56.6
  TOP w0.102: U2009.A3 46.84,90.39 v2(46.84,88.99)
  IN3 w0.089: v2(84.37,71.44) 85.21,72.28 85.51,72.58 85.51,74.3 84.59,75.22 84.59,75.74 82.84,77.5 82.84,79.61 82.68,79.76 81.76,79.76 81.63,79.89 81.63,80.56 81,81.19 80.68,81.19 79.94,81.93 79.94,82.09 79.34,82.68 79.09,82.68 78.97,82.57 78.85,82.57 78.72,82.69 78.72,82.82 78.84,82.94 78.84,83.06 78.29,83.61 70.39,83.61 65.09,88.91 64.68,88.91 64.58,89.01 64.58,89.34 64.48,89.44 64.31,89.44 64.22,89.35 64.22,89 64.13,88.91 63.96,88.91 63.87,89 63.87,89.35 63.78,89.44 63.6,89.44 63.51,89.35 63.51,89 63.42,88.91 63.25,88.91 63.16,89 63.16,89.35 63.07,89.44 62.89,89.44 62.8,89.35 62.8,89 62.71,88.91 62.53,88.91 62.45,89 62.45,89.35 62.36,89.44 56.85,89.44 56.32,88.91 46.93,88.91 v2(46.84,88.99)
  BOTTOM w0.114: U2030.AF64 v2(84.37,71.44)
M_B_DQ2: length 56.6
  TOP w0.102: U2009.B8 v2(45.07,86.56)
  IN3 w0.089: v2(82.53,72.65) 82.28,72.89 82.28,74.02 81.63,74.67 81.63,74.96 79.41,77.18 79.41,77.83 78.75,78.49 78.75,79.59 78.65,79.69 78.37,79.69 78.29,79.62 78.29,79.36 78.23,79.3 77.63,79.3 76.86,80.07 76.72,80.07 75.1,81.7 68.98,81.7 66.06,84.61 64.95,84.61 64.86,84.7 64.86,85.41 64.78,85.5 64.6,85.5 64.51,85.41 64.51,84.7 64.42,84.61 64.24,84.61 64.15,84.7 64.15,86.12 64.06,86.21 63.89,86.21 63.8,86.12 63.8,84.7 63.71,84.61 63.52,84.61 63.42,84.71 63.42,86.21 63.33,86.3 63.16,86.3 63.05,86.19 63.05,85.2 62.95,85.1 62.83,85.1 62.7,85.23 62.7,86.17 62.57,86.3 62.42,86.3 62.32,86.19 62.32,85.97 62.22,85.86 62.06,85.86 61.96,85.97 61.96,86.14 61.81,86.3 47.61,86.3 47.49,86.18 47.49,85.7 47.4,85.61 47.22,85.61 47.14,85.7 47.14,86.04 47.05,86.12 46.87,86.12 46.78,86.04 46.78,85.7 46.69,85.61 46.51,85.61 46.42,85.7 46.42,86.04 46.34,86.12 45.5,86.12 v2(45.07,86.56)
  BOTTOM w0.114: v2(82.53,72.65) 82.43,72.6 U2030.AK65
M_B_DQ3: length 57.4
  TOP w0.102: U2009.D7 43.47,87.36 v2(43.47,87.31)
  IN3 w0.089: v2(81.66,71.44) 81.18,71.92 81.18,73.79 80.63,74.34 80.63,74.72 80.04,75.3 78.63,75.3 77.25,76.68 77.25,78.66 76.66,79.25 75.29,79.25 73.57,80.97 68.68,80.97 65.76,83.89 62.77,83.89 61.93,84.73 61.77,84.73 61.68,84.64 61.68,84.3 61.58,84.19 61.4,84.19 61.33,84.27 61.33,84.65 61.25,84.73 61.04,84.73 60.95,84.64 60.95,84.36 60.86,84.28 60.69,84.28 60.6,84.36 60.6,84.64 60.51,84.73 60.33,84.73 60.24,84.64 60.24,84.36 60.15,84.28 59.97,84.28 59.89,84.36 59.89,84.64 59.8,84.73 59.62,84.73 59.53,84.64 59.53,84.36 59.44,84.28 59.26,84.28 59.17,84.36 59.17,84.64 59.09,84.73 58.91,84.73 58.82,84.64 58.82,84.36 58.73,84.28 58.55,84.28 58.46,84.36 58.46,84.64 58.37,84.73 58.2,84.73 58.11,84.64 58.11,84.36 58.02,84.28 57.84,84.28 57.75,84.36 57.75,84.64 57.66,84.73 57.49,84.73 57.4,84.64 57.4,84.36 57.31,84.28 57.13,84.28 57.04,84.36 57.04,84.64 56.95,84.73 54.3,84.73 54.21,84.64 54.21,84.36 54.13,84.28 53.95,84.28 53.86,84.36 53.86,84.64 53.77,84.73 50.01,84.73 49.92,84.64 49.92,84.22 49.83,84.13 49.65,84.13 49.56,84.22 49.56,84.64 49.47,84.73 49.29,84.73 49.21,84.64 49.21,84.22 49.12,84.13 48.94,84.13 48.85,84.22 48.85,84.64 48.76,84.73 48.49,84.73 48.4,84.64 48.4,84.45 48.31,84.36 48.14,84.36 48.05,84.45 48.05,84.64 47.96,84.73 44.85,84.73 43.98,85.6 43.98,86.8 v2(43.47,87.31)
  BOTTOM w0.114: U2030.AK64 v2(81.66,71.44)
M_B_DQ4: length 57.1
  TOP w0.102: U2009.C3 44.67,90.72 45.03,90.36 45.03,88.55 v2(45.21,88.36)
  IN3 w0.089: v2(84.37,72.74) 84.56,72.93 84.82,73.19 84.82,74.02 84.06,74.77 84.06,75.34 82.49,76.91 81.95,76.91 81.34,77.52 81.34,79.16 81.2,79.31 81.2,80.31 80.8,80.71 80.37,80.71 79.78,81.3 78.26,81.3 77.98,81.57 77.98,81.69 78.12,81.83 78.12,81.98 78,82.11 77.9,82.11 77.73,81.95 77.61,81.95 77.48,82.07 77.48,82.2 77.67,82.39 77.67,82.51 77.54,82.64 77.42,82.64 77.23,82.45 77.1,82.45 76.99,82.56 76.99,82.68 77.18,82.87 77.18,82.97 77.07,83.07 76.92,83.07 76.78,82.93 76.63,82.93 76.42,83.13 69.68,83.13 66.62,86.19 66.23,86.19 65.6,86.82 65.6,87.72 64.9,88.42 58.99,88.42 58.9,88.51 58.9,88.77 58.81,88.86 58.64,88.86 58.57,88.8 58.57,88.54 58.46,88.42 58.28,88.42 58.19,88.51 58.19,88.8 58.1,88.89 57.92,88.89 57.84,88.8 57.84,88.51 57.75,88.42 57.57,88.42 57.48,88.51 57.48,88.8 57.39,88.89 57.21,88.89 57.12,88.8 57.12,88.51 57.04,88.42 47.18,88.42 47.03,88.28 46.01,88.28 45.73,88.56 45.4,88.56 v2(45.21,88.36)
  BOTTOM w0.114: U2030.AF66 v2(84.37,72.74)
M_B_DQ5: length 56.5
  TOP w0.102: U2009.D3 44.54,90.28 v2(44.54,88.34)
  IN3 w0.089: v2(44.54,88.34) 44.54,88.04 44.66,87.92 47.15,87.92 47.42,88.18 62.92,88.18 63.05,88.05 63.05,87.59 63.15,87.49 63.31,87.49 63.41,87.59 63.41,88.08 63.51,88.18 63.66,88.18 63.77,88.07 63.77,87.59 63.87,87.49 64.04,87.49 64.17,87.62 64.17,88.06 64.26,88.14 64.46,88.14 64.53,88.07 64.53,87.46 64.63,87.36 64.77,87.36 64.88,87.48 64.88,87.74 64.96,87.82 65.14,87.82 65.24,87.72 65.24,86.73 66.16,85.81 66.67,85.81 69.58,82.89 76.18,82.89 78.02,81.05 79.68,81.05 80.27,80.46 80.7,80.46 80.99,80.17 80.99,79.15 81.12,79.03 81.12,77.42 81.47,77.07 81.47,76.89 81.3,76.72 81.3,76.58 81.46,76.42 81.58,76.42 81.8,76.63 82.3,76.63 83.81,75.13 83.81,74.56 84.37,73.99 v2(84.37,73.39)
  BOTTOM w0.114: U2030.AF67 v2(84.37,73.39)
M_B_DQ6: length 55.3
  TOP w0.102: U2009.C7 44.27,87.36 v2(44.27,87.31)
  IN3 w0.089: v2(44.27,87.31) 44.27,85.65 44.95,84.97 57.47,84.97 57.56,85.06 57.56,85.44 57.64,85.53 57.82,85.53 57.91,85.44 57.91,85.06 58,84.97 58.18,84.97 58.27,85.06 58.27,85.44 58.36,85.53 58.53,85.53 58.62,85.44 58.62,85.06 58.71,84.97 58.89,84.97 58.98,85.06 58.98,85.44 59.07,85.53 59.24,85.53 59.33,85.44 59.33,85.06 59.42,84.97 59.6,84.97 59.69,85.06 59.69,85.44 59.78,85.53 59.96,85.53 60.05,85.44 60.05,85.06 60.13,84.97 60.31,84.97 60.4,85.06 60.4,85.44 60.49,85.53 60.67,85.53 60.76,85.44 60.76,85.06 60.85,84.97 61.02,84.97 61.11,85.06 61.11,85.44 61.2,85.53 61.38,85.53 61.47,85.44 61.47,85.06 61.56,84.97 62.17,84.97 63.01,84.13 65.86,84.13 68.78,81.21 73.67,81.21 74.41,80.47 74.56,80.47 74.98,80.9 75.08,80.9 75.21,80.77 75.21,80.62 74.81,80.22 74.81,80.07 74.93,79.95 75.04,79.95 75.51,80.42 75.64,80.42 75.76,80.29 75.76,80.17 75.34,79.74 75.34,79.62 75.46,79.49 75.6,79.49 76.01,79.89 76.11,79.89 76.45,79.55 76.7,79.55 77.51,78.74 77.51,76.83 78.72,75.61 80.09,75.61 80.96,74.74 80.96,74.55 81.6,73.9 v2(81.6,73.44)
  BOTTOM w0.114: v2(81.6,73.44) 81.84,73.58 U2030.AK67
M_B_DQ7: length 55.8
  TOP w0.102: U2009.C8 45.07,87.35 v2(45.07,87.36)
  IN3 w0.089: v2(45.07,87.36) 44.56,86.86 44.56,85.7 44.95,85.31 48.01,85.31 48.1,85.4 48.1,85.93 48.19,86.02 48.37,86.02 48.46,85.93 48.46,85.4 48.55,85.31 48.72,85.31 48.81,85.4 48.81,85.93 48.9,86.02 49.08,86.02 49.17,85.93 49.17,85.4 49.26,85.31 49.5,85.31 49.62,85.43 49.62,85.81 49.71,85.9 49.89,85.9 49.98,85.81 49.98,85.43 50.06,85.34 50.24,85.34 50.33,85.43 50.33,85.81 50.42,85.9 50.6,85.9 50.69,85.81 50.69,85.43 50.78,85.34 50.95,85.34 51.04,85.43 51.04,85.81 51.13,85.9 54.16,85.9 54.25,85.81 54.25,85.32 54.3,85.26 54.33,85.23 54.51,85.23 54.6,85.32 54.6,85.81 54.69,85.9 54.87,85.9 54.96,85.81 54.96,85.32 55.05,85.23 55.22,85.23 55.31,85.32 55.31,85.81 55.4,85.9 61.67,85.9 63.2,84.37 65.96,84.37 68.88,81.45 74.98,81.45 76.64,79.8 76.8,79.8 77.79,78.81 77.79,77.01 78.83,75.97 79.13,75.97 79.21,76.05 79.21,76.29 79.3,76.38 79.45,76.38 79.54,76.29 79.54,76.04 79.61,75.97 80.19,75.97 81.31,74.85 81.31,74.57 82.02,73.86 82.02,73.19 81.6,72.76 v2(81.6,72.74)
  BOTTOM w0.114: U2030.AK66 v2(81.6,72.74)
M_B_DQ8: length 62.3
  TOP w0.102: U2009.H3 v2(41.35,90.28)
  IN3 w0.089: v2(41.35,90.28) 41.8,90.73 41.8,92.49 43.34,94.02 43.46,94.02 43.66,93.83 43.79,93.83 43.91,93.95 43.91,94.08 43.72,94.27 43.72,94.4 43.83,94.52 43.94,94.52 44.18,94.27 44.37,94.27 44.77,94.66 49.51,94.66 50.03,94.14 53.59,94.14 54.34,93.39 57.22,93.39 57.57,93.04 73.36,93.04 75.31,91.09 75.31,90.79 79.26,86.84 80.72,86.84 86.59,80.97 86.59,78.12 85.51,77.03 v2(85.21,77.03)
  BOTTOM w0.102: U2030.AF70 84.22,75.85 84.76,76.39 84.76,76.58 v2(85.21,77.03)
M_B_DQ9: length 64.3
  TOP w0.102: U2009.H2 40.67,91.98 41.13,92.44 41.13,93.22 41.72,93.82 v2(41.82,93.82)
  IN3 w0.089: v2(85.22,75.86) 85.27,75.86 86.87,77.46 87.07,77.66 87.07,81.17 80.92,87.32 79.46,87.32 75.79,90.99 75.79,91.29 73.57,93.52 57.77,93.52 57.42,93.88 54.54,93.88 53.38,95.03 50.84,95.03 50.73,95.14 47.08,95.14 46.99,95.23 46.99,95.55 46.91,95.64 46.73,95.64 46.64,95.55 46.64,95.23 46.55,95.14 46.37,95.14 46.28,95.23 46.28,95.5 46.19,95.59 46.02,95.59 45.93,95.5 45.93,95.23 45.84,95.14 43.14,95.14 42.97,94.97 42.97,94.85 43.04,94.78 43.04,94.65 42.91,94.53 42.79,94.53 42.72,94.6 42.59,94.6 v2(41.82,93.82)
  BOTTOM w0.102: v2(85.22,75.86) 85.18,75.86 84.49,75.17 84.49,74.73 U2030.AF68
M_B_DQ10: length 62.6
  TOP w0.102: U2009.J7 40.35,88.23 40.35,88.47 40.61,88.74 41.35,88.74 41.78,88.31 v2(41.78,88.31)
  IN3 w0.089: v2(41.78,88.31) 42.23,88.76 43.4,88.76 45.17,90.54 50.64,90.54 51.39,91.29 60.82,91.29 60.91,91.2 60.91,90.65 61,90.56 61.18,90.56 61.27,90.65 61.27,91.1 61.35,91.19 61.53,91.19 61.62,91.1 61.62,90.65 61.71,90.56 61.89,90.56 61.98,90.65 61.98,91.1 62.07,91.19 62.24,91.19 62.33,91.1 62.33,90.65 62.42,90.56 62.6,90.56 62.69,90.65 62.69,91.1 62.78,91.19 62.95,91.19 63.04,91.1 63.04,90.65 63.13,90.56 63.31,90.56 63.4,90.65 63.4,91.1 63.49,91.19 63.67,91.19 63.75,91.1 63.75,90.65 63.84,90.56 64.02,90.56 64.11,90.65 64.11,91.1 64.2,91.19 64.38,91.19 64.47,91.1 64.47,90.65 64.55,90.56 64.73,90.56 64.83,90.66 64.83,91.07 64.93,91.17 65.11,91.17 65.24,91.05 65.24,90.61 65.34,90.51 66.1,90.51 67.77,88.84 67.77,88.08 71.07,84.78 80.13,84.78 81.62,83.29 81.62,82.64 83.65,80.6 83.65,80.24 84.18,79.71 84.18,79.27 v2(83.8,78.89)
  BOTTOM w0.076: v2(83.8,78.89) 83.19,78.28 83.19,77.75 83.08,77.64 83.08,77.09 82.89,76.9 U2030.AH71
M_B_DQ11: length 64.4
  TOP w0.102: v2(41.1,88.29) 40.67,87.86 U2009.H7
  IN3 w0.089: v2(41.1,88.29) 41.91,89.1 43.26,89.1 44.98,90.82 47.53,90.82 47.64,90.92 47.64,91.68 47.74,91.79 47.9,91.79 47.99,91.7 47.99,90.91 48.08,90.82 48.26,90.82 48.35,90.91 48.35,91.7 48.44,91.79 48.62,91.79 48.7,91.7 48.7,90.91 48.79,90.82 48.97,90.82 49.06,90.91 49.06,91.7 49.15,91.79 49.33,91.79 49.42,91.7 49.42,90.91 49.5,90.82 49.68,90.82 49.77,90.91 49.77,91.57 49.86,91.66 50.04,91.66 50.13,91.57 50.13,90.91 50.22,90.82 50.39,90.82 50.48,90.91 50.48,91.44 50.57,91.53 65.42,91.53 68.01,88.94 68.01,88.18 71.17,85.02 80.23,85.02 81.86,83.39 81.86,82.74 83.91,80.69 83.91,80.33 84.47,79.77 84.47,79.11 84.27,78.91 84.27,78.21 v2(83.78,77.72)
  BOTTOM w0.076: U2030.AH68 82.89,74.59 83.24,74.93 83.24,75.33 83.35,75.56 83.35,75.75 83.28,75.91 83.28,76.07 83.33,76.19 83.33,76.8 83.41,76.88 83.41,77.35 v2(83.78,77.72)
M_B_DQ12: length 61.7
  TOP w0.102: U2009.J3 41.22,89.61 v2(41.34,89.61)
  IN3 w0.089: v2(41.34,89.61) 42.13,90.4 42.13,92.35 43.32,93.53 44.02,93.53 44.91,94.42 49.41,94.42 49.93,93.9 53.49,93.9 54.24,93.15 57.12,93.15 57.47,92.8 73.26,92.8 75.07,90.99 75.07,90.69 79.16,86.6 80.62,86.6 86.35,80.87 86.35,78.22 85.75,77.61 v2(85.17,77.61)
  BOTTOM w0.102: v2(85.17,77.61) 84.8,77.24 84.8,77.01 84.5,76.72 84.5,76.6 U2030.AF71
M_B_DQ13: length 63.5
  TOP w0.102: U2009.G2 41.86,92.15 41.86,92.7 42.46,93.29 v2(42.46,93.82)
  IN3 w0.089: v2(85.22,76.44) 85.51,76.44 86.83,77.76 86.83,81.07 80.82,87.08 79.36,87.08 75.55,90.89 75.55,91.19 73.46,93.28 57.67,93.28 57.32,93.64 54.44,93.64 53.38,94.69 53.25,94.69 53.17,94.61 53.17,94.47 53.08,94.39 52.94,94.39 52.85,94.47 52.85,94.68 52.76,94.77 52.58,94.77 52.49,94.68 52.49,94.47 52.41,94.39 52.23,94.39 52.14,94.47 52.14,94.68 52.05,94.77 51.87,94.77 51.78,94.68 51.78,94.47 51.69,94.39 51.52,94.39 51.43,94.47 51.43,94.65 51.34,94.74 51.16,94.74 51.07,94.65 51.07,94.47 50.98,94.39 50.81,94.39 50.72,94.47 50.72,94.81 50.63,94.9 50.45,94.9 50.36,94.81 50.36,94.47 50.27,94.39 50.13,94.39 50.03,94.48 50.03,94.79 49.92,94.9 43.75,94.9 42.66,93.82 v2(42.46,93.82)
  BOTTOM w0.102: U2030.AF69 84.12,75.12 84.81,75.81 84.81,76.03 v2(85.22,76.44)
M_B_DQ14: length 63.1
  TOP w0.102: U2009.F7 42.43,87.91 v2(42.43,88.31)
  IN3 w0.089: v2(83.8,79.52) 83.41,79.92 83.41,80.5 81.38,82.54 81.38,83.19 80.03,84.54 70.97,84.54 67.53,87.98 67.53,88.74 66.06,90.21 60.67,90.21 60.58,90.3 60.58,90.91 60.49,90.99 60.31,90.99 60.22,90.91 60.22,90.3 60.14,90.21 59.96,90.21 59.87,90.3 59.87,90.91 59.78,90.99 59.6,90.99 59.51,90.91 59.51,90.3 59.42,90.21 59.25,90.21 59.16,90.3 59.16,90.91 59.07,90.99 58.89,90.99 58.8,90.91 58.8,90.3 58.71,90.21 58.53,90.21 58.45,90.3 58.45,90.91 58.36,90.99 58.18,90.99 58.09,90.91 58.09,90.3 58,90.21 57.82,90.21 57.73,90.3 57.73,90.91 57.65,90.99 57.47,90.99 57.38,90.91 57.38,90.3 57.29,90.21 55.21,90.21 55.13,90.3 55.13,90.78 55.04,90.87 54.86,90.87 54.77,90.78 54.77,90.3 54.68,90.21 54.5,90.21 54.41,90.3 54.41,90.78 54.33,90.87 54.15,90.87 54.06,90.78 54.06,90.3 53.97,90.21 53.79,90.21 53.7,90.3 53.7,90.78 53.61,90.87 53.44,90.87 53.35,90.78 53.35,90.3 53.26,90.21 45.25,90.21 43.46,88.41 42.53,88.41 v2(42.43,88.31)
  BOTTOM w0.076: 83.29,79.18 83.01,78.9 83.01,77.85 82.92,77.76 82.92,77.18 82.63,76.89 82.63,76.21 82.69,76.06 82.69,75.87 U2030.AH70
  BOTTOM w0.102: 83.29,79.18 83.46,79.18 v2(83.8,79.52)
M_B_DQ15: length 63.5
  TOP w0.102: U2009.H8 41.07,87.35 v2(41.11,87.35)
  IN3 w0.089: v2(41.11,87.35) 41.55,87.8 42.53,87.8 42.9,88.17 43.62,88.17 45.38,89.93 46.44,89.93 46.53,89.84 46.53,89.64 46.62,89.55 46.8,89.55 46.89,89.64 46.89,89.84 46.97,89.93 47.15,89.93 47.24,89.84 47.24,89.66 47.33,89.57 47.51,89.57 47.6,89.66 47.6,89.84 47.69,89.93 47.86,89.93 47.95,89.84 47.95,89.61 48.04,89.52 48.22,89.52 48.31,89.61 48.31,89.84 48.4,89.93 48.57,89.93 48.66,89.84 48.66,89.61 48.75,89.52 48.93,89.52 49.02,89.61 49.02,89.84 49.11,89.93 49.29,89.93 49.37,89.84 49.37,89.61 49.46,89.52 49.64,89.52 49.73,89.61 49.73,89.84 49.82,89.93 50,89.93 50.09,89.84 50.09,89.61 50.17,89.52 50.35,89.52 50.44,89.61 50.44,89.84 50.53,89.93 50.71,89.93 50.8,89.84 50.8,89.61 50.89,89.52 51.06,89.52 51.15,89.61 51.15,89.84 51.24,89.93 51.42,89.93 51.51,89.84 51.51,89.61 51.6,89.52 51.78,89.52 51.86,89.61 51.86,89.84 51.95,89.93 64.77,89.93 65.32,89.38 65.45,89.38 65.91,89.84 66.03,89.84 66.16,89.72 66.16,89.59 65.7,89.13 65.7,89.01 65.82,88.88 65.95,88.88 66.38,89.32 66.54,89.32 66.66,89.19 66.66,89.09 66.2,88.63 66.2,88.5 66.33,88.38 66.45,88.38 66.89,88.81 67.01,88.81 67.14,88.69 67.14,88.56 66.7,88.13 66.7,88 66.88,87.83 67.31,87.83 70.84,84.3 79.93,84.3 81.09,83.14 81.09,81.49 81.9,80.68 81.9,80.17 82.1,79.97 82.82,79.97 83.17,79.62 83.17,78.94 v2(83.8,78.31)
  BOTTOM w0.076: U2030.AH69 83.07,75.19 83.07,75.36 83.18,75.6 83.18,75.72 83.11,75.89 83.11,76.1 83.16,76.22 83.16,76.92 83.25,77 83.25,77.5 83.37,77.62 83.37,77.87 v2(83.8,78.31)
M_B_DQ16: length 52.7
  TOP w0.102: v2(41.66,75.74) 41.36,75.74 40.12,74.5 U2010.J7
  IN3 w0.089: v2(41.66,75.74) 41.66,75.88 41.02,76.53 41.02,78.64 44.36,81.98 44.49,81.98 44.62,81.85 44.72,81.85 44.84,81.98 44.84,82.1 44.64,82.31 44.64,82.43 44.78,82.57 44.93,82.57 45.22,82.28 45.4,82.28 45.5,82.38 45.5,82.51 45.17,82.84 45.17,82.97 45.24,83.03 50.89,83.03 51.56,83.7 53.06,83.7 53.62,83.15 60.72,83.15 61.61,82.25 65.2,82.25 66.14,81.32 66.86,81.32 68.31,79.87 73.13,79.87 75.25,77.75 75.25,76.25 75.95,75.54 76.81,75.54 v2(78.82,73.53)
  BOTTOM w0.114: U2030.AT66 v2(78.82,73.53)
M_B_DQ17: length 52.3
  TOP w0.102: v2(41.68,76.52) 41.68,76.52 41.05,76.52 U2010.J3
  IN3 w0.089: v2(41.68,76.52) 41.26,76.94 41.26,78.36 44.32,81.42 45.15,81.42 46.46,82.73 54.36,82.73 54.45,82.64 54.45,82.27 54.54,82.18 54.71,82.18 54.8,82.27 54.8,82.64 54.89,82.73 57.63,82.73 57.72,82.64 57.72,82.17 57.81,82.09 57.98,82.09 58.07,82.17 58.07,82.64 58.16,82.73 58.34,82.73 58.43,82.64 58.43,82.17 58.52,82.09 58.7,82.09 58.78,82.17 58.78,82.64 58.87,82.73 60.67,82.73 61.39,82.01 65.1,82.01 66.04,81.08 66.76,81.08 68.21,79.63 72.89,79.63 74.93,77.58 74.93,76.02 75.24,75.71 75.4,75.55 75.4,74.98 75.82,74.56 76,74.56 76.11,74.68 76.24,74.68 76.36,74.55 76.36,74.42 76.25,74.31 76.25,74.13 76.36,74.02 77.75,74.02 v2(78.19,73.59)
  BOTTOM w0.114: U2030.AU66 v2(78.19,73.59)
M_B_DQ18: length 55.5
  TOP w0.102: v2(41.88,74.87) 41.35,74.87 41.09,74.61 41.09,74.11 U2010.H8
  IN3 w0.089: v2(79.46,72.66) 79.1,72.3 78.42,72.3 78.15,72.02 76.33,72.02 75.14,73.21 73.91,73.21 73.37,73.76 73.37,74.74 72.42,75.69 72.42,76.44 71.82,77.04 71.05,77.04 70.98,77.12 70.98,77.51 70.9,77.58 70.79,77.58 70.71,77.51 70.71,77.12 70.63,77.04 70.52,77.04 70.44,77.12 70.44,77.25 70.36,77.33 70.25,77.33 70.18,77.25 70.18,77.12 70.1,77.04 69.99,77.04 69.91,77.12 69.91,77.25 69.83,77.33 69.72,77.33 69.64,77.25 69.64,77.12 69.56,77.04 69.45,77.04 69.38,77.12 69.38,77.25 69.3,77.33 69.19,77.33 69.11,77.25 69.11,77.12 69.03,77.04 68.31,77.04 66.1,79.25 55.44,79.25 55.35,79.34 55.35,79.58 55.26,79.67 55.08,79.67 55,79.58 55,79.34 54.91,79.25 54.66,79.25 54.59,79.32 54.59,79.64 54.51,79.72 54.4,79.72 54.32,79.64 54.32,79.32 54.24,79.25 54.13,79.25 54.05,79.32 54.05,79.64 53.98,79.72 53.86,79.72 53.79,79.64 53.79,79.32 53.71,79.25 53.6,79.25 53.52,79.32 53.52,79.64 53.44,79.72 53.33,79.72 53.25,79.64 53.25,79.32 53.17,79.25 52.86,79.25 52.78,79.32 52.78,79.49 52.7,79.57 52.59,79.57 52.52,79.49 52.52,79.32 52.44,79.25 52.33,79.25 52.25,79.32 52.25,79.49 52.17,79.57 52.06,79.57 51.98,79.49 51.98,79.32 51.9,79.25 51.66,79.25 51.18,79.73 51.18,80.1 51.1,80.18 50.99,80.18 50.91,80.1 50.91,79.6 50.84,79.52 50.73,79.52 50.65,79.6 50.65,80.1 50.57,80.18 50.46,80.18 50.38,80.1 50.38,79.6 50.3,79.52 50.19,79.52 50.11,79.6 50.11,79.95 50.04,80.03 49.93,80.03 49.85,79.95 49.85,79.6 49.77,79.52 49.32,79.52 47.27,77.48 46.57,77.48 46.23,77.14 44.22,77.14 42.38,75.3 42.31,75.3 v2(41.88,74.87)
  BOTTOM w0.114: v2(79.46,72.66) 79.51,72.6 U2030.AP65
M_B_DQ19: length 56.1
  TOP w0.102: U2010.F7 42.65,74.88 v2(42.69,74.88)
  IN3 w0.089: v2(42.69,74.88) 42.69,75.26 42.86,75.43 42.96,75.43 43.16,75.23 43.26,75.23 43.36,75.33 43.36,75.43 43.19,75.61 43.19,75.76 43.26,75.83 43.41,75.83 44.16,75.08 44.16,74.79 44.34,74.61 44.75,74.61 44.83,74.69 44.83,74.78 43.6,76.01 43.6,76.13 43.68,76.2 43.79,76.2 45,74.99 45.14,74.99 45.22,75.07 45.22,75.16 43.95,76.42 43.95,76.53 44.04,76.62 44.18,76.62 44.48,76.32 44.59,76.32 44.67,76.4 44.67,76.51 44.54,76.64 44.54,76.78 44.63,76.87 44.74,76.87 44.94,76.67 46.15,76.67 46.72,77.24 47.37,77.24 48.93,78.79 49.39,78.79 49.5,78.9 49.5,79.2 49.57,79.28 49.68,79.28 49.76,79.2 49.76,79.08 49.84,79.01 49.95,79.01 50.03,79.08 50.03,79.2 50.11,79.28 50.22,79.28 50.3,79.2 50.3,79.08 50.37,79.01 50.48,79.01 50.56,79.08 50.56,79.2 50.64,79.28 50.75,79.28 50.83,79.2 50.83,79.08 50.91,79.01 51.02,79.01 51.1,79.08 51.1,79.2 51.17,79.28 51.28,79.28 51.36,79.2 51.36,79.08 51.44,79.01 66,79.01 68.2,76.81 71.69,76.81 72.17,76.33 72.17,75.58 73.19,74.56 73.19,73.63 73.82,73 75,73 76.15,71.84 78.22,71.84 78.5,72.12 80.36,72.12 80.43,72.19 80.43,72.34 v2(80.11,72.66)
  BOTTOM w0.114: v2(80.11,72.66) 80.16,72.6 U2030.AN65
M_B_DQ20: length 55.2
  TOP w0.102: v2(41.6,80.82) 41.02,80.24 41.02,79.16 40.67,78.81 U2010.H2
  IN3 w0.089: v2(80.75,73.59) 80.28,74.06 80.28,74.67 79.9,75.05 78.33,75.05 77.23,76.15 76.24,76.15 75.84,76.55 75.84,78 73.36,80.48 68.38,80.48 66.1,82.76 65.11,82.76 65.02,82.85 65.02,83.3 64.93,83.39 64.75,83.39 64.67,83.3 64.67,82.85 64.58,82.76 64.4,82.76 64.31,82.85 64.31,83.3 64.22,83.39 64.04,83.39 63.95,83.3 63.95,82.92 63.87,82.83 63.69,82.83 63.6,82.92 63.6,83.3 63.51,83.39 63.33,83.39 63.24,83.3 63.24,82.92 63.15,82.83 62.98,82.83 62.89,82.92 62.89,83.3 62.8,83.39 62.62,83.39 62.53,83.3 62.53,82.92 62.44,82.83 62.27,82.83 62.18,82.92 62.18,83.3 62.11,83.37 61.43,83.37 61.02,83.78 53.67,83.78 53.26,84.19 50.59,84.19 49.91,83.52 46.28,83.52 46.19,83.6 46.19,84 46.1,84.09 45.92,84.09 45.83,84 45.83,83.6 45.75,83.52 45.5,83.52 45.42,83.6 45.42,83.92 45.33,84.01 45.15,84.01 45.06,83.92 45.06,83.6 44.97,83.52 44.29,83.52 v2(41.6,80.82)
  BOTTOM w0.114: U2030.AN66 v2(80.75,73.59)
M_B_DQ21: length 54.6
  TOP w0.102: v2(42.28,80.78) 42.28,79.89 41.89,79.5 41.89,78.92 U2010.G2
  IN3 w0.089: v2(80.14,73.53) 79.75,73.92 78.95,73.92 78.82,74.06 78.82,74.18 79.03,74.4 79.03,74.55 78.91,74.67 78.81,74.67 78.57,74.43 78.44,74.43 77.02,75.85 76.11,75.85 75.47,76.49 75.47,77.93 73.3,80.11 68.41,80.11 66.74,81.77 66.57,81.77 66.36,81.56 66.24,81.56 66.07,81.73 66.07,81.86 66.3,82.09 66.3,82.21 66.18,82.34 66.05,82.34 65.82,82.11 65.69,82.11 65.3,82.49 61.8,82.49 60.84,83.45 53.66,83.45 53.16,83.95 50.79,83.95 50.68,83.84 50.68,83.76 50.91,83.53 50.91,83.4 50.79,83.27 50.68,83.27 50.4,83.56 50.3,83.56 50.01,83.27 45.14,83.27 44.88,83.02 44.79,83.02 44.54,83.27 44.39,83.27 44.24,83.13 44.24,83 44.48,82.76 44.48,82.62 44.36,82.49 44.25,82.49 43.99,82.75 43.86,82.75 43.74,82.62 43.74,82.5 44.07,82.17 44.07,82.03 43.94,81.9 43.83,81.9 43.49,82.25 43.37,82.25 43.25,82.13 43.25,82 43.58,81.66 43.58,81.54 43.49,81.45 43.36,81.45 43.04,81.77 42.94,81.77 42.8,81.63 42.8,81.52 43.13,81.19 43.13,81.09 43.03,80.99 42.89,80.99 42.57,81.3 42.47,81.3 42.28,81.12 v2(42.28,80.78)
  BOTTOM w0.114: U2030.AP66 v2(80.14,73.53)
M_B_DQ22: length 54.7
  TOP w0.102: U2010.H7 40.67,74.58 41.38,75.29 41.84,75.29 v2(42.3,75.75)
  IN3 w0.089: v2(42.3,75.75) 43.94,77.38 46.04,77.38 46.38,77.72 47.17,77.72 50.03,80.57 53.17,80.57 53.25,80.5 53.25,80.05 53.33,79.97 53.44,79.97 53.52,80.05 53.52,80.5 53.6,80.57 53.71,80.57 53.79,80.5 53.79,80.05 53.86,79.97 53.98,79.97 54.05,80.05 54.05,80.5 54.13,80.57 54.24,80.57 54.32,80.5 54.32,80.05 54.4,79.97 54.51,79.97 54.59,80.05 54.59,80.5 54.66,80.57 57.54,80.57 57.61,80.5 57.61,79.59 57.69,79.51 57.8,79.51 57.88,79.59 57.88,80.5 57.96,80.57 58.1,80.57 58.18,80.5 58.18,79.56 58.25,79.49 58.41,79.49 58.48,79.56 58.48,80.38 58.55,80.45 58.68,80.45 58.77,80.36 58.77,79.61 58.89,79.49 66.25,79.49 67.64,78.09 69.71,78.09 69.94,78.32 71.11,78.32 71.2,78.23 71.2,78.07 71.29,77.98 71.46,77.98 71.55,78.07 71.55,78.23 71.64,78.32 72.09,78.32 72.84,77.57 72.84,76.9 72.96,76.79 73.11,76.79 73.19,76.71 73.19,76.56 73.09,76.46 72.76,76.46 72.66,76.36 72.66,75.8 73.57,74.89 73.57,73.86 74,73.43 75.44,73.43 76.49,72.38 76.91,72.38 77.09,72.2 77.71,72.2 v2(78.16,72.64)
  BOTTOM w0.114: v2(78.16,72.64) 78.5,72.18 U2030.AT65
M_B_DQ23: length 53.4
  TOP w0.102: U2010.H3 40.84,77.7 41.61,76.93 41.92,76.93 v2(42.32,76.54)
  IN3 w0.089: v2(42.32,76.54) 42.63,76.54 43.79,77.7 44.93,77.7 45.76,78.52 46.29,78.52 46.34,78.57 47.68,78.57 49.93,80.82 58.96,80.82 59.09,80.68 59.09,79.87 59.23,79.73 62.25,79.73 62.34,79.82 62.34,80.73 62.43,80.82 62.6,80.82 62.69,80.73 62.69,79.82 62.78,79.73 62.96,79.73 63.05,79.82 63.05,80.73 63.14,80.82 63.31,80.82 63.4,80.73 63.4,79.82 63.49,79.73 63.67,79.73 63.76,79.82 63.76,80.73 63.85,80.82 64.03,80.82 64.11,80.73 64.11,79.82 64.2,79.73 64.38,79.73 64.47,79.82 64.47,80.6 64.56,80.69 64.74,80.69 64.83,80.6 64.83,79.82 64.91,79.73 66.35,79.73 67.74,78.33 69.48,78.33 69.71,78.56 72.33,78.56 73.2,77.69 73.37,77.69 73.64,77.42 73.64,77 73.49,76.85 73.49,76.19 74.36,75.33 74.36,75.12 74.28,75.04 74.15,75.04 74.05,74.94 74.05,74.78 74.14,74.69 74.33,74.69 74.46,74.56 74.46,73.96 74.76,73.66 75.52,73.66 76.5,72.67 77.42,72.67 v2(77.51,72.58)
  BOTTOM w0.114: v2(77.51,72.58) U2030.AU65
M_B_DQ24: length 55.3
  TOP w0.102: v2(45.63,76.07) 44.67,77.03 U2010.C3
  IN3 w0.089: v2(45.63,76.07) 46.06,75.64 47.06,75.64 47.2,75.78 48.45,75.78 48.58,75.91 48.58,76.34 48.68,76.44 48.8,76.44 48.88,76.36 48.88,75.86 48.96,75.78 49.08,75.78 49.19,75.88 49.19,77.15 49.26,77.22 49.39,77.22 49.49,77.12 49.49,76.29 49.59,76.19 49.68,76.19 49.82,76.33 49.82,77.61 49.89,77.68 50.03,77.68 50.13,77.58 50.13,76.91 50.21,76.82 50.31,76.82 50.42,76.93 50.42,77.46 50.64,77.68 59.48,77.68 59.49,77.69 61.68,77.69 61.75,77.61 61.75,76.76 61.83,76.68 61.94,76.68 62.02,76.76 62.02,77.61 62.1,77.69 62.21,77.69 62.29,77.61 62.29,76.72 62.37,76.64 62.48,76.64 62.55,76.72 62.55,77.61 62.63,77.69 62.74,77.69 62.82,77.61 62.82,76.72 62.9,76.64 63.01,76.64 63.09,76.72 63.09,77.61 63.17,77.69 63.28,77.69 63.35,77.61 63.35,76.72 63.43,76.64 63.54,76.64 63.62,76.72 63.62,77.61 63.7,77.69 63.81,77.69 63.89,77.61 63.89,76.72 63.97,76.64 64.11,76.64 64.18,76.72 64.18,77.61 64.26,77.68 64.37,77.68 64.45,77.61 64.45,76.72 64.53,76.64 66.98,76.64 67.71,75.92 67.71,75.92 67.78,75.84 67.78,75.18 68,74.96 71.58,74.96 71.83,74.71 71.83,74.06 73.54,72.35 74.58,72.35 75.62,71.31 78.03,71.31 78.2,71.14 v2(78.2,70.86)
  BOTTOM w0.114: v2(78.2,70.86) 78.2,70.85 78.51,70.36 U2030.AT61
M_B_DQ25: length 54.6
  TOP w0.102: U2010.D3 43.87,77.24 v2(45.04,76.07)
  IN3 w0.089: v2(45.04,76.07) 45.79,75.32 47.09,75.32 47.23,75.46 49.29,75.46 50.66,76.83 50.66,77.36 50.74,77.44 50.91,77.44 50.98,77.36 50.98,76.74 51.06,76.66 51.17,76.66 51.25,76.74 51.25,77.36 51.33,77.44 51.44,77.44 51.52,77.36 51.52,77.07 51.6,76.99 51.71,76.99 51.78,77.07 51.78,77.36 51.86,77.44 51.97,77.44 52.05,77.36 52.05,77.02 52.13,76.94 52.24,76.94 52.32,77.02 52.32,77.36 52.4,77.44 52.51,77.44 52.58,77.36 52.58,76.96 52.66,76.88 52.77,76.88 52.85,76.96 52.85,77.36 52.93,77.44 53.04,77.44 53.12,77.36 53.12,76.91 53.2,76.83 53.31,76.83 53.38,76.91 53.38,77.36 53.46,77.44 53.57,77.44 53.65,77.36 53.65,76.74 53.73,76.66 53.84,76.66 53.92,76.74 53.92,77.36 54,77.44 54.11,77.44 54.19,77.36 54.19,76.64 54.26,76.56 54.37,76.56 54.45,76.64 54.45,77.36 54.53,77.44 54.64,77.44 54.72,77.36 54.72,76.96 54.8,76.89 54.91,76.89 54.99,76.96 54.99,77.36 55.06,77.44 55.17,77.44 55.25,77.36 55.25,77.19 55.33,77.12 55.44,77.12 55.52,77.19 55.52,77.36 55.6,77.44 55.71,77.44 55.79,77.36 55.79,77.17 55.87,77.09 55.98,77.09 56.05,77.16 56.05,77.36 56.13,77.44 56.24,77.44 56.32,77.36 56.32,77.19 56.4,77.12 56.51,77.12 56.59,77.19 56.59,77.36 56.66,77.44 56.77,77.44 56.85,77.36 56.85,77.17 56.93,77.09 57.04,77.09 57.12,77.17 57.12,77.36 57.2,77.44 57.31,77.44 57.39,77.36 57.39,77.19 57.46,77.12 57.57,77.12 57.65,77.19 57.65,77.36 57.73,77.44 57.84,77.44 57.92,77.36 57.92,77.19 58,77.11 58.11,77.11 58.19,77.19 58.19,77.36 58.26,77.44 58.37,77.44 58.45,77.36 58.45,77.08 58.53,77 58.64,77 58.72,77.08 58.72,77.36 58.8,77.44 58.91,77.44 58.99,77.36 58.99,76.68 59.06,76.61 59.17,76.61 59.25,76.68 59.25,77.36 59.33,77.44 59.44,77.44 59.54,77.34 59.54,76.88 59.65,76.77 61.4,76.77 61.77,76.4 66.88,76.4 67.54,75.74 67.54,75.08 67.92,74.7 71.42,74.7 71.65,74.47 71.65,73.94 73.45,72.13 74.45,72.13 75.87,70.71 75.97,70.71 76.07,70.8 76.07,71.07 76.13,71.13 77.24,71.13 v2(77.52,70.85)
  BOTTOM w0.114: v2(77.52,70.85) 77.86,70.36 U2030.AU61
M_B_DQ26: length 57.8
  TOP w0.102: v2(44.3,74.1) 44.67,74.48 U2010.C7
  IN3 w0.089: v2(44.3,74.1) 44.54,74.1 44.64,74 44.64,73.04 44.94,72.73 45.06,72.73 45.4,73.07 49.92,73.07 50.56,73.71 57.19,73.71 57.84,73.06 58.55,73.06 59.19,72.41 63.2,72.41 63.29,72.5 63.29,73.58 63.37,73.66 63.49,73.66 63.58,73.58 63.58,72.5 63.66,72.41 63.78,72.41 63.87,72.5 63.87,73.58 63.96,73.66 64.08,73.66 64.16,73.58 64.16,72.5 64.25,72.41 64.37,72.41 64.45,72.5 64.45,73.58 64.54,73.66 64.66,73.66 64.75,73.58 64.75,72.5 64.83,72.41 64.95,72.41 65.04,72.5 65.04,73.58 65.12,73.66 65.24,73.66 65.33,73.58 65.33,72.5 65.42,72.41 65.54,72.41 65.62,72.5 65.62,73.58 65.71,73.66 65.83,73.66 65.91,73.58 65.91,72.5 66,72.41 66.12,72.41 66.21,72.5 66.21,73.58 66.29,73.66 66.41,73.66 66.5,73.58 66.5,72.5 66.58,72.41 66.71,72.41 66.79,72.49 66.79,73.01 66.86,73.09 67.04,73.09 67.14,72.99 67.14,72.17 67.3,72.02 67.46,72.02 67.55,72.11 67.55,72.49 67.68,72.62 71.2,72.62 72.38,71.45 72.38,71.33 72.3,71.26 71.55,71.26 71.46,71.17 71.46,71.02 71.55,70.93 72.89,70.93 73.56,70.26 74.24,70.26 75.29,69.22 78.09,69.22 78.39,69.52 79.12,69.52 v2(79.48,69.88)
  BOTTOM w0.114: U2030.AP60 79.68,69.62 v2(79.48,69.88)
