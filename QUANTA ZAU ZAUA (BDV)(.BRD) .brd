# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_CLK_L_C: length 12.7
  TOP w0.102: L12.1 52.88,109.86 C548.1 52.43,110.07 v1(52.44,110.08)
  BOTTOM w0.102: v1(52.44,110.08) 51.96,110.55 50.38,110.55 49.62,109.79 45.99,109.79 43.85,107.65 CN29.1
DMIC_DAT: length 4.8
  BOTTOM w0.102: R459.1 208.17,26.96 207.4,26.96 206.94,27.42 206.51,27.42 206.28,27.65 206.28,28.86 206.46,29.04 U20.2
DMIC_DAT_2: length 175
  IN1 w0.089: v1(60.59,112.38) 59.63,113.34 51.24,113.34 v1(51.04,113.13)
  IN3 w0.089: v1(51.04,113.13) 51.04,113.47 49.96,114.55 48.77,114.55 47.93,115.4 42.33,115.4 41.37,116.36 39.21,116.36 v1(36.45,113.61) ; v1(60.59,112.38) 60.59,112.03 61,111.62 61.99,111.62 62.27,111.9 66.48,111.9 67.1,111.29 69.63,111.29 70.24,110.67 70.89,110.67 71.12,110.44 71.12,109.62 71.56,109.19 73.12,109.19 74.62,107.69 75.8,106.51 77.03,106.51 80.83,102.71 82.27,102.71 82.68,102.3 87.85,102.3 88.96,103.41 89.87,103.41 93.3,99.99 93.3,96.86 94.77,95.39 94.77,93.33 96.43,91.67 97.51,91.67 100.32,88.87 102.75,88.87 102.87,88.74 102.87,87.8 102.99,87.69 102.99,85.76 103.39,85.35 103.39,80.52 103.59,80.33 103.59,77.05 104.23,76.4 104.23,74.17 105.01,73.39 105.01,70.57 106.48,69.11 106.8,69.11 109.24,66.67 109.24,62.94 110.62,61.57 111.69,61.57 112.71,60.55 112.71,54.93 111.99,54.21 110.17,54.21 110.08,54.3 110.08,54.92 110.01,54.98 109.8,54.98 109.68,54.87 109.68,54.3 109.59,54.21 109.02,54.21 108.93,54.11 108.93,53.88 109.03,53.78 110.53,53.78 110.62,53.69 110.62,53.54 110.43,53.35 108.98,53.35 108.91,53.28 108.91,52.32 109,52.23 110.43,52.23 110.52,52.14 110.52,51.92 110.43,51.83 109,51.83 108.91,51.74 108.91,51.53 109,51.44 110.43,51.44 110.52,51.35 110.52,51.13 110.43,51.04 109.61,51.04 109.54,50.98 109.54,50.76 109.66,50.65 110.43,50.65 110.52,50.56 110.52,49.79 111.37,48.94 111.37,46.01 112.45,44.93 112.45,44.08 112.1,43.73 111.63,43.73 111.54,43.64 111.54,43.43 111.63,43.34 112.1,43.34 112.19,43.25 112.19,43.03 112.1,42.94 111.63,42.94 111.54,42.85 111.54,42.64 111.63,42.55 112.1,42.55 112.19,42.46 112.19,41.42 111.56,40.79 110.18,40.79 109.24,39.85 109.24,31.97 v1(107.05,29.78)
  BOTTOM w0.102: R25497.1 104.79,28.89 105.19,28.48 106.23,28.48 106.77,29.02 106.77,29.5 v1(107.05,29.78) ; v1(36.45,113.61) 34.7,115.36 CN38.2
DMIC_DAT_2_R: length 25.6
  TOP w0.079: v1(98.06,35.77) 97.75,36.08 94.3,36.08 92.95,37.43 92.95,38.11 94.17,39.33 v1(94.17,40.14) 94.3,40.27 94.58,40.27 94.68,40.17 94.68,39.91 v4(94.88,39.7)
  BOTTOM w0.102: R25497.2 104.23,30.57 103.65,30.57 103.53,30.7 103.35,30.7 103.16,30.89 103.16,31.41 102.79,31.78 102.79,32.02 102.69,32.12 102.49,32.12 102.38,32.02 102.38,31.78 102.28,31.68 102.08,31.68 101.98,31.78 101.98,32.02 101.88,32.12 101.67,32.12 101.57,32.02 101.57,31.78 101.47,31.68 100.37,31.68 100.19,31.85 100.19,32.21 99.96,32.43 99.96,32.81 99.6,33.17 99.6,33.81 98.99,34.43 98.82,34.43 98.65,34.26 98.5,34.26 98.36,34.4 98.36,34.55 98.56,34.75 98.56,34.85 98.4,35.01 98.23,35.01 98.08,34.86 97.93,34.86 97.52,35.27 97.52,35.95 97.72,36.16 97.85,36.16 98.06,35.95 v1(98.06,35.77) ; v4(94.88,39.7) 95.05,39.88 95.32,39.88 95.42,39.78 U2030.D7
DMIC_DAT_L: length 257.4
  TOP w0.102: v1(50.36,112.08) 50.36,111.93 50.77,111.53 L13.2
  IN3 w0.089: v2(205.51,26.29) 205.32,26.48 204.23,26.48 204.11,26.36 203.4,26.36 203.15,26.61 202.17,26.61 201.86,26.91 198.86,26.91 197.13,28.64 197.13,30.02 196.64,30.51 196.64,31.33 195.52,32.44 195.15,32.44 194.94,32.66 194.94,32.92 194.53,33.32 193.07,33.32 192.84,33.09 192.42,33.09 192.03,33.48 191.4,33.48 189.99,32.06 189.99,31.93 188.92,30.86 187.8,30.86 186.96,31.71 185.25,31.71 185.05,31.51 183.32,31.51 183.07,31.25 181.19,31.25 180.61,31.84 177.91,31.84 176.15,30.07 169.63,30.07 169.35,29.79 166.85,29.79 164.26,32.38 163.41,32.38 163.04,32.75 159.9,32.75 159.41,32.26 157.52,32.26 156.53,33.25 156.53,34.17 155.7,34.99 148.46,34.99 148.16,34.7 146.25,34.7 145.93,34.38 145.93,33.87 145.35,33.29 143.12,33.29 141.4,31.57 139.96,31.57 138.52,30.13 138.52,29.77 138.09,29.34 137.28,29.34 136.5,30.12 136.5,31.21 135.88,31.82 134.51,31.82 132.62,33.71 131.76,33.71 131.45,33.4 128.36,33.4 126.05,35.71 124.52,35.71 122.64,37.59 122.64,38.05 121.32,39.37 121.32,43.12 121.4,43.2 121.4,44.78 120.2,45.98 120.2,48.19 119.36,49.03 116.39,51.99 116.39,54.96 117.04,55.61 117.04,56.31 116.45,56.9 116.13,56.9 114.9,58.12 114.9,61.55 114.53,61.92 114.53,68.06 113.07,69.52 113.07,74.98 112.67,75.38 107.3,75.38 106.32,76.35 106.32,80.19 105.74,80.77 105.74,84.6 107.27,86.14 107.27,89.22 107,89.5 107,90.06 106.04,91.02 106.04,91.61 105.92,91.73 105.92,92.88 104.94,93.86 104.43,93.86 104.2,94.09 104.2,97.65 103.91,97.94 99.54,97.94 98.18,99.3 98.18,100.34 96.15,102.37 96.15,113.23 94.53,114.86 94.53,115.17 92.31,117.39 90.01,117.39 84.54,122.86 77.5,122.86 77.4,122.96 68.81,122.96 66.61,120.76 66.61,117.08 65.54,116.01 61.46,116.01 58.76,113.31 53.04,113.31 52.35,112.62 52.35,112.31 51.82,111.78 50.66,111.78 v1(50.36,112.08)
  BOTTOM w0.102: v2(205.51,26.29) 205.51,26.16 206.41,25.26 208.25,25.26 R459.2
DMIC_DAT_L_C: length 11
  TOP w0.102: L13.1 50.95,110.75 50.53,110.33 50.53,109.79 50.88,109.44 C547.1 v1(51.14,110.09)
  BOTTOM w0.102: CN29.2 44.35,107.57 46.16,109.38 49.79,109.38 50.49,110.09 v1(51.14,110.09)
DNBSWON#: length 171
  TOP w0.102: U37.123 186.85,28.19 188.31,26.72 188.31,26.11 188.89,25.54 188.89,24.59 190.05,23.42 190.62,23.42 v2(192.3,21.75)
  IN1 w0.089: v2(192.3,21.75) 193.41,20.64 193.82,20.64 194.46,19.99 194.46,19.43 196.78,17.11 197.41,17.11 197.9,16.62 197.9,15.28 197.31,14.69 191.09,14.69 190.08,15.7 187.39,15.7 186.39,16.71 186.39,17.53 186.15,17.78 183.72,17.78 183.32,18.18 181.18,18.18 180.48,18.88 177.34,18.88 177.16,19.06 175.5,19.06 174.98,18.54 166.34,18.54 165.96,18.92 142.55,18.92 141.9,19.58 138.89,19.58 137.8,18.48 131.77,18.48 131.44,18.8 123.63,18.8 123.24,19.2 120.08,19.2 119.82,19.46 110.44,19.46 110.01,19.89 102.42,19.89 101.91,20.4 101.25,20.4 100.73,19.89 99.35,19.89 98.85,20.39 98.38,20.86 96.77,20.86 95.58,22.05 93.76,22.05 93.08,22.73 93.08,23.15 91.25,24.98 82.31,24.98 80.91,23.58 77.46,23.58 76.92,24.12 71.11,24.12 68.77,26.45 68.77,29.5 67.78,30.49 66.51,30.49 v1(65.21,31.79)
  BOTTOM w0.102: v1(65.21,31.79) 65.16,31.84 65.16,33.06 65.39,33.29 65.39,34.1 65.19,34.3 R2523.2
DP_UTIL: length 11.3
  BOTTOM w0.102: R2489.1 105.82,64.02 105.37,64.47 R2488.1 105.37,64.69 104.22,65.85 101.56,65.85 101.05,65.34 101.05,65.14 100.39,64.48 98.59,64.48 98.11,64.96 97.67,64.96 97.46,64.75 97.09,64.75 U2030.B52
DPWROK_R: length 9.5
  BOTTOM w0.102: R2503.1 67.89,44.03 v1(69.23,45.37) 69.53,45.67 72.78,45.67 73.65,46.54 74.63,46.54 U2030.BB20
DRVEN_SET: length 3.3
  BOTTOM w0.203: PR7104.2 133.78,52.23 PR7103.1 133.95,53.17 135.05,54.27 PU7000.18
EC_FPBACK#: length 212.9
  TOP w0.102: U37.86 198.06,24.18 197.25,23.38 196.76,23.38 196.48,23.66 v2(196.48,24.29) ; v1(61.56,110.63) 62.02,111.1 Q6522.2
  IN2 w0.089: v1(61.56,110.63) 61.89,110.96 64.77,110.96 71.29,104.43 73.53,104.43 76.21,101.75 77,101.75 78.54,100.22 81.71,100.22 81.9,100.03 85,100.03 85.33,99.7 85.33,99.25 85.58,99 86.05,99 86.41,99.35 87.42,99.35 88.08,100.01 88.08,100.75 88.45,101.12 90.26,101.12 91,100.38 91,92.3 92.25,91.05 93.8,91.05 96.1,88.76 96.75,88.76 98.84,86.66 98.84,85.67 99.15,85.37 99.72,85.37 103.27,81.82 103.27,79.2 103.19,79.13 103.19,77.19 103.57,76.82 103.57,71.07 104.48,70.16 104.48,69.03 104.86,68.65 105.12,68.65 106.29,67.48 106.87,67.48 107,67.62 112.89,67.62 114.19,66.31 114.19,62.45 113.83,62.09 113.83,54.64 115.86,52.61 115.86,51.13 117.34,49.66 121.43,49.66 122.52,48.56 122.52,42.5 125.34,39.68 125.34,38.44 124.67,37.77 124.67,36.22 127.83,33.06 130.39,33.06 133.05,30.39 133.05,28.63 134.59,27.09 135.82,27.09 136.49,26.43 137.72,26.43 139.16,27.87 140.5,27.87 140.65,27.72 141.08,27.72 141.29,27.93 142.83,27.93 143.32,28.42 144.24,28.42 146.56,30.74 154.22,30.74 155.6,32.12 164.57,32.12 165.25,31.44 168.03,31.44 168.7,30.76 172.23,30.76 172.84,30.15 177.05,30.15 177.76,30.87 180.54,30.87 180.68,31.01 181.24,31.01 181.25,31.01 183.19,31.01 184.29,29.91 190.68,29.91 192.38,28.21 192.38,26.69 193.82,25.26 195.08,25.26 195.34,25.51 195.79,25.51 196.14,25.17 196.14,24.64 v2(196.48,24.29)
EC_ODD_EJ#: length 87.2
  TOP w0.102: v2(201.18,24.73) 201.41,24.95 R25328.1 ; R638.1 128.84,16.09 128.08,16.09 v1(127.39,16.78)
  IN3 w0.089: v2(201.18,24.73) 198.52,24.73 197.2,23.41 196.94,23.41 195.25,21.72 192.88,21.72 192.44,22.16 188.53,22.16 187.79,22.9 184.43,22.9 182.18,20.65 182.18,19.32 181.6,18.74 179.75,18.74 179.17,19.32 173.39,19.32 172.98,18.91 164.68,18.91 164.23,18.46 164.23,17.87 163.72,17.37 151.21,17.37 150.6,17.98 139.28,17.98 138.67,17.37 128.15,17.37 127.55,16.78 v1(127.39,16.78)
  BOTTOM w0.102: v1(127.39,16.78) 127.39,16.45 127.85,15.99 129.02,15.99 129.35,16.32 CN15.16
EC_ODD_EJ_R#: length 3.8
  TOP w0.102: U37.94 199.85,27.38 200.01,27.54 200.79,27.54 C2607.1 201.21,26.14 R25328.2
EC_PECI: length 109.6
  TOP w0.102: v1(176.69,32.21) 177.2,32.71 178.4,32.71 R380.2
  IN1 w0.089: v1(158.72,34.33) 158.45,34.6 157.33,34.6 155.83,33.1 148.46,33.1 147.01,34.56 146.73,34.56 145.72,35.57 144.68,35.57 143.26,36.98 143.26,40.77 142.87,41.16 142.87,43.15 142.13,43.89 141.4,43.89 140.54,43.03 139.22,43.03 138.76,43.49 137.25,43.49 136.86,43.1 134.51,43.1 134.34,43.28 124.32,43.28 124.08,43.52 120.73,43.52 119.64,44.6 117.17,44.6 116.52,45.25 113.49,45.25 108.89,49.85 108.18,49.85 107.04,50.99 106.13,50.99 104.53,52.59 102.02,52.59 99.96,54.65 99.96,58.2 101.76,60.01 101.76,62.34 v1(99.02,65.09)
  IN3 w0.089: v1(158.72,34.33) 159.86,34.33 159.98,34.21 163.65,34.21 164.02,33.84 165.01,33.84 166.13,32.71 169.5,32.71 170.64,31.57 174.7,31.57 175.35,32.22 176.68,32.22 v1(176.69,32.21)
  BOTTOM w0.102: v1(99.02,65.09) 99.02,65.57 98.12,66.47 97.37,66.47 U2030.A54
EC_PECR_R: length 12.6
  TOP w0.102: R380.1 180.16,32.68 180.83,32.84 181.78,32.84 v1(181.8,32.86) 183.03,33.03 183.85,33.25 184.56,33.46 186.88,33.46 187.59,32.76 187.59,32.36 187.58,32.34 187.48,32.23 187.48,31.67 187.61,31.33 187.97,30.96 188.27,30.85 188.95,30.85 189.25,30.55 U37.117
EC_PWROK: length 170
  TOP w0.102: U37.33 184.85,14.7 184.69,14.85 184,14.85 183.5,15.35 182.56,15.35 181.69,16.22 181.04,16.22 v2(180.77,16.49)
  IN1 w0.089: v1(63.2,31.3) 63.87,31.3 64.5,30.67 65.64,30.67 68.29,28.03 68.29,26.25 71.44,23.1 81.11,23.1 82.52,24.51 91.05,24.51 92.61,22.95 92.61,22.54 93.57,21.58 95.38,21.58 96.6,20.36 v1(96.6,20.34) 98.23,20.34 99.16,19.42 109.82,19.42 110.25,18.99 119.53,18.99 119.79,18.73 123.05,18.73 123.44,18.33 131.25,18.33 131.57,18.01 138,18.01 139.09,19.11 141.7,19.11 142.36,18.45 165.72,18.45 166.15,18.02 v1(166.43,18.02)
  IN3 w0.089: v2(180.77,16.49) 180.64,16.36 171.04,16.36 169.96,17.44 167.02,17.44 v1(166.43,18.02) ; v1(105.01,36.56) 105.01,35.57 105.12,35.47 105.12,34.22 105.32,34.02 105.32,32.91 104.16,31.75 104.16,31.09 103.66,30.58 103.66,29.8 103.29,29.43 103.29,28.46 103.34,28.41 103.34,27.34 101.01,25.01 100.4,25.01 99.79,24.39 97.45,24.39 96.06,23 96.06,20.88 v1(96.6,20.34)
  BOTTOM w0.102: v1(63.2,31.3) 63.2,32.48 62.72,32.96 62.72,39.36 63.83,40.46 64.59,40.46 65.06,40.93 R2512.1 R2510.2 65.06,41.89 65.64,42.48 R2500.1 ; R2511.1 103.67,36.07 104.73,36.07 105.01,36.36 v1(105.01,36.56)
EC_PWROK_R: length 11.2
  BOTTOM w0.102: U2030.BA20 75.19,46.65 74.87,46.33 73.73,46.33 72.81,45.42 69.93,45.42 68.08,43.57 66.71,43.57 R2507.2 R2500.2
EC_RCIN#: length 13.5
  BOTTOM w0.076: U2030.AW13 76.48,43 76.09,43.4 75.64,43.4 75.48,43.45 75.34,43.45 75.12,43.39 74.99,43.39 74.83,43.46 74.34,43.46 74.16,43.29 73.91,43.29
  BOTTOM w0.102: R2521.2 67.32,38.21 67.44,38.34 R2518.1 68.03,39.18 68.03,39.82 71.5,43.29 73.91,43.29
EC_TYPEC_CHG: length 2.2
  BOTTOM w0.102: R6515.2 26.27,12.64 v1(26.27,12.99) 25.92,13.35 25.6,13.35 25.5,13.45 U6503.7
EC_TYPEC_CHG_HI: length 213.2
  TOP w0.102: U37.3 183.99,27.38 185.16,26.21 186.95,26.21 188.4,24.76 188.4,24.39 189.85,22.94 190.42,22.94 192.57,20.79 193.57,20.79 194.22,20.14 194.22,19.49 197.04,16.67 197.43,16.67 197.74,16.36 197.74,14.58 197.53,14.37 197.53,12.51 196.39,11.38 v2(196.39,10.53)
  IN2 w0.089: v1(24.83,11.97) 25.56,11.97 28.3,9.24 38.41,9.24 41.23,12.06 42.51,12.06 46.04,15.58 47.38,15.58 48.27,16.47 63.49,16.47 64.72,15.23 78.37,15.23 84,20.86 88.53,20.86 90.89,18.5 95.24,18.5 95.44,18.71 95.84,18.71 99.37,15.18 99.63,15.18 100.54,14.27 114.7,14.27 115.33,14.9 118.12,14.9 119.26,13.76 180.77,13.76 181.57,12.95 182.36,12.95 184.29,11.02 184.72,11.02 184.91,10.83 185.91,10.83 186.03,10.95 187,10.95 187.23,10.71 187.23,10.34 187.91,9.66 195.56,9.66 196.39,10.5 v2(196.39,10.53)
  BOTTOM w0.102: U6503.8 25,12.15 v1(24.83,11.97) 24.38,11.97 R6516.2
EC_TYPEC_EN: length 4.2
  TOP w0.102: R2356.1 201.69,21.06 201.51,21.24 201.51,21.72 201.3,21.94 201.12,21.94 200.82,22.24 199.92,22.24 199.8,22.11 199.8,21.96 199.62,21.78 U37.80
EC_TYPEC_EN_R: length 207
  TOP w0.102: R25586.2 26.53,14.72 v1(26.88,14.36) ; v2(195.58,10.51) 195.58,10.31 196,9.89 203.62,9.89 204.23,10.5 204.23,11.35 203.23,12.35 203.23,18.98 v1(203.49,19.24) 203.49,19.34 R2356.2
  IN2 w0.089: v1(26.88,14.36) 26.83,14.36 26.78,14.31 26.78,13.44 27.03,13.19 28.08,13.19 28.62,12.65 28.62,10.77 29.96,9.43 38.33,9.43 43.67,14.77 44.07,14.77 46.05,16.75 63.71,16.75 64.95,15.51 78.38,15.51 83.94,21.07 88.61,21.07 90.98,18.69 95.16,18.69 95.36,18.9 95.92,18.9 98.44,16.38 99.93,16.38 101.85,14.46 113.24,14.46 114,15.22 114.44,15.22 114.57,15.1 118.18,15.1 119.33,13.95 180.85,13.95 181.65,13.14 182.44,13.14 183.75,11.84 185.05,11.84 185.52,12.3 186.43,12.3 186.83,11.9 186.83,11.39 187.42,10.79 187.42,10.42 187.99,9.85 194.93,9.85 v2(195.58,10.51)
  BOTTOM w0.102: v1(26.88,14.36) 26.78,14.36 26.78,14.36 U6503.6
ECAGND: length 16.6
  TOP w0.203: L11.1 201.28,19.59 199.9,19.59 199.72,19.78 U37.75
  TOP w0.254: C6564.1 200.91,10.83 v1(201.04,10.7) 201.42,10.32 203.44,10.32 203.8,10.68 203.8,11.17 202.8,12.17 202.8,17.32 202.38,17.74 C6566.2 202.37,17.76 202.37,17.89 201.68,18.58 L11.1
EDP_RCOMP: length 2.5
  TOP w0.508: R2171.1 93.79,63.77 94.11,64.08 v4(94.88,64.4)
  BOTTOM w0.305: v4(94.88,64.4) 94.88,64.64 U2030.E52
EDRAM_OPIO_RCOMP: length 0.5
  BOTTOM w0.127: U2030.H66 92.76,73.82 v4(92.73,73.86)
EMMC_RCOMP: length 7.3
  BOTTOM w0.102: U2030.AT1 78.61,35.91 78.99,35.53 79.21,35.31 79.69,34.83 80.48,34.05 80.97,34.05 81.37,33.65 81.37,31.75 v1(81.1,31.49) 81.37,31.22 81.37,30.56 R2584.2
EN: length 3.8
  TOP w0.102: R1238.2 205.73,16.12 206.22,16.61 206.99,16.61 R1236.1 207.83,17.08 208.04,16.87 U42.7
EN1_CORE: length 2.3
  BOTTOM w0.102: v1(116.55,69.46) 116.96,69.87 PR7107.2
  BOTTOM w0.254: PU7002.1 117.96,70.2 117.7,69.94 117.29,69.94 PR7107.2
EN2_CORE: length 2.4
  BOTTOM w0.102: PR7079.2 134.8,45.38 v1(134.92,45.26)
  BOTTOM w0.203: PU7001.1 133.86,46.5 134.27,46.09 PR7079.2
EN_GT: length 1
  BOTTOM w0.203: PR7111.2 129.55,76.41 PU7003.1
EN_SA: length 1.4
  BOTTOM w0.305: PU7004.1 142.2,40.25 142.63,39.81 PR7115.2
EOPIO_RCOMP: length 1.9
  BOTTOM w0.127: U2030.H65 92.76,72.73 93.1,73.06 93.1,73.48 93.32,73.71 v4(93.32,74.04)
EQ1: length 5.3
  TOP w0.102: U42.17 213.06,15.87 213.38,15.54 v1(213.76,15.54) 214.11,15.54 R497.1 215.28,15.54 215.28,14.3 215.07,14.09 R498.2
EQ2: length 5.9
  TOP w0.102: R495.2 216.22,14.6 216.22,15.62 R1234.1 215.38,16.12 214.96,16.54 214.01,16.54 v1(213.7,16.85) 213.68,16.87 U42.19
FAN1_RPM: length 35.6
  TOP w0.102: v2(187,21.88) 187,21.74 187.4,21.34 187.4,19.79 189.54,17.65 189.54,15.84 190.45,14.93 U37.47 ; R25372.2 178.64,29.82 v2(178.64,30.28)
  BOTTOM w0.102: v2(187,21.88) 187,22.31 187.62,22.92 187.62,24.67 186.98,25.3 186.98,32.04 187.38,32.44 187.38,32.84 187.16,33.06 179.44,33.06 178.64,32.26 v2(178.64,30.28) 178.64,29.72 177.79,28.87 FAN3.2
FAN_PWM: length 34.3
  TOP w0.102: U37.32 182.48,15.78 181.84,16.42 181.38,16.42 180.93,16.87 180.52,16.87 180.39,16.74 180.39,16.41 180.12,16.14 178.12,16.14 177.89,16.37 174.28,16.37 174.08,16.57 174.08,16.98 174.33,17.23 174.38,17.23 174.53,17.39 174.53,19.29 171.28,22.55 171.28,24.05 169.81,25.52 169.81,26.63 170.01,26.83 170.01,28.55 170.75,29.29 170.75,31.28 171.55,32.08 171.55,32.76 171.84,33.06 173.36,33.06 173.6,32.82 v1(174.11,32.82) 175.51,32.82 175.67,32.66 Q6523.1
FAN_PWM_C: length 6.2
  TOP w0.102: v1(175.27,30.97) 175.21,31.03 R25373.2 174.91,30.48 174.91,30.26 v1(175.53,29.64) 176.15,29.64 Q6523.3
  BOTTOM w0.102: v1(175.27,30.97) 175.27,30.31 175.46,30.13 FAN3.3
FB_CAL_PD_VDDQ: length 9.4
  TOP w0.381: R318.2 119.43,93.46 116.55,93.46 116.37,93.64 115.06,93.64 114.72,93.97 114.28,93.97 113.98,93.67 113.5,93.67 112.14,95.03 v2(112.03,95.03)
  BOTTOM w0.381: U8.D22 111.63,95.43 v2(112.03,95.03)
FB_CAL_PU_GND: length 6.9
  TOP w0.102: R319.2 116.66,94.09 116.53,94.22 115.17,94.22 114.93,94.46 113.97,94.46 v2(113.73,94.22)
  BOTTOM w0.102: U8.C24 113.73,94.23 v2(113.73,94.22)
FB_CAL_TERM_GND: length 6.3
  BOTTOM w0.203: 116.77,93.59 116.65,93.59 116,94.24 114.54,94.24 U8.B25
  BOTTOM w0.508: R320.1 119.31,94.09 118.8,93.59 116.77,93.59
FB_CORE: length 8.3
  BOTTOM w0.203: PC7010.2 143.33,46.95 143.06,47.21 ; 143.06,47.21 143.06,47.52 142.84,47.74 PC7011.2 PR7048.1 142.32,49.66 142.21,49.77 141.51,49.77 141.27,50.01 140.46,50.01 140.24,50.24 140.24,50.27 140.15,50.36 PU7000.3 ; 143.06,47.21 PR7047.1 PR7049.2
FB_GT: length 5.9
  BOTTOM w0.203: PR7056.2 133.79,55.14 PC7016.1 PR7054.1 ; PU7000.24 135.02,56.67 134.99,56.7 134.35,56.7 133.98,57.08 PR7054.1 ; PR7055.1 133.79,59.03 PC7017.2 133.79,58.05 PR7054.1
FB_SA: length 11.2
  TOP w0.203: PR7063.1 146.27,51.35 146.62,51.7 v1(146.62,51.93)
  BOTTOM w0.203: PC7020.2 146.62,51.6 v1(146.62,51.93) 146.62,52.28 PR7059.1 ; PR7059.1 145.79,53.1 145.79,54.19 v1(145.61,54.38) 145.34,54.65 145.34,54.79 144.86,55.27 PC7021.2 144.49,55.27 144.21,55.54 PR7060.1 ; PR7059.1 145.77,53.03 143.31,53.03 143.08,53.26 142.66,53.26 142.45,53.47 PU7000.45
FBA_CMD0: length 27.5
  TOP w0.127: v2(119.44,97.4) 119.86,97.81 123.97,97.81 125.45,99.3 v1(128.59,99.3) 131.17,99.3 131.71,98.76 131.71,97.96 135.01,94.66 135.01,93.01 v2(135.41,92.61)
  BOTTOM w0.127: v2(135.41,92.61) 135.01,92.21 VRAM1.G12 ; U8.C27 116.11,94.63 116.33,94.41 117.98,94.41 119.44,95.87 v2(119.44,97.4)
FBA_CMD1: length 32.4
  TOP w0.127: v2(118.81,97.4) 118.81,97.52 119.53,98.25 123.72,98.25 v1(124.65,99.17) 125.22,99.74 131.33,99.74 132.14,98.93 132.14,98.14 135.81,94.47 135.81,91.54 135.67,91.4 135.16,91.4 135.01,91.25 135.01,90.61 v2(134.61,90.21)
  BOTTOM w0.127: VRAM1.H10 134.22,90.6 v2(134.61,90.21) ; v2(118.81,97.4) 118.81,95.87 117.79,94.86 116.32,94.86 116.17,95.01 115.31,95.01 U8.C26
FBA_CMD2: length 29.8
  TOP w0.127: v2(112.96,95.87) 113.36,96.26 113.89,96.26 113.9,96.25 115.5,96.25 116.19,96.94 120.85,96.94 121.29,97.38 124.15,97.38 125.62,98.86 131,98.86 131.28,98.58 131.28,97.78 134.09,94.98 v1(134.09,93.08) 134.09,91.53 v2(134.61,91.01)
  BOTTOM w0.127: v2(134.61,91.01) 134.22,91.4 VRAM1.H11 ; U8.E24 113.33,96.24 v2(112.96,95.87)
FBA_CMD3: length 28.3
  IN3 w0.102: v2(133.01,91.01) 133.59,91.58 133.59,94.07 128.03,99.63 118.76,99.63 118.55,99.43 117.28,99.43 116.72,98.87 115.58,98.87 114.69,97.98 113.36,97.98 v2(112.93,97.55)
  BOTTOM w0.127: U8.F24 113.33,97.15 v2(112.93,97.55) ; v2(133.01,91.01) 132.62,91.4 VRAM1.K11
FBA_CMD4: length 23.3
  TOP w0.127: v2(133.01,90.21) 132.61,90.61 132.61,93.09 132.65,93.13 132.65,94.37 131.07,95.95 125.64,95.95 125.17,95.48 120.23,95.48 119.9,95.15 117.68,95.15 v2(117.33,95.49)
  BOTTOM w0.127: VRAM1.K10 132.62,90.6 v2(133.01,90.21) ; v2(117.33,95.49) 116.93,95.08 116.42,95.08 116.07,95.43 U8.D27
FBA_CMD5: length 24.1
  TOP w0.127: v2(132.21,92.61) 131.81,93.01 131.81,94.42 131.44,94.79 131.07,94.79 130.87,94.99 v1(130.87,95.36) 130.71,95.52 126.05,95.52 125.57,95.05 125.09,95.05 124.9,94.86 124.9,94.38 124.64,94.11 124.46,94.11 124.33,94.24 124.33,94.84 124.12,95.05 120.41,95.05 120.08,94.72 116.92,94.72 116.65,94.99 v2(116.65,95.49)
  BOTTOM w0.127: v2(132.21,92.61) 131.81,92.2 VRAM1.L12 ; v2(116.65,95.49) 117,95.84 117,96.02 116.87,96.15 115.3,96.15 114.93,95.78 U8.D26
FBA_CMD6: length 27.9
  IN3 w0.102: v2(132.21,86.21) 131.82,86.6 131.82,87.36 131.23,87.95 130.37,87.95 129.36,88.96 128.74,88.96 127.83,89.87 127.83,90.38 127.81,90.41 127.81,95.3 127.07,96.04 119.47,96.04 118.98,96.53 118.36,96.53 117.54,97.36 v2(117.54,97.37)
  BOTTOM w0.102: 115.34,97.29 115.1,97.53 114.53,97.53 U8.F25
  BOTTOM w0.127: v2(132.21,86.21) 132.61,85.81 VRAM1.K4 ; v2(117.54,97.37) 116.86,96.7 115.6,96.7 115.34,96.96 115.34,97.29
FBA_CMD7: length 26.3
  IN3 w0.102: v2(118.17,97.37) 118.54,97 119.25,97 119.7,96.56 127.2,96.56 128.62,95.14 128.62,92.19 128.61,92.18 128.61,90.03 129.22,89.42 129.57,89.42 130.59,88.4 131.04,88.4 132.21,87.23 v2(132.21,87.01)
  BOTTOM w0.127: U8.F26 114.93,96.83 115.38,96.38 117.41,96.38 118.17,97.14 v2(118.17,97.37) ; VRAM1.K5 132.61,86.61 v2(132.21,87.01)
FBA_CMD8: length 32.2
  IN3 w0.102: v2(112.94,96.73) 112.94,96.66 113.35,96.25 114.86,96.25 115.3,96.7 115.3,97.45 115.89,98.03 117.16,98.03 117.36,98.23 127.46,98.23 131.01,94.69 131.01,90 131.23,89.78 131.61,89.78 133.41,87.97 133.41,86.43 133.18,86.21 v2(133.01,86.21)
  BOTTOM w0.127: v2(112.94,96.73) 112.54,97.13 U8.F23 ; VRAM1.J4 133.41,85.81 v2(133.01,86.21)
FBA_CMD9: length 33.7
  IN3 w0.102: v2(133.01,87.01) 133.01,87.73 131.42,89.32 130.97,89.32 130.2,90.08 130.2,90.38 130.23,90.41 130.23,94.82 127.47,97.58 120.63,97.58 120.43,97.78 116.04,97.78 115.76,97.5 115.76,96.51 114.72,95.46 112.74,95.46 112.58,95.62 112.58,96.13 112.46,96.25 111.82,96.25 111.72,96.35 111.72,97.15 v2(111.32,97.55)
  BOTTOM w0.127: VRAM1.J5 133.41,86.61 v2(133.01,87.01) ; U8.G22 111.69,97.92 v2(111.32,97.55)
FBA_CMD10: length 32.9
  IN3 w0.102: v2(112.11,97.55) 112.17,97.55 112.58,97.14 114.62,97.14 115.71,98.23 116.98,98.23 117.44,98.69 127.65,98.69 131.81,94.54 131.81,91.93 131.83,91.91 131.83,91.55 132.14,91.25 132.14,89.9 134.2,87.83 134.2,86.59 v2(133.81,86.21)
  BOTTOM w0.127: v2(133.81,86.21) 134.21,85.81 VRAM1.H4 ; U8.G23 112.49,97.93 v2(112.11,97.55)
FBA_CMD11: length 30.9
  IN3 w0.102: v2(134.61,87.01) 134.61,88.07 132.62,90.06 132.62,94.4 127.87,99.15 117.38,99.15 116.67,98.44 115.53,98.44 114.64,97.55 v2(113.73,97.55)
  BOTTOM w0.102: U8.G24 113.35,97.93 v2(113.73,97.55)
  BOTTOM w0.127: VRAM1.H5 134.21,86.61 v2(134.61,87.01)
FBA_CMD12: length 30.2
  IN3 w0.102: v2(116.9,97.37) 116.9,97.35 118.2,96.05 118.77,96.05 119.24,95.59 126.46,95.59 126.99,95.05 126.99,89.46 128.08,88.38 129.32,88.38 130.08,87.62 130.62,87.62 130.74,87.49 130.74,86.09 131.02,85.81 132.37,85.81 132.6,85.58 132.6,85.15 132.73,85.03 135.03,85.03 v2(135.41,85.41)
  BOTTOM w0.127: U8.F27 115.94,96.92 116.46,96.92 v2(116.9,97.37) ; v2(135.41,85.41) 135.01,85.01 VRAM1.G3
FBA_CMD13: length 35.2
  IN3 w0.102: v2(133.81,85.41) 134.22,85.81 134.78,85.81 135.01,86.04 135.01,88.94 134.23,89.72 134.23,91.24 134.05,91.43 134.05,94.26 128.2,100.11 123.2,100.11 122.77,100.54 120.42,100.54 v1(119.95,100.07)
  BOTTOM w0.127: v1(119.95,100.07) 119.95,99.81 R315.2 116.9,99.05 116.27,98.41 114.62,98.41 114.14,97.93 U8.G25 ; VRAM1.J2 133.81,84.6 v2(133.81,85.41)
FBA_CMD14: length 27.2
  IN3 w0.102: v2(133.01,85.41) 133.01,85.6 132.63,85.98 132.63,87.46 131.23,88.86 130.78,88.86 129.62,90.02 129.62,90.54 129.42,90.74 129.42,91.91 129.4,91.93 129.4,95 127.39,97.01 120.46,97.01 120.1,97.37 v2(120.08,97.37)
  BOTTOM w0.127: U8.G27 119.34,97.93 119.44,98.03 R316.2 119.94,97.51 v2(120.08,97.37) ; v2(133.01,85.41) 133.41,85.01 VRAM1.J3
FBA_CMD15: length 27.5
  IN3 w0.102: v2(116.27,97.37) 116.27,97.33 118.09,95.52 118.6,95.52 118.98,95.13 125.38,95.13 126.02,94.49 126.02,89.37 127.47,87.92 129.27,87.92 129.6,87.59 129.6,86.22 130.21,85.61 130.21,85.13 130.31,85.03 131.83,85.03 v2(132.21,85.41)
  BOTTOM w0.102: U8.G26 115.24,97.93 115.65,97.52
  BOTTOM w0.127: v2(132.21,85.41) 131.81,85 VRAM1.L3 ; 115.65,97.52 116.11,97.52 v2(116.27,97.37)
FBA_CMD16: length 27.6
  TOP w0.127: v2(113.73,102.49) 114.19,102.03 v1(119.82,102.03) 120.65,102.03 122.03,103.41 122.03,106 126.47,110.44 131.93,110.44 132.61,109.75 132.61,108.21 v2(132.21,107.81)
  BOTTOM w0.127: VRAM2.G12 131.81,107.4 v2(132.21,107.81) ; v2(113.73,102.49) 113.7,102.49 113.33,102.12 U8.M24
FBA_CMD17: length 26.1
  TOP w0.127: v2(132.21,109.46) 131.67,110.01 126.65,110.01 122.46,105.82 122.46,103.21 120.84,101.59 117.41,101.59 117.19,101.8 113.6,101.8 v2(112.92,102.49)
  BOTTOM w0.127: VRAM2.H10 132.61,109.01 132.21,109.41 v2(132.21,109.46) ; U8.M23 112.53,102.1 v2(112.92,102.49)
FBA_CMD18: length 25.8
  IN3 w0.102: v2(114.53,100.85) 114.88,100.49 118.22,100.49 119.52,101.79 119.67,101.79 122.26,104.38 131.89,104.38 132.62,105.12 132.62,108.21 v2(132.21,108.62)
  BOTTOM w0.102: v2(114.53,100.85) 114.5,100.82 114.06,100.82 113.64,100.41 U8.K24
  BOTTOM w0.127: v2(132.21,108.62) 132.21,108.61 132.61,108.21 VRAM2.H11
FBA_CMD19: length 29.6
  IN3 w0.102: v2(133.81,108.62) 133.39,108.2 133.39,107.65 133.08,107.34 133.08,103.92 132.42,103.26 121.8,103.26 119.87,101.33 119.57,101.33 118.53,100.29 114.84,100.29 114.15,99.59 114.15,98.96 113.98,98.79 113.6,98.79 113.35,99.05 113.35,99.43 112.93,99.84 v2(112.93,100.01)
  BOTTOM w0.102: U8.K23 v2(112.93,100.01)
  BOTTOM w0.127: VRAM2.K11 134.21,108.21 133.81,108.61 v2(133.81,108.62)
FBA_CMD20: length 24.8
  TOP w0.127: v2(133.81,109.46) 133.76,109.46 132.35,110.87 126.29,110.87 121.6,106.18 121.6,103.61 120.58,102.6 118.04,102.6 117.61,103.03 116.6,103.03 116.25,102.69 v2(116.25,102.61)
  BOTTOM w0.127: U8.M27 v2(116.25,102.61) ; v2(133.81,109.46) 133.81,109.41 134.21,109.01 VRAM2.K10
FBA_CMD21: length 30
  TOP w0.127: v2(115.34,102.55) 115.89,103.1 116.03,103.1 116.39,103.47 117.82,103.47 118.17,103.11 120.46,103.11 121.16,103.82 121.16,106.36 126.11,111.3 v1(133.16,111.3) 134.62,111.3 135.81,110.11 135.81,108.21 v2(135.41,107.81)
  BOTTOM w0.127: U8.M26 114.93,102.14 v2(115.34,102.55) ; v2(135.41,107.81) 135.01,107.41 VRAM2.L12
FBA_CMD22: length 28.4
  IN3 w0.102: v2(134.61,113.4) 134.61,113.41 134.24,113.78 132.78,113.78 132.27,113.27 132.27,112.25 131.76,111.75 124.65,111.75 118.35,105.45 118.35,104.1 118.04,103.8 118.04,102.65 117.56,102.16 114.8,102.16 v2(114.5,102.46)
  BOTTOM w0.127: v2(134.61,113.4) 134.61,113.41 134.22,113.8 VRAM2.K4 ; U8.M25 v2(114.5,102.46)
FBA_CMD23: length 26.7
  IN3 w0.102: v2(134.61,112.61) 134.61,111.67 132.85,109.92 125.74,109.92 121.09,105.27 121.09,103.86 118.59,101.35 115.98,101.35 v2(115.5,100.88)
  BOTTOM w0.127: U8.K26 114.99,100.41 115.46,100.88 v2(115.5,100.88) ; VRAM2.K5 134.22,113 134.61,112.61 v2(134.61,112.61)
FBA_CMD24: length 30.5
  IN3 w0.102: v2(112.11,100.01) 111.69,100.43 111.69,101 111.97,101.28 112.41,101.28 113.35,102.22 113.35,102.73 113.56,102.94 114.32,102.94 115.31,103.94 115.31,104.57 117.16,106.41 117.79,106.41 124.04,112.66 129.75,112.66 130.21,113.12 130.21,113.75 131.05,114.59 132.63,114.59 v2(133.01,114.21)
  BOTTOM w0.127: v2(112.11,100.01) 111.71,100.41 U8.K22 ; v2(133.01,114.21) 133.01,114.21 133.41,113.81 VRAM2.J4
FBA_CMD25: length 31.3
  IN3 w0.102: v2(112.93,99.19) 112.51,99.61 112.51,101 113.47,101.96 117.66,101.96 118.81,103.11 118.81,105.14 124.95,111.29 131.94,111.29 132.59,111.94 132.59,112.83 132.75,112.99 133.43,112.99 133.81,112.61 v2(133.81,112.61)
  BOTTOM w0.127: v2(133.81,112.61) 133.81,112.61 133.42,113 VRAM2.J5 ; U8.J23 112.53,99.59 v2(112.93,99.19)
FBA_CMD26: length 30.8
  IN3 w0.102: v2(113.73,100.01) 113.52,100.22 113.52,101.22 113.86,101.56 118.19,101.56 119.73,103.1 119.73,104.64 125.46,110.37 132.55,110.37 134.2,112.03 134.2,112.86 133.66,113.41 133.02,113.41 v2(133.01,113.4)
  BOTTOM w0.102: v2(113.73,100.01) U8.J25
  BOTTOM w0.127: v2(133.01,113.4) 133.01,113.41 132.62,113.8 VRAM2.H4
FBA_CMD27: length 29.5
  IN3 w0.102: v2(113.75,99.19) 113.75,99.41 113.32,99.83 113.32,101.31 113.77,101.76 117.89,101.76 119.26,103.14 119.26,104.84 125.26,110.83 132.35,110.83 133.01,111.49 v2(133.01,112.61)
  BOTTOM w0.127: VRAM2.H5 132.62,113 133.01,112.61 v2(133.01,112.61) ; v2(113.75,99.19) U8.J24
FBA_CMD28: length 25.7
  IN3 w0.102: v2(131.41,114.21) 131.41,114 131.81,113.6 131.81,112.43 131.58,112.2 124.34,112.2 117.89,105.75 117.89,104.3 117.44,103.85 v2(117.44,102.6)
  BOTTOM w0.127: VRAM2.G3 131.81,114.6 131.42,114.21 v2(131.41,114.21) ; v2(117.44,102.6) 117.44,101.61 116.23,100.41 U8.K27
FBA_CMD29: length 29.2
  TOP w0.127: v2(118.43,103.62) 119.58,103.62 R317.1 120.73,104.77 120.73,106.53 126.03,111.83 132.1,111.83 132.57,112.31 132.57,114.36 133.01,114.8 v2(133.01,114.99)
  BOTTOM w0.127: VRAM2.J2 133.41,115.4 133.01,115.01 v2(133.01,114.99) ; U8.K25 114.5,100.04 116.37,100.04 116.57,100.24 116.83,100.24 117.89,101.31 117.89,102.83 118.43,103.36 v2(118.43,103.62)
FBA_CMD30: length 34.6
  IN3 w0.102: v2(121.22,101.36) 121.75,101.36 122.74,102.35 133.16,102.35 134.99,104.18 134.99,110.53 135.82,111.37 135.82,114.41 135.62,114.62 134.38,114.62 133.97,114.21 v2(133.81,114.21)
  BOTTOM w0.127: v2(133.81,114.21) 133.8,114.21 VRAM2.J3 ; v2(121.22,101.36) 120.37,100.51 119.76,100.51 119.3,100.05 R314.1 118.94,99.81 115.93,99.81 U8.J27
FBA_CMD31: length 32.8
  IN3 w0.102: v2(134.61,114.21) 134.61,114.21 135.01,113.8 135.01,112.3 135.32,112 135.32,111.6 134.23,110.52 134.23,104.31 132.73,102.81 122.01,102.81 120.2,101 119.92,101 118.98,100.06 116.16,100.06 v2(115.3,99.21)
  BOTTOM w0.127: VRAM2.L3 135,114.6 134.61,114.21 v2(134.61,114.21) ; U8.J26 115.3,99.24 v2(115.3,99.21)
FBA_DBI0: length 36.7
  TOP w0.165: v2(137.81,83.81) 136.8,83.81 136.14,84.46 127.03,84.46 126.12,85.37 126.12,86.63 v1(124.26,88.5) 122.45,90.31 112.3,90.31 110.86,91.75 110.86,92.65 110.01,93.51 110.01,94 109.7,94.31 109.7,95.61 v2(109.5,95.82)
  BOTTOM w0.165: v2(109.5,95.82) 109.47,95.82 109.15,95.5 U8.D19 ; v2(137.81,83.81) 137.42,84.2 VRAM1.D2
FBA_DBI1: length 37.7
  IN1 w0.102: 137.22,94.73 137.39,94.56 137.39,93.79 v2(137.01,93.41) ; 107.25,97.12 106.77,97.12 106.67,97.01 106.67,96.43 106.48,96.25 105.82,96.25 v2(105.45,95.87)
  IN1 w0.152: 107.25,97.12 109.15,97.12 109.21,97.06 109.86,97.06 109.92,97.12 111.91,97.12 111.93,97.14 114.46,97.14 114.49,97.12 115,97.12 115.72,97.83 117.25,97.83 118.06,98.64 132.28,98.64 132.74,98.18 133.5,98.18 135.51,96.18 135.77,96.18 137.22,94.73
  BOTTOM w0.165: v2(137.01,93.41) 137.41,93.01 VRAM1.D13 ; v2(105.45,95.87) 105.03,95.45 U8.D14
FBA_DBI2: length 28.1
  IN1 w0.152: v2(107,91.55) 107,91.26 107.74,90.51 109.05,90.51 109.86,89.7 123.01,89.7 124.86,91.55 126.54,91.55 127.47,92.49 128.9,92.49 v2(129.01,92.61)
  BOTTOM w0.102: v2(107,91.55) 107.22,91.77 107.22,93.64 107.17,93.69 107.17,93.97 107.51,94.32 U8.C17
  BOTTOM w0.165: VRAM1.P13 129.41,93 v2(129.01,92.61)
FBA_DBI3: length 24.8
  BOTTOM w0.079: VRAM1.P2 129.04,84.57 128.46,84.57 128.34,84.69 126.82,84.69 126.68,84.82
  BOTTOM w0.165: 126.68,84.82 126.55,84.82 126.2,85.18 126.2,87.08 122.46,90.82 113.1,90.82 112.01,91.91 112.01,92.5 112.27,92.76 112.27,93.47 112.08,93.66 112.08,94.09 111.63,94.54 U8.C22
FBA_DBI4: length 27.9
  IN1 w0.102: v2(137.81,106.21) 137.81,105.95 138.19,105.57 138.19,105.25 137.94,104.99
  IN1 w0.152: v2(113.73,104.07) 114.05,103.74 114.36,103.74 114.96,103.15 117.37,103.15 118.3,104.08 126.24,104.08 126.49,104.33 137.27,104.33 137.94,104.99
  BOTTOM w0.165: v2(113.73,104.07) 113.39,103.73 U8.P24 ; v2(137.81,106.21) 137.42,106.6 VRAM2.P13
FBA_DBI5: length 28
  IN1 w0.102: v2(137.81,115.01) 137.41,114.6 136.65,114.6
  IN1 w0.152: v2(114.51,108.29) 114.84,108.29 116.34,109.78 119.18,109.78 120.88,111.48 122.99,111.48 125.34,113.83 128.54,113.83 128.56,113.8 135.85,113.8 136.65,114.6
  BOTTOM w0.165: v2(137.81,115.01) 137.8,115.01 VRAM2.P2 ; v2(114.51,108.29) 113.77,108.29 U8.W24
FBA_DBI6: length 17.7
  TOP w0.165: v2(114.53,109.93) 115.08,109.93 116.31,111.16 121.94,111.16 v1(122.13,111.35) 125.19,114.41 128.28,114.41 128.86,114.99 v2(129.01,114.99)
  BOTTOM w0.165: VRAM2.D2 129.41,115.4 129.01,115.01 v2(129.01,114.99) ; v2(114.53,109.93) U8.AA25
FBA_DBI7: length 16.3
  BOTTOM w0.079: 126.66,107.22 126.79,107.09 128.34,107.09 128.46,106.97 128.97,106.97 129.34,106.6 VRAM2.D13
  BOTTOM w0.165: 126.66,107.22 126.47,107.4 v1(123.38,107.4) 119,107.4 118.11,106.52 116.13,106.52 116.01,106.4 115.39,106.4 115.15,106.64 114.56,106.64 U8.U25
FBA_EDC0: length 36.9
  TOP w0.102: 136.46,84.93 136.66,84.93 136.71,84.99 137.43,84.99 v2(137.81,84.61)
  TOP w0.165: 136.46,84.93 127.22,84.93 126.59,85.56 126.59,86.83 v1(123.46,89.96) 122.63,90.79 112.55,90.79 111.13,92.22 111.13,92.77 110.27,93.62 110.27,94.11 109.97,94.42 109.97,96.23 v2(109.54,96.65)
  BOTTOM w0.165: v2(137.81,84.61) 138.21,84.21 VRAM1.C2 ; U8.E19 109.15,96.26 v2(109.54,96.65)
FBA_EDC1: length 37.5
  IN1 w0.102: 115.12,95.71 114.87,95.45 111.4,95.45 111.36,95.41 107.68,95.41 107.63,95.36 107.28,95.36 107.23,95.41 105.79,95.41 v2(105.46,95.07) ; 135.55,94.73 135.82,94.45 135.82,93.1 135.93,93 137.41,93 v2(137.81,93.41)
  IN1 w0.152: 135.55,94.73 135.05,95.22 134.19,95.22 131.79,97.62 121.62,97.62 120.46,96.46 115.87,96.46 115.12,95.71
  BOTTOM w0.165: v2(137.81,93.41) 138.21,93.01 VRAM1.C13 ; U8.C15 105.87,94.66 v2(105.46,95.07)
FBA_EDC2: length 28
  IN1 w0.152: v2(129.01,93.41) 128.61,93 127.26,93 126.81,92.54 125.13,92.54 122.8,90.21 110.07,90.21 109.26,91.02 107.95,91.02 107.5,91.47 107.5,91.81 107.25,92.06 106.64,92.06 v2(106.39,91.81)
  BOTTOM w0.102: U8.B16 106.67,93.53 107.01,93.19 107.01,92.43 v2(106.39,91.81)
  BOTTOM w0.165: v2(129.01,93.41) 128.61,93 VRAM1.R13
FBA_EDC3: length 23.5
  BOTTOM w0.079: VRAM1.R2 128.45,84.2 128.13,84.52 126.6,84.52
  BOTTOM w0.165: 126.6,84.52 126.55,84.57 126.3,84.57 125.92,84.95 125.92,86.68 122.25,90.35 112.9,90.35 111.72,91.53 111.72,92.59 112,92.87 112,93.28 111.63,93.65 U8.B22
FBA_EDC4: length 26.9
  IN1 w0.102: v2(137.81,107.01) 137.39,106.59 137.39,105.25 137.03,104.89
  IN1 w0.152: v2(114.57,104.15) 115.39,104.15 116.01,103.53 117.02,103.53 118.07,104.58 126.02,104.58 126.28,104.83 136.98,104.83 137.03,104.89
  BOTTOM w0.165: U8.R25 114.13,104.52 114.5,104.15 v2(114.57,104.15) ; v2(137.81,107.01) 138.21,106.61 VRAM2.R13
FBA_EDC5: length 29.6
  IN1 w0.102: 136.71,115.4 137.41,115.4 v2(137.81,115.81)
  IN1 w0.152: v2(112.93,108.27) 113.92,108.27 114.35,108.7 114.88,108.7 115.92,109.75 115.92,110.35 116.23,110.66 119.34,110.66 120.67,111.99 122.78,111.99 126.19,115.39 133.41,115.39 133.5,115.3 136.61,115.3 136.71,115.4
  BOTTOM w0.165: v2(112.93,108.27) 112.93,108.25 U8.W23 ; VRAM2.R2 138.21,115.41 v2(137.81,115.81)
FBA_EDC6: length 16.2
  TOP w0.165: v2(128.21,115.81) 127.84,115.43 125.54,115.43 v1(124.21,114.09) 121.76,111.64 v2(118.25,111.64)
  BOTTOM w0.165: VRAM2.C2 128.21,115.8 v2(128.21,115.81) ; U8.AB26 115.11,110.33 115.5,110.73 117.54,110.73 118.25,111.44 v2(118.25,111.64)
FBA_EDC7: length 14.6
  BOTTOM w0.079: 126.6,106.92 128.13,106.92 128.45,106.6 VRAM2.C13
  BOTTOM w0.165: 126.6,106.92 126.07,106.92 125.69,106.54 v1(119.7,106.54) 118.8,106.54 118.51,106.25 116.24,106.25 116.12,106.13 115.38,106.13 114.93,105.68 U8.T26
FBA_VREFC_1: length 4
  TOP w0.508: R411.2 R407.2 R410.2 133.56,99.02 133.56,98.06 C505.1 133.66,97.9 133.66,97.29 133.7,97.25 v1(133.7,97.18)
FBA_VREFC_2: length 5.5
  TOP w0.508: R25284.2 R25283.2 C506.1 R25282.2 133.81,105.15 v2(133.81,105.41)
  BOTTOM w0.33: v2(133.81,105.41) 133.42,105.8 VRAM2.J14
FBVDD_EN: length 3.7
  BOTTOM w0.102: v1(101.55,122.02) 101.55,121.76 U11.4 102.66,121.21 102.86,121.02 103.1,121.02 R25469.1 103.1,120.77 103.36,120.52 103.71,120.52 103.96,120.26 R325.2
FBVDDQ_EN: length 107.3
  IN1 w0.089: v1(104.62,124.2) 104.79,124.2 105.04,124.44 105.76,124.44 106.18,124.03 106.18,122.71 106.05,122.58 106.05,122.26 105.8,122.02 105.8,120.1 106.09,119.82 106.09,117.09 104.82,115.82 104.82,112.1 105.01,111.91 105.01,110.42 103.82,109.23 101.45,109.23 99.98,107.76 99.98,103.52 100.18,103.32 100.18,101.73 100.09,101.64 100.09,101.14 101.07,100.16 101.07,98.72 100.06,97.71 100.06,96.28 99.76,95.97 99.76,94.65 100.54,93.86 100.54,91.66 102.15,90.05 103.68,90.05 110.42,83.3 115.32,83.3 118.02,80.6 121.47,80.6 122.42,81.55 125.81,81.55 126.45,80.91 127.24,80.91 128.05,80.1 139.93,80.1 142.73,77.3 142.73,69.53 142.09,68.88 141.45,68.88 141.29,68.72 141.29,67.63 141.65,67.27 v1(142.51,67.27)
  BOTTOM w0.102: PR9095.2 141.95,66.71 v1(142.51,67.27) ; v1(104.62,124.2) 104.61,124.19 104.61,123.5 104.27,123.16 104.27,122.8 104.79,122.29 105.28,121.79 105.28,120.75 105.09,120.56 104.33,120.56 R25469.2
G5335-AGND-1: length 11.8
  TOP w0.203: v1(122.22,41.26) 119.34,41.26 118.82,41.78 v1(118.82,42.1)
  BOTTOM w0.203: PR273.1 121.57,38.87 PR272.2 121.85,40.02 122.31,40.02 122.57,40.27 122.57,40.92 v1(122.22,41.26) PC228.2 ; PR273.1 121.59,38.63 121.86,38.37 122.01,38.37 122.4,37.98 PR270.2 ; PR273.1 121.39,38.85 120.38,37.84 PU16.4 ; PC232.2 118.82,41.83 v1(118.82,42.1)
G5335-AGND-2: length 3.2
  BOTTOM w0.254: v1(141.69,68.39) 141.92,68.16 PC9090.2 ; v1(140.73,66.18) 140.57,66.18 140.32,66.44 PU9004.4 ; v1(141.49,69.9) 141.06,69.47 PC9091.2 ; PR9097.2 v1(142.39,63.39)
G5335-BST-1: length 1.8
  TOP w0.508: PR277.2 117.68,40.48 117.54,40.62 v1(117.54,40.91)
  BOTTOM w0.203: PU16.20 117.72,40.55 117.54,40.72 v1(117.54,40.91)
G5335-BST-2: length 3.4
  BOTTOM w0.254: 139.04,70.05 138.95,70.05 138.73,69.84 138.01,69.84 137.56,69.38 PU9004.20
  BOTTOM w0.508: 139.04,70.05 139.56,70.57 PR9089.2
G5335-EN-1: length 3.9
  BOTTOM w0.203: PR274.1 PC228.1 121.12,41.11 120.79,40.78 120.79,39.18 120.45,38.84 PU16.2
G5335-EN-2: length 18.6
  TOP w0.508: v1(140.55,68.44) 140.02,68.97 140.02,71.01 138.98,72.05 137.96,72.05 134.76,75.25 132.52,75.25 131.41,76.36 PQ9086.2
  BOTTOM w0.254: PU9004.2 140.25,67.44 140.55,67.73 v1(140.55,68.44) 140.82,68.44 141.43,67.83 PC9090.1 141.49,67.8 PR9095.1 141.49,66.34 141.33,66.18 PR9096.2
G5335-FB-1: length 4.6
  BOTTOM w0.203: PR269.2 122.58,36.21 122.68,36.31 PC225.1 121.62,37.82 PR270.1 121.52,37.98 121,37.98 120.54,37.52 120.54,37.45 120.42,37.34 PU16.5
G5335-FB-2: length 3.9
  BOTTOM w0.254: PR9097.1 PR9094.2 PC9089.1 140.51,65.35 140.51,65.68 140.25,65.94 PU9004.5
G5335-LX-1: length 2.5
  TOP w0.508: PC235.1 114.51,39.62 v1(114.64,39.48) 115.05,39.08 115.62,39.08 PR99.1
  vias: v1(115.03,40.23)
G5335-LX-2: length 1
  TOP w0.508: v1(136.64,63.87) 137.09,64.32 PR9092.1
  vias: v1(134.28,69.06)
G5335-PFM-1: length 2.9
  BOTTOM w0.203: PR98.1 PR272.1 121.12,39.04 120.41,38.34 PU16.3
G5335-PFM-2: length 2.4
  TOP w0.254: PR9093.1 141.29,67.06 141,67.35 140.91,67.35 PR9091.1 140.7,67.15 v1(140.7,66.84)
  BOTTOM w0.254: PU9004.3 140.6,66.94 v1(140.7,66.84)
G5335-PWRGD-1: length 2.2
  BOTTOM w0.203: PR276.1 120.46,39.56 120.23,39.34 PU16.1
G5335-PWRGD-2: length 2.8
  BOTTOM w0.254: PU9004.1 139.81,68.43 140.32,68.95 141.29,68.95 141.36,68.88 PR9090.1
G5335-SS-1: length 1.2
  BOTTOM w0.203: PU16.23 119.22,40.6 119.04,40.78 PC232.1
G5335-SS-2: length 1.5
  BOTTOM w0.254: PU9004.23 139.48,68.69 140.14,69.35 PC9091.1
G5335-TON-1: length 1.6
  BOTTOM w0.203: PU16.6 120.15,36.84 120.33,36.66 120.33,36.03 120.55,35.81 PR268.1
G5335-TON-2: length 1.7
  BOTTOM w0.254: PU9004.6 139.81,64.14 PR9086.1
G5335-VCC-1: length 1.6
  TOP w0.508: PR104.2 119.17,40.06 118.29,40.94 v1(118.18,40.94)
G5335-VCC-2: length 5.5
  BOTTOM w0.254: PU9004.21 138.06,69.25 138.24,69.43 139.29,69.43 139.9,70.04 140.4,70.04 141,70.64 PR9087.2
  BOTTOM w0.508: PC9075.1 140.99,71.58 140.98,71.57 140.98,70.69 PR9087.2
G5719LX1.5V:
  vias: v1(164.69,22.29)
G_MBCLK_R: length 6.6
  TOP w0.102: R25356.2 59.52,22.92 58.2,22.92 58,23.12 R591.2 C6605.1 57.44,22.79 v1(56.84,22.19) 56.08,21.43 U32.4
G_MBDATA_R: length 4.6
  TOP w0.102: U32.6 54.4,19.66 54.13,19.94 v1(53.59,19.94) 53.21,19.94 52.71,19.44 C6604.1 52.23,19.6 52.02,19.81 51.92,19.81 51.78,19.95 R590.2 R25355.2
GC6_FB_EN: length 30.1
  TOP w0.102: v2(85,101.38) 85.08,101.3 85.08,100.38 85.35,100.11 86.03,100.11 86.84,99.3 87.27,99.3 87.69,98.88 R394.1 87.69,98.39 87.96,98.12 R25569.2 88.46,98.48 88.45,98.5 R372.2
  IN1 w0.089: v2(85,101.38) 85.53,101.92 87.36,101.92 87.97,101.31 89.27,101.31 89.48,101.52 89.48,102.14 88.91,102.71 88.91,103.46 89.45,104.01 89.45,108.77 90.21,109.52 90.21,116.56 v1(90.64,116.99)
  BOTTOM w0.102: v1(90.64,116.99) 90.28,117.34 Q16.2
GC6_FB_EN_N17: length 13.7
  TOP w0.102: v2(92.91,99.74) 92,98.84 89.53,98.84 89.38,98.69 89.04,98.69 R372.1
  IN2 w0.089: v2(92.2,94.59) 91.98,94.8 91.98,95.52 92.26,95.79 92.26,99.1 v2(92.91,99.74)
  BOTTOM w0.102: v2(92.2,94.59) 92.3,94.59 92.97,93.92 93.73,93.92 94.16,93.49 94.79,93.49 U8.B2
GC6_FB_EN_Q: length 123.3
  TOP w0.102: v4(80.81,38.82) 80.81,37.81 79.23,36.23 77.58,36.23 76.68,35.33 76.68,34.75 76.73,34.7 76.73,34.64 77.48,33.89 77.48,33.87 79.53,31.82 79.64,31.71 79.64,31.09 79.92,30.81 80.33,30.81 81.47,29.67 81.47,27.36 80.72,26.61 79.79,26.61 79.56,26.38 79.56,26.11 R2651.2 79.34,25.89 79.34,24.55 79.64,24.24 R2650.1
  IN1 w0.089: v4(80.81,38.82) 80.97,38.66 80.97,37.9 81.25,37.62 82.13,37.62 82.6,38.1 82.6,41.95 83.22,42.57 83.22,43.38 83.61,43.76 84.46,43.76 84.58,43.64 85.03,43.64 85.35,43.96 85.62,43.96 86.04,44.39 86.04,47.46 85.33,48.17 85.33,49.48 84.74,50.07 84.74,68.58 84.57,68.74 84.57,69.52 83.99,70.1 83.99,73.8 84.19,73.99 84.19,75.17 84.57,75.55 84.57,79.83 85.15,80.41 85.15,81.44 85.41,81.7 85.41,82.64 83.06,84.99 83.06,87.45 83.63,88.03 84.39,88.03 84.62,87.8 85.38,87.8 86.33,88.76 86.33,91.06 86.91,91.63 87.13,91.63 87.42,91.92 87.42,92.31 87.7,92.6 87.7,94.98 88.46,95.74 88.46,97.89 88.97,98.4 89.13,98.4 89.88,99.16 89.88,99.53 90.59,100.25 90.59,108.33 91.32,109.06 91.32,115.23 93.91,117.82 v1(93.91,117.83)
  BOTTOM w0.102: v4(80.81,38.82) 80.81,38.92 U2030.AN7 ; v1(93.91,117.83) 93.91,117.94 Q14.3 95.01,119.04 96.33,119.04 96.83,119.54 97.19,119.54 97.8,118.93 99.5,118.93 100.2,119.64 U11.1
GC6FBEN_Q_EC: length 1.9
  TOP w0.102: U37.2 182.11,27.78 TP9021.1
GPIO10_VREF: length 87.7
  TOP w0.381: v1(137.85,100.58) Q20.2
  IN2 w0.089: v2(97.64,92.44) 97.62,92.43 97.62,92.16 98.72,91.07 101.57,91.07 102.39,90.26 103.31,90.26 105.85,87.72 108.22,87.72 108.77,87.16 112.7,87.16 113.44,86.41 113.44,84.18 114.25,83.37 115.35,83.37 117.98,80.73 121.4,80.73 121.96,81.29 127.16,81.29 128.56,79.89 141.95,79.89 142.81,80.76 142.81,97.27 139.5,100.58 v1(137.85,100.58)
  BOTTOM w0.102: R398.2 90.35,89.39 92.07,91.11 94.14,91.11 94.46,91.43 95.39,91.43 96.35,92.39 97.59,92.39 v2(97.64,92.44) 97.64,92.56 98.08,93 98.08,93.61 97.95,93.74 97.95,94.26 U8.C5
GPU_CHOKE_THERMAL: length 222.9
  TOP w0.102: PR9025.1 74.51,105.14 v1(75.2,104.46) ; U37.126 185.65,30.71 185.45,30.9 185.45,31.74 185.38,31.82 185.38,32.17 v2(185.76,32.55) ; v1(40.09,108.47) 40.24,108.62 R25502.1
  IN2 w0.089: v1(40.09,108.47) 40.14,108.42 40.87,108.42 41.36,108.91 46.13,108.91 46.83,109.61 49.19,109.61 50.72,111.13 52,111.13 52.44,111.57 52.44,112.69 53,113.25 59.24,113.25 59.73,113.74 61.7,113.74 63.06,112.39 64.73,112.39 70.74,106.37 73.76,106.37 75.2,104.94 v1(75.2,104.46) 75.2,104.34 76.8,102.73 77.4,102.73 78.94,101.2 82.12,101.2 82.31,101.01 85.22,101.01 85.48,101.27 86.38,101.27 86.6,101.06 87,101.06 88.6,102.66 90.59,102.66 93.28,99.97 93.28,95.9 92.98,95.59 92.98,94.78 93.28,94.47 93.28,93.41 92.92,93.05 92.48,93.05 92.21,92.78 92.21,92.47 92.65,92.03 94.21,92.03 96.5,89.74 97.33,89.74 98.08,90.49 101.3,90.49 102.06,89.72 103.14,89.72 103.43,89.43 103.43,87.55 103.71,87.28 103.71,86.06 104.25,85.52 104.25,80.7 105.51,79.44 105.51,70.66 107.56,68.6 113.33,68.6 115.2,66.73 115.2,62.03 114.94,61.76 114.94,54.92 118.39,51.47 119.15,51.47 119.96,50.66 121.81,50.66 123.5,48.97 123.5,43.68 v1(124.47,42.71) ; v1(147.69,36.31) 147.69,35.75 148.02,35.41 149.31,35.41 149.37,35.35 155.58,35.35 155.77,35.54 159.15,35.54 161.24,33.45 165.12,33.45 165.78,32.8 171.09,32.8 171.79,32.1 173.48,32.1 174.05,32.66 176.08,32.66 176.37,32.95 184.03,32.95 184.43,32.55 v2(185.76,32.55)
  IN3 w0.089: v1(147.69,36.31) 147.66,36.33 146.77,36.33 146.59,36.51 145.98,36.51 145.6,36.89 143.22,36.89 142.62,36.3 142.62,34.79 140.66,32.83 139.43,32.83 138.33,33.93 136.24,33.93 135.89,34.28 135.89,35.2 135.6,35.5 134.22,35.5 133.29,36.43 132.63,36.43 130.24,38.82 127.98,38.82 125.14,41.66 125.14,42.04 v1(124.47,42.71)
GPU_EVENT#: length 101.9
  TOP w0.079: v4(79.59,38.8) 79.59,38.57 78.73,37.71 78.57,37.71 78.43,37.58 75.25,37.58
  TOP w0.102: R25573.2 88.33,99.68 87.86,100.14 87.43,100.14 86.78,100.79 85.96,100.79 v2(85.76,100.6) ; 75.25,37.58 75.12,37.58 74.79,37.25 74.79,34.61 74.53,34.35 74.53,32.81 76.69,30.65 76.69,24.37 77.13,23.94 77.13,23.26 R25482.2
  IN1 w0.089: v4(79.59,38.8) 79.38,38.8 78.84,39.33 77.36,39.33 77.13,39.56 77.13,39.66 77.09,39.7 77.09,40.32 77.86,41.1 80.91,41.1 81.15,41.34 81.15,41.79 80.94,42 80.54,42 80.35,42.19 80.35,42.91 80.46,43.01 80.46,43.51 80.73,43.79 81.4,43.79 82,44.38 82.49,44.38 82.79,44.68 82.79,45.16 82.71,45.24 82.71,48.36 83.07,48.72 83.07,51.73 83.6,52.26 83.6,54.76 83.45,54.91 83.45,55.64 84.03,56.23 84.03,69.34 83.4,69.97 83.4,70.2 82.82,70.79 82.82,72.38 82.9,72.46 82.9,73.09 82.76,73.23 82.76,75.48 83.4,76.11 83.4,79.67 83.79,80.06 83.79,82.88 82.28,84.39 82.28,87.77 83.93,89.43 85.29,89.43 85.51,89.64 85.51,90 85.02,90.49 85.02,91.79 85.04,91.82 85.04,92.84 85.02,92.86 85.02,95.36 86.02,96.35 87.18,96.35 87.48,96.66 87.48,98.55 87.13,98.91 86.98,98.91 86.41,99.48 86.41,99.95 v2(85.76,100.6)
  BOTTOM w0.102: v4(79.59,38.8) 79.81,38.57 U2030.AP5
GPU_EVENT#_GPU: length 3.6
  TOP w0.102: D4.2 90.01,98.05 R373.2 R25572.2 89.73,96.43 89.5,96.2 88.89,96.2 R25490.1
GPU_EVENT#_R: length 3.2
  TOP w0.102: D4.1 89.59,99.94 89.34,99.94 89.09,99.68 R25573.1 88.93,99.94 88.81,100.06 88.45,100.06 87.95,100.56 R25558.1
GPU_GPIO0: length 13.2
  TOP w0.102: v2(98.84,95.85) 98.56,96.13 R370.1 98.31,95.87 98.2,95.77 97.7,95.77 97.6,95.87 97.6,96.1 97.37,96.33 96.76,96.33 96.15,96.94 94.5,96.94 92.83,98.61 89.62,98.61 89.14,98.12 R25569.1
  BOTTOM w0.102: U8.C6 98.84,95.04 v2(98.84,95.85)
GPU_GPIO2: length 9
  TOP w0.102: v2(97.19,95.92) 96.86,95.92 96.48,95.54 94.23,95.54 92.63,97.14 R373.1
  BOTTOM w0.102: U8.D6 97.94,95.92 v2(97.19,95.92)
GPU_GPIO6: length 9.8
  TOP w0.102: v2(97.24,94.23) 96.85,94.23 95.97,95.11 94.17,95.11 93.19,96.09 91.2,96.09 90.83,95.72 R376.1 R25572.1
  BOTTOM w0.102: v2(97.24,94.23) 97.17,94.16 97.17,93.47 U8.A4
GPU_GPIO16: length 10
  TOP w0.102: v2(98.1,95.03) 98.1,93.86 97.58,93.35 97.07,93.35 96.97,93.25 94.04,93.25 93.98,93.3 92.05,93.3 91.36,93.99 R25589.1
  BOTTOM w0.102: v2(98.1,95.03) 97.69,95.43 U8.D5
GPU_GPIO21: length 10.6
  TOP w0.102: R404.1 88.46,95.38 89.06,94.78 89.46,94.78 89.81,95.12 90.32,95.12 90.51,94.93 R25591.1 90.99,94.7 91.83,95.54 92.65,95.54 93.05,95.14 93.05,94.7 93.3,94.45 96.05,94.45 v2(96.27,94.23)
  BOTTOM w0.102: v2(96.27,94.23) 96.43,94.23 96.73,94.53 U8.C4
GPU_PEX_RST_HOLD#: length 67.3
  TOP w0.102: v2(97.16,94.94) 97.69,94.41 97.69,94.03 97.41,93.75 96.9,93.75 96.8,93.65 94.2,93.65 93.82,94.04 93.06,94.04 92.92,94.19 91.74,94.19 91.53,94.4 90.95,94.4 90.89,94.34 90.35,94.34 90.16,94.15 90.16,94.09 R25589.2 89.96,94.09 89.96,94.6 R25591.2 ; v1(104.7,122.98) 104.86,123.14 104.86,123.83 105.6,124.56 105.6,124.95 106.11,125.46 107,125.46 107.07,125.54 114.9,125.54 115.73,124.7 U6505.2
  IN1 w0.089: v1(104.7,122.98) 104.93,122.76 104.93,122.12 105.22,121.83 105.22,119.93 103.87,118.58 103.87,117.03 102.91,116.07 102.91,114.62 102.46,114.17 102.39,114.17 100.9,112.69 100.9,109.64 99.4,108.14 99.4,103.28 99.6,103.08 99.6,101.98 99.51,101.88 99.51,100.69 98.86,100.04 98.86,97.23 97.65,96.02 97.65,95.43 v2(97.16,94.94)
  BOTTOM w0.102: v2(97.16,94.94) 97.02,95.08 95.79,95.08 95.47,94.76 95.47,92.89 95.27,92.69 94.89,92.69 94.85,92.73 94.06,92.73 93.62,93.17 90.76,93.17 90.52,92.93 90.2,92.93 89.94,92.68 89.94,92.36 89.42,91.84 89.04,91.84 R399.1
GPU_PWR_GD: length 67.4
  TOP w0.102: PR9008.1 74.88,107.3 75.46,106.73 75.46,106.53 77.01,104.98 77.01,104.74 v1(77.03,104.72)
  IN1 w0.089: v1(96.61,120.69) 95.47,120.69 94.16,119.37 93.86,119.37 93,118.51 93,117.69 90.78,115.46 90.78,109.28 90.05,108.55 90.05,100.47 89.52,99.94 88.72,99.94 87.86,99.09 87.86,96.2 86.8,95.13 85.95,95.13 85.92,95.1 85.65,95.1 85.4,94.85 85.4,93.02 85.45,92.97 85.45,91.69 85.41,91.64 85.41,90.65 85.89,90.16 85.89,89.49 85.05,88.64 v1(84.92,88.64)
  BOTTOM w0.102: 79.41,93.59 80.12,93.59 81.34,92.37 82.03,92.37 82.46,91.93 82.46,90.16 83.97,88.64 v1(84.92,88.64) ; 79.41,93.59 79.06,93.23 PR9079.2 ; 79.41,93.59 79.41,93.77 79.52,93.88 79.52,96.47 80.35,97.29 80.35,99.17 79.64,99.88 78.79,99.88 78.41,100.26 78.41,104.19 77.94,104.66 77.09,104.66 v1(77.03,104.72) ; v1(96.61,120.69) 97,121.08 R324.1
GPUT_CLK_L: length 14
  TOP w0.102: v2(101.32,95.05) 101.32,92.3 101.1,92.09 101.1,91.63 103.11,89.62 R25583.2 103.68,88.97 v1(103.92,89.22) 104.31,89.22 R365.2 104.99,89 106.3,89 106.72,88.58 107.44,88.58 108.03,87.99 Q13.4
  BOTTOM w0.102: U8.D9 101.29,95.05 v2(101.32,95.05)
GPUT_DATA_L: length 14.1
  TOP w0.102: v2(100.49,94.94) 100.49,94.94 100.49,94.93 100.48,94.92 100.48,91.85 100.75,91.58 100.75,91.48 102.58,89.65 102.58,88 v1(103.21,87.37) 103.5,87.08 103.5,86.52 104.44,85.58 R25582.2 R362.2 105.98,85.2 Q13.1
  BOTTOM w0.102: U8.D8 100.49,95.01 100.49,94.94 v2(100.49,94.94)
GSPI0_MOSI: length 9
  BOTTOM w0.079: 78.8,35.4 78.29,35.91 78.29,37.85 ; U2030.AR7 78.86,38.96
  BOTTOM w0.102: 78.86,38.96 78.58,38.96 78.21,38.58 78.21,38.22 78.29,38.13 78.29,37.85 ; R2603.2 80.96,32.82 81.16,33.03 81.16,33.56 80.88,33.84 80.36,33.84 79.53,34.67 78.8,35.4
GSPI1_MOSI: length 21.4
  TOP w0.102: R2287.2 78.24,24.82 78.24,26.38 78.67,26.81 80.63,26.81 81.26,27.44 81.26,29.59 80.26,30.59 79.85,30.59 79.23,31.21 79.23,31.81 76.5,34.54 76.5,35.41 77.58,36.49 79.13,36.49 79.96,37.32 v4(79.96,37.82)
  BOTTOM w0.102: U2030.AN5 79.96,37.85 v4(79.96,37.82)
H_CPU_SVIDART#: length 5.4
  BOTTOM w0.102: R2460.1 100.21,73.67 99.4,73.67 98.88,73.15 98.88,72.87 98.24,72.24 98.08,72.24 97.64,71.8 97.11,71.8 U2030.B63
