# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BOARD_ID2: length 32.1
  IN1 w0.089: 83.58,41.34 83.58,41.76 84.39,42.57 85.06,42.57 85.16,42.47 85.43,42.19 85.61,42.02 v4(85.68,41.95)
  IN1 w0.102: 83.58,41.34 83.58,31.74 83.65,31.67 83.65,31.43 83.91,31.18 84.26,31.18 84.29,31.2 85.76,31.2 86.42,31.86 87.43,31.86 88.09,32.52 93.46,32.52 94.21,31.78 v1(94.37,31.78)
  BOTTOM w0.102: R2602.1 92.67,28.39 R2583.2 92.41,29.01 92.87,29.48 93.61,29.48 94.37,30.24 v1(94.37,31.78) ; U2030.AB12 86.04,42.32 v4(85.68,41.95)
BOARD_ID3: length 30.5
  TOP w0.079: 97.93,35.32 97.33,35.92 94.23,35.92 92.77,37.37 92.77,37.91 92.03,38.66 92.03,39.52 91.97,39.57 91.97,41.5 91.22,42.25 89.89,42.25 89.04,43.11 88.63,43.11 88.44,42.91 87.16,42.91 86.79,42.54 v4(86.79,41.9)
  TOP w0.102: R2599.1 102.82,28.35 103.29,28.82 103.87,28.82 104.11,29.05 104.11,29.57 104.01,29.67 102.75,29.67 102.65,29.77 R2580.2 102.25,30.5 102.25,31.24 101.76,31.73 101.76,32.56 v1(102.02,32.82) 101.73,33.11 101.4,33.11 99.69,34.81 98.89,34.81 98.39,35.32 97.93,35.32
  BOTTOM w0.102: v4(86.79,41.9) 87.21,42.32 U2030.W12
BOARD_ID4: length 105.7
  TOP w0.079: R2598.1 97.54,31.04 R2585.2 ; 96.54,32 95.95,32 94.06,33.89 93.38,33.89 92.91,34.36 91.67,34.36 90.97,35.06 90.08,35.06 88.4,36.74 88.4,39.28 88.33,39.35 88.33,39.53 88.34,39.54 88.34,39.99 88.33,40 88.33,40.16 88.33,41.71 v4(87.8,42.24)
  TOP w0.102: R2585.2 97.54,31.72 97.27,31.99 96.59,31.99 96.58,32 96.54,32
  IN1 w0.089: v1(84.57,86.85) 84.44,86.73 84.44,85.05 86.35,83.15 86.35,81.78 85.86,81.3 85.86,75 85.1,74.24 85.1,70.69 85.36,70.44 85.36,51.16 86.62,49.9 86.62,48.1 87.36,47.36 87.36,42.68 v4(87.8,42.24)
  IN2 w0.089: v1(61.96,97.74) 62.43,97.74 63.36,98.67 65.34,98.67 67.68,96.33 69.3,96.33 70.52,95.12 73.85,95.12 81.16,87.8 82.58,87.8 83.63,86.75 84.47,86.75 v1(84.57,86.85)
  BOTTOM w0.102: U2030.W11 87.26,41.7 v4(87.8,42.24) ; v1(61.96,97.74) 61.24,98.46 60.62,98.46 59.4,99.68 56.13,99.68 55.76,100.05 55.76,100.82 56.45,101.51 C20025.2 R25598.1
BOARD_ID5: length 19.3
  TOP w0.079: v4(87.82,41.63) 88.17,41.28 88.17,40.55 88.18,40.55 88.18,40.23 88.17,40.23 88.17,39.93 88.18,39.92 88.18,39.61 88.17,39.6 88.17,39.28 88.17,35.82 88.96,35.04 89.8,35.04 89.98,34.86 90.89,34.86 91.78,33.97 v1(92.21,33.97) 92.87,33.97 93.8,33.03 94.65,33.03 96.17,31.52 R2560.2 96.11,31.07 96.11,29.77 96.29,29.59 R2562.1
  BOTTOM w0.102: U2030.W10 87.26,41.13 87.57,41.43 87.62,41.43 v4(87.82,41.63)
BOARD_ID6: length 101.3
  TOP w0.102: R2595.1 R2563.2 90.92,32.15 90.92,32.94 91.04,33.06 91.04,33.37 90.79,33.63 90.07,33.63 89.39,34.3 88.63,34.3 87.03,35.9 87.03,37.42 86.96,37.49 86.96,38.11 87.18,38.34 87.18,39.15 v4(87.8,39.76)
  IN1 w0.089: v4(87.8,39.76) 87.26,40.31 87.26,42.52 87.17,42.6 87.17,47.18 86.44,47.92 86.44,49.67 85.2,50.91 85.2,70.37 84.94,70.63 84.94,74.37 85.7,75.13 85.7,81.37 86.14,81.81 86.14,83.02 83.96,85.2 v1(83.96,87.21)
  IN2 w0.089: v1(58.07,101.75) 61.12,101.75 63.35,99.52 65.78,99.52 67.59,97.71 68.84,97.71 71.25,95.31 73.93,95.31 81.24,87.99 82.66,87.99 83.32,87.33 83.84,87.33 v1(83.96,87.21)
  BOTTOM w0.102: v4(87.8,39.76) 87.31,39.76 U2030.W8 ; R25599.1 57.85,104.76 58.23,104.38 58.23,103.11 58.73,102.61 C20026.2 59.27,101.75 v1(58.07,101.75)
BOARD_ID7: length 14.8
  TOP w0.102: v4(87.79,39.12) 87.36,38.69 87.36,38.27 87.16,38.06 87.16,37.62 87.26,37.52 87.26,35.95 88.71,34.5 89.5,34.5 89.96,34.04 v1(90.36,34.04) 90.77,34.04 91.22,33.59 91.22,32.99 91.1,32.86 91.1,32.07 90.99,31.97 90.99,30.94 90.92,30.87 90.92,30.3 R2577.2 91.48,29.74 91.48,28.92 91.01,28.45 R2594.1
  BOTTOM w0.102: v4(87.79,39.12) 87.74,39.06 U2030.W7
BRIGHT: length 3
  TOP w0.102: R441.1 54.37,102.95 v1(53.78,102.36) 53.38,102.77 R439.2 R443.2
BT_EN: length 11.3
  BOTTOM w0.102: CN17.54 191.51,17.88 191.7,18.07 191.7,18.36 192.08,18.74 192.08,19.18 v1(192.44,19.54) 193.35,20.44 R671.1 193.78,20.97 194.12,20.97 194.39,21.24 194.39,22.36 194.61,22.58 196.05,22.58 196.85,23.38 197.22,23.38 198.21,24.37 R960.2
BXTALOUT: length 10
  BOTTOM w0.102: U8.C10 101.28,94.2 101.28,92.92 100.66,92.29 100.66,91.74 99.63,90.71 98.46,90.71 98.11,90.36 98.11,90.11 R332.1 97.51,89.66 97.22,89.37 97.22,88.61 97.45,88.38 97.73,88.38 R330.1
C_IN_CLK: length 15.8
  TOP w0.102: R706.1 15.38,81.9 v1(15.51,81.77) 15.66,81.93 R703.2
  IN1 w0.089: CN37.10 11.6,76.55 11.7,76.66 13.33,76.66 14.59,77.91 14.59,81.88 15.1,82.38 16.32,82.38 16.51,82.19 16.51,81.65 16.27,81.41 15.62,81.41 15.51,81.52 v1(15.51,81.77)
  BOTTOM w0.102: R703.2 15.66,81.93 v1(15.51,81.77) 15.5,81.78 R489.1 14.46,81.45 13.88,81.45 13.78,81.55 D13087.2
C_IN_CLK#: length 15.8
  TOP w0.102: R702.2 15.66,80.86 v1(15.51,81.01) 15.38,80.89 R707.1
  IN1 w0.089: v1(15.51,81.01) 15.7,81.2 16.35,81.2 16.71,81.56 16.71,82.28 16.4,82.59 15.01,82.59 14.39,81.96 14.39,78 13.25,76.86 11.94,76.86 CN37.12
  BOTTOM w0.102: R702.2 15.66,80.86 v1(15.51,81.01) 15.5,81 R489.2 14.56,81.24 14.55,81.24 14.14,81.24 D13088.2
C_IN_CLK#_R: length 3
  TOP w0.102: U23.31 23.74,79.72 23.88,79.86 24.14,79.86 24.36,80.08 24.36,81 24.45,81.09 24.73,81.09 24.86,80.96 C847.2
C_IN_CLK_R: length 3
  TOP w0.102: C849.2 24.86,81.44 24.73,81.31 24.36,81.31 24.14,81.09 24.14,80.17 24.05,80.08 23.9,80.08 23.76,80.22 U23.32
C_TX0_HDMI+: length 17
  TOP w0.102: D13085.2 14.07,75.4 14.79,75.4 15.02,75.63 R712.1 15.38,75.81 v1(15.51,75.68) R697.2
  IN1 w0.089: v1(15.51,75.68) 15.73,75.45 16.09,75.45 16.5,75.04 16.5,74.46 15.73,73.7 14.16,73.7 13.3,72.84 13.3,72.77 11.95,71.41 11.26,71.41 10.78,71.89 10.78,74.95 10.69,75.04 10.39,75.04 CN37.7
  BOTTOM w0.102: R487.1 15.5,75.69 v1(15.51,75.68) 15.66,75.83 R697.2
C_TX0_HDMI+_R: length 3.3
  TOP w0.102: C852.2 24.86,75.68 24.75,75.58 24.52,75.58 24.37,75.73 24.37,76.87 24.16,77.08 23.96,77.08 23.82,77.22 U23.26
C_TX0_HDMI-: length 16.9
  TOP w0.102: R696.2 v1(15.51,75.02) 15.28,74.79 R713.1 15.02,74.99 14.82,75.18 13.88,75.18 13.78,75.08 D13086.2
  IN1 w0.089: v1(15.51,75.02) 15.73,75.25 16.01,75.25 16.29,74.96 16.29,74.54 15.65,73.9 14.07,73.9 13.1,72.93 13.1,72.85 11.86,71.61 11.34,71.61 10.98,71.97 10.98,75.04 10.78,75.25 10.22,75.25 10.05,75.41 CN37.9
  BOTTOM w0.102: R487.2 15.4,74.91 15.51,75.01 v1(15.51,75.02) 15.76,74.76 R696.2
C_TX0_HDMI-_R: length 3.3
  TOP w0.102: C853.2 24.86,75.27 24.76,75.36 24.43,75.36 24.15,75.64 24.15,76.78 24.07,76.86 23.9,76.86 23.76,76.72 U23.25
C_TX1_HDMI+: length 12.3
  TOP w0.102: R699.2 15.53,77.74 v1(15.51,77.71) 15.38,77.84 R710.1
  IN3 w0.089: CN37.4 11.93,73.53 12.47,73.53 12.64,73.7 15.06,73.7 16.52,75.16 16.52,77.01 16.1,77.43 15.78,77.43 v1(15.51,77.71)
  BOTTOM w0.102: R699.2 15.53,77.74 v1(15.51,77.71) 14.8,77.71 R486.1 14.56,77.48 14.02,77.48 D13083.2
C_TX1_HDMI+_R: length 2.3
  TOP w0.102: U23.28 23.78,78.22 23.92,78.08 24.1,78.08 24.67,77.5 24.78,77.5 24.86,77.58 C851.2
C_TX1_HDMI-: length 12.4
  TOP w0.102: R711.1 15.38,76.82 v1(15.51,76.95) 15.78,76.67 R698.2
  IN3 w0.089: v1(15.51,76.95) 15.51,77.14 15.59,77.23 16.02,77.23 16.32,76.93 16.32,75.25 14.97,73.9 12.56,73.9 12.39,73.73 12.07,73.73 CN37.6
  BOTTOM w0.102: D13084.2 13.78,77.1 13.94,77.27 14.47,77.27 R486.2 15.5,76.94 v1(15.51,76.95) 15.78,76.67 R698.2
C_TX1_HDMI-_R: length 2.3
  TOP w0.102: C848.2 24.86,77.2 24.78,77.28 24.58,77.28 24.01,77.86 23.89,77.86 23.75,77.72 U23.27
C_TX2_HDMI+: length 18
  TOP w0.102: D13081.2 14.45,79.56 14.84,79.56 R708.1 15.41,79.64 v1(15.51,79.74) R701.2
  IN3 w0.089: CN37.1 10.38,72.03 10.63,72.03 11.26,71.41 11.93,71.41 13.61,73.09 15.31,73.09 17.23,75.01 17.23,77.59 16.83,78 16.83,78.65 16.01,79.46 15.78,79.46 v1(15.51,79.74)
  BOTTOM w0.102: R484.1 15.5,79.75 v1(15.51,79.74) 15.66,79.89 R701.2
C_TX2_HDMI+_R: length 2.2
  TOP w0.102: C854.2 24.86,79.49 24.77,79.41 24.39,79.41 24.06,79.08 23.94,79.08 23.8,79.22 U23.30
C_TX2_HDMI-: length 17.9
  TOP w0.102: R700.2 v1(15.51,78.98) 15.41,79.08 R709.1 14.65,79.35 14.25,79.35 14.15,79.25 D13082.2
  IN3 w0.089: v1(15.51,78.98) 15.78,79.26 15.93,79.26 16.62,78.57 16.62,77.91 17.03,77.51 17.03,75.09 15.23,73.29 13.52,73.29 11.85,71.61 11.34,71.61 10.72,72.24 10.18,72.24 10.05,72.37 CN37.3
  BOTTOM w0.102: R484.2 15.5,78.97 v1(15.51,78.98) 15.66,78.83 R700.2
C_TX2_HDMI-_R: length 2.2
  TOP w0.102: C850.2 24.86,79.1 24.77,79.19 24.48,79.19 24.15,78.86 23.9,78.86 23.76,78.72 U23.29
CATERR#: length 7.7
  BOTTOM w0.076: 98.1,71.39 97.7,70.99 97.25,70.99 97.13,71.04 96.99,71.04 96.76,70.97 96.63,70.97 96.29,71.13 95.72,71.13 U2030.D63
  BOTTOM w0.102: 98.1,71.39 98.34,71.63 98.73,71.63 99.12,71.23 100.02,71.23 100.45,70.8 TP2071.1 101.67,70.54 R2479.2
CFG4: length 9.3
  BOTTOM w0.102: U2030.E70 95.66,75.66 95.97,75.35 96.94,75.35 97.11,75.52 97.51,75.52 97.52,75.5 97.57,75.5 97.78,75.7 97.78,77.37 96.83,78.32 R2449.1
CFG_RCOMP: length 12.2
  TOP w0.203: v1(104.58,71.41) 104.58,71.95 104.35,72.18 R2166.2
  IN1 w0.203: v1(104.58,71.41) 104.58,71.14 104.21,70.77 98.96,70.77 98.74,70.55 97.4,70.55 96.45,69.59 v4(95.17,69.59)
  BOTTOM w0.254: U2030.E60 94.81,69.59 v4(95.17,69.59)
CHA_SA0: length 5.2
  TOP w0.102: R2273.2 52.39,28.91 R2279.1 52.39,29.37 52.77,29.74 v2(52.77,30.01)
  BOTTOM w0.102: JDIM2000.256 52.55,30.45 52.77,30.24 v2(52.77,30.01)
CHA_SA1: length 3.9
  TOP w0.102: R2274.2 R2275.1 52.03,30.31 52.18,30.16 v2(52.18,30.01)
  BOTTOM w0.102: JDIM2000.260 51.78,29.45 52.18,29.86 v2(52.18,30.01)
CHA_SA2: length 5.4
  TOP w0.102: v2(52.28,52.46) 52.28,52.41 51.31,51.45 R2208.2 R2206.1
  BOTTOM w0.102: JDIM2000.166 51.96,52.95 52.28,52.64 v2(52.28,52.46)
CLK_24M_DEBUG: length 150.5
  IN3 w0.089: v1(97.45,14.31) 97.45,14.71 98.8,16.06 100.6,16.06 101.72,14.94 109.86,14.94 112.14,17.23 119.25,17.23 120.36,18.34 123.27,18.34 123.74,17.86 127.42,17.86 127.79,18.23 138.31,18.23 138.92,18.84 162.4,18.84 162.84,19.28 162.84,19.87 163.31,20.34 179.16,20.34 179.84,21.02 181.19,21.02 184.02,23.84 188.18,23.84 188.89,23.14 191.03,23.14 191.32,23.43 193.62,23.43 v2(194.86,22.19)
  BOTTOM w0.102: v2(194.86,22.19) 194.86,21.17 195.08,20.95 195.08,20.63 194.65,20.2 194.65,19.62 195.81,18.46 R655.1 195.8,18.23 195.28,18.23 195.18,18.33 R674.2 ; v1(97.45,14.31) 97.45,17.22 95.7,18.97 94.45,18.97 94.02,19.4 94.02,20.09 93.7,20.41 93.7,20.61 90.68,23.62 89.37,23.62 88.93,23.18 82.65,23.18 82.14,22.66 77.33,22.66 77.25,22.74 71.84,22.74 70.06,24.52 69.81,24.52 69,25.33 66.49,25.33 66.46,25.36 65.66,25.36 64.86,26.17 R2548.1
CLK_24M_DEBUG_R: length 4.8
  BOTTOM w0.102: R674.1 194.65,17.73 193.11,17.73 192.81,17.44 192.47,17.44 191.87,16.84 191.87,16.66 191.59,16.38 CN17.60
CLK_PCI_EC: length 147.4
  TOP w0.102: U37.13 181.45,23.38 R402.2 181.29,23.35 180.89,23.76 179.35,23.76 178.99,24.11 v2(178.99,24.85)
  IN3 w0.089: v2(179.23,19.85) 179.14,19.94 163.47,19.94 163.24,19.71 163.24,19.12 162.56,18.45 139.09,18.45 138.48,17.84 127.95,17.84 127.58,17.47 123.58,17.47 123.11,17.94 120.52,17.94 119.41,16.83 112.31,16.83 110.02,14.55 100.65,14.55 100.02,15.18 98.95,15.18 v1(98.08,14.31)
  BOTTOM w0.102: v2(179.23,19.85) 179.23,20.76 179.16,20.84 179.16,24.14 178.99,24.3 v2(178.99,24.85) ; R2569.1 66.75,25.74 69.18,25.74 69.99,24.93 70.23,24.93 72.01,23.15 77.42,23.15 77.5,23.07 81.95,23.07 82.46,23.58 83.88,23.58 83.98,23.68 83.98,24.62 84.09,24.73 84.29,24.73 84.39,24.62 84.39,23.68 84.49,23.58 84.7,23.58 84.8,23.68 84.8,24.62 84.9,24.73 85.1,24.73 85.2,24.62 85.2,23.68 85.31,23.58 85.51,23.58 85.61,23.68 85.61,24.62 85.71,24.73 85.91,24.73 86.02,24.62 86.02,23.68 86.12,23.58 86.32,23.58 86.42,23.68 86.42,24.62 86.52,24.73 86.73,24.73 86.83,24.62 86.83,23.68 86.93,23.58 87.13,23.58 87.24,23.68 87.24,24.62 87.34,24.73 87.54,24.73 87.64,24.62 87.64,23.68 87.74,23.58 87.95,23.58 88.05,23.68 88.05,24.62 88.15,24.73 88.35,24.73 88.45,24.62 88.45,23.68 88.56,23.58 88.76,23.58 88.86,23.68 88.86,24.62 88.96,24.73 89.17,24.73 89.42,24.47 90.41,24.47 94.21,20.66 94.21,20.47 94.81,19.87 95.37,19.87 98.08,17.16 v1(98.08,14.31)
CLK_PCI_EC_R: length 21.7
  BOTTOM w0.102: U2030.AW9 76.7,39.9 76.38,39.58 76.38,39.32 76.19,39.14 75.9,39.14 75.87,39.11 74.73,39.11 72.93,37.31 72.93,34.4 72.3,33.77 70.29,33.77 70.04,33.51 70.04,32.24 70.06,32.22 70.06,32.07 67.91,29.91 v1(67.91,28.13) 67.3,27.52 66.58,27.52 66.06,27 C2592.2 65.84,26.65 R2569.2
CLK_PCI_LPC_R: length 20.1
  BOTTOM w0.102: U2030.AY9 75.84,40.58 75.51,40.26 74.27,40.26 71.84,37.83 71.84,36.46 71.32,35.94 71.32,35.28 71.13,35.09 71.13,34.1 71,33.97 70.17,33.97 69.84,33.64 69.84,32.13 67.43,29.73 v1(67.43,29.54) 67.43,28.57 67.08,28.22 C2590.2 66.36,27.76 65.57,27.76 R2548.2
CLK_PCIE_LANN: length 102.1
  TOP w0.102: U24.16 45.53,102.76 45.45,102.68 45.45,102.58 45.78,102.25 45.78,100.95 47.24,99.49 47.98,99.49 48.63,98.84 50.38,98.84 50.9,98.32 50.9,97.32 v1(51.23,96.99)
  IN3 w0.089: v4(98.22,60.72) 98.44,60.93 98.44,61.18 98.35,61.27 97.78,61.27 97.57,61.48 97.57,62.76 97.45,62.88 97.16,62.88 97.07,62.79 97.07,61.48 96.86,61.27 94.78,61.27 94.62,61.11 93.82,61.11 93.81,61.12 92.64,61.12 92.42,61.34 92.42,62.45 92.62,62.66 93.34,62.66 93.43,62.74 93.43,63.06 93.34,63.15 92.88,63.15 92.67,63.36 92.67,64.74 92.58,64.83 92.22,64.83 92.01,65.04 92.01,65.53 92.22,65.73 92.84,65.73 92.92,65.82 92.92,66.11 92.81,66.23 92.22,66.23 92.01,66.44 92.01,66.92 92.22,67.13 92.81,67.13 92.9,67.22 92.9,67.49 92.76,67.63 92.22,67.63 92.01,67.83 92.01,68.32 92.22,68.53 92.81,68.53 92.95,68.67 92.95,68.95 92.85,69.05 92.29,69.05 92.09,69.26 92.09,70.24 91.43,70.9 91.43,72.11 90.92,72.62 90.92,74.24 91.25,74.57 91.25,81.45 90.74,81.96 90.74,82.51 88.87,84.38 88.87,85.86 87.06,87.67 86.52,87.67 85.14,89.04 84.86,89.04 84.36,89.55 83.79,89.55 82.08,91.25 82.08,91.6 78.93,94.75 77.43,94.75 75.06,97.12 73.18,97.12 72.85,97.45 70.39,97.45 68.53,99.3 66.13,99.3 64.34,101.09 56.41,101.09 53.02,97.7 51.1,97.7 50.89,97.49 50.89,97.33 v1(51.23,96.99)
  BOTTOM w0.102: U2030.B40 96.93,59.03 97.2,59.31 97.53,59.31 97.62,59.22 98.01,59.22 98.46,59.67 98.46,60.66 98.4,60.72 v4(98.22,60.72)
CLK_PCIE_LANP: length 102.1
  TOP w0.102: v1(50.47,96.99) 50.68,97.21 50.68,98.23 50.29,98.63 48.54,98.63 47.89,99.27 47.15,99.27 45.57,100.86 45.57,102.16 45.24,102.49 45.24,102.61 45.13,102.72 U24.15
  IN3 w0.089: v1(98.87,60.72) 98.64,60.95 98.64,61.26 98.43,61.47 97.86,61.47 97.77,61.56 97.77,62.85 97.54,63.08 97.08,63.08 96.87,62.87 96.87,61.56 96.78,61.47 94.7,61.47 94.53,61.31 93.91,61.31 93.89,61.32 92.72,61.32 92.62,61.43 92.62,62.36 92.71,62.45 93.43,62.45 93.64,62.66 93.64,63.15 93.43,63.35 92.96,63.35 92.87,63.44 92.87,64.83 92.67,65.03 92.3,65.03 92.21,65.12 92.21,65.44 92.3,65.53 92.92,65.53 93.13,65.74 93.13,66.2 92.89,66.43 92.3,66.43 92.21,66.52 92.21,66.84 92.3,66.93 92.89,66.93 93.1,67.13 93.1,67.57 92.84,67.83 92.3,67.83 92.21,67.92 92.21,68.24 92.3,68.32 92.89,68.32 93.15,68.58 93.15,69.03 92.93,69.25 92.38,69.25 92.29,69.34 92.29,70.33 91.63,70.99 91.63,72.2 91.12,72.71 91.12,74.15 91.45,74.48 91.45,81.53 90.94,82.04 90.94,82.59 89.07,84.46 89.07,85.94 87.15,87.87 86.61,87.87 85.23,89.25 84.94,89.25 84.44,89.75 83.87,89.75 82.28,91.34 82.28,91.69 79.02,94.95 77.51,94.95 75.14,97.32 73.26,97.32 72.93,97.65 70.47,97.65 68.62,99.5 66.21,99.5 64.42,101.29 56.33,101.29 52.94,97.9 51.01,97.9 50.68,97.57 50.68,97.21 v1(50.47,96.99)
  BOTTOM w0.102: v1(98.87,60.72) 98.66,60.51 98.66,59.59 98.1,59.02 97.39,59.02 U2030.A40
CLK_PCIE_REQ0#: length 20.6
  TOP w0.079: v4(78.76,40.63) 79.18,40.21 79.18,39.61 78.7,39.13 77.1,39.13 76.98,39.24
  TOP w0.102: 76.98,39.24 76.33,39.24 75.92,38.84 73.86,38.84 71.99,36.97 67.83,36.97 66.36,35.5 66.36,35.48 R2278.2 65.69,35.04 65.54,35.19 63.33,35.19 R226.2
  BOTTOM w0.102: v4(78.76,40.63) 79.16,41.03 U2030.AR10
CLK_PCIE_REQ1#: length 17.9
  TOP w0.102: R2285.2 64.04,35.52 64.14,35.42 65.47,35.42 65.57,35.52 R2281.2 66.36,35.83 67.73,37.2 71.9,37.2 73.77,39.07 75.9,39.07 76.32,39.49 77.19,39.49 77.37,39.31 78.29,39.31 78.76,39.77 v4(78.8,39.77)
  BOTTOM w0.102: U2030.AT7 78.8,39.54 v4(78.8,39.77)
CLK_PCIE_REQ2#: length 15.2
  TOP w0.102: R2612.2 66.16,36.62 TP2088.1 66.74,36.82 67.58,37.65 71.71,37.65 73.58,39.52 75.72,39.52 76.13,39.94 76.42,39.94 76.59,40.11 77.75,40.11 v4(78.15,39.72)
  BOTTOM w0.102: v4(78.15,39.72) 78.15,39.81 U2030.AT8
CLK_PCIE_REQ3#: length 19
  TOP w0.079: v4(78.14,40.62) 78.06,40.54 76.66,40.54 76.29,40.17 76.08,40.17 75.66,39.75 75.25,39.75
  TOP w0.102: R2615.2 61.94,37.55 TP2089.1 62.52,37.35 63.96,37.35 64.12,37.5 64.73,37.5 64.83,37.4 67.04,37.4 67.52,37.88 71.61,37.88 73.48,39.75 75.25,39.75
  BOTTOM w0.102: v4(78.14,40.62) 78.14,40.72 U2030.AT10
CLK_PCIE_REQ4#: length 16.7
  TOP w0.079: v4(77.52,39.72) 76.31,39.72 75.89,39.3 75.25,39.3
  TOP w0.102: R2305.2 63.38,36.56 63.44,36.62 R2301.2 64.47,36.62 64.81,36.28 66.5,36.28 67.64,37.43 71.8,37.43 73.67,39.3 75.25,39.3
  BOTTOM w0.102: U2030.AU8 77.52,39.83 v4(77.52,39.72)
CLK_PCIE_REQ5#: length 17.5
  TOP w0.079: 75.25,38.61 76.2,38.61 76.34,38.47 77.28,38.47 v4(77.51,38.7)
  TOP w0.102: 75.25,38.61 73.96,38.61 72.09,36.74 68.13,36.74 65.69,34.3 64.22,34.3 64.07,34.45 63.79,34.45 63.57,34.68 R2286.2 R2307.2
  BOTTOM w0.102: v4(77.51,38.7) 77.51,38.77 77.86,39.13 U2030.AU7
CLK_PCIE_SSDN: length 135.8
  IN3 w0.089: v1(27.7,12.45) 27.46,12.45 27.37,12.36 27.37,9.54 26.91,9.08 26.91,6.95 26.66,6.7 26.66,4.48 27.19,3.95 29.22,3.95 30.39,2.78 36.41,2.78 37.76,4.13 38.47,4.13 39.2,4.86 39.2,6.04 42.93,9.77 44.76,9.77 47.41,12.42 47.41,12.91 48.25,13.75 49.13,13.75 49.8,14.41 78.34,14.41 83.6,19.67 83.91,19.67 84.57,20.33 89.6,20.33 94.58,25.31 95.1,25.31 95.51,25.72 99.07,25.72 100.65,27.29 100.65,27.9 100.53,28.02 100.53,28.4 100.29,28.64 100.29,29.51 100.54,29.76 100.54,30.58 103.74,33.78 103.74,34.65 102.5,35.89 102.5,39.14 104.38,41.02 104.38,48.79 101.9,51.27 101.15,51.27 99.33,53.09 99.33,58.17 98.64,58.85 97.72,58.85 97.4,59.17 97.4,59.5 v4(97.18,59.71)
  BOTTOM w0.102: U2030.B42 96.72,59.82 96.83,59.71 v4(97.18,59.71) ; v1(27.7,12.45) 27.48,12.45 27.38,12.35 27.38,11.76 27.55,11.59 R2658.1
CLK_PCIE_SSDN_C: length 2.4
  BOTTOM w0.102: R2658.2 27.5,11.14 27.42,11.06 27.42,10.78 27.24,10.6 26.78,10.6 26.73,10.55 26.73,10.46 26.85,10.33 CN16.53
CLK_PCIE_SSDP: length 135.8
  IN3 w0.089: v1(26.94,12.45) 27.16,12.23 27.16,9.62 26.71,9.16 26.71,7.03 26.46,6.78 26.46,4.39 27.1,3.75 29.14,3.75 30.31,2.58 36.49,2.58 37.84,3.92 38.55,3.92 39.41,4.78 39.41,5.96 43.01,9.56 44.84,9.56 47.61,12.33 47.61,12.83 48.33,13.55 49.22,13.55 49.88,14.21 78.43,14.21 83.69,19.47 83.99,19.47 84.65,20.13 89.69,20.13 94.66,25.11 95.18,25.11 95.59,25.51 99.15,25.51 100.85,27.21 100.85,27.98 100.73,28.1 100.73,28.49 100.49,28.72 100.49,29.42 100.75,29.68 100.75,30.49 103.95,33.69 103.95,34.73 102.7,35.98 102.7,39.06 104.58,40.94 104.58,48.87 101.98,51.47 101.23,51.47 99.53,53.17 99.53,58.25 98.72,59.06 97.8,59.06 97.6,59.26 97.6,59.5 97.81,59.71 v4(97.81,59.72)
  BOTTOM w0.102: U2030.A42 97.38,60.16 v4(97.81,59.72) ; R2659.1 27.16,11.82 27.16,12.23 v1(26.94,12.45)
CLK_PCIE_SSDP_C: length 2.4
  BOTTOM w0.102: R2659.2 27.15,11.14 27.2,11.09 27.2,10.87 27.15,10.82 26.69,10.82 26.51,10.63 26.51,10.58 26.35,10.42 CN16.55
CLK_PCIE_WLANN: length 116
  IN1 w0.089: v1(179.17,31.35) 179.39,31.13 179.39,31 179.28,30.9 177.75,30.9 177.09,30.24 172.71,30.24 172.5,30.44 169.01,30.44 167.86,31.58 165.91,31.58 164.76,32.73 163.23,32.73 163.05,32.9 156.68,32.9 156.15,32.38 148.16,32.38 147.18,33.36 145.38,33.36 144.94,33.79 144.94,34.28 142.42,36.8 131.87,36.8 127.52,41.16 125.19,41.16 123.56,42.79 120.43,42.79 119.59,43.63 117.1,43.63 116.21,44.52 113.79,44.52 113.19,44.52 109.3,48.41 108.59,49.12 107.58,49.12 106.5,50.2 105.85,50.2 103.97,52.08 101.87,52.08 99.07,54.88 98.11,54.88 97.04,55.94 97.04,57.85 96.1,58.79 95.46,58.79 95.24,58.56 94.66,58.56 v4(94.33,58.89)
  BOTTOM w0.102: v1(179.17,31.35) 179.38,31.14 179.38,29.22 180.47,28.14 180.47,27.19 179.82,26.54 179.82,25.16 179.98,24.99 179.98,24.56 179.59,24.17 179.59,21.04 180.92,19.71 181.58,19.71 182.02,19.27 182.38,19.27 182.52,19.13 CN17.49 ; U2030.E40 94.33,58.78 v4(94.33,58.89)
CLK_PCIE_WLANP: length 116.1
  IN1 w0.089: v1(179.8,31.35) 179.59,31.13 179.59,30.92 179.37,30.69 177.84,30.69 177.18,30.03 172.62,30.03 172.42,30.24 168.92,30.24 167.78,31.38 165.82,31.38 164.68,32.52 163.14,32.52 162.97,32.7 156.76,32.7 156.23,32.17 148.08,32.17 147.09,33.16 145.29,33.16 144.74,33.71 144.74,34.19 142.33,36.6 131.79,36.6 127.43,40.96 125.11,40.96 123.47,42.59 120.34,42.59 119.51,43.42 117.02,43.42 116.12,44.32 113.87,44.32 113.87,44.32 113.11,44.32 109.1,48.33 108.51,48.92 107.49,48.92 106.41,50 105.77,50 103.89,51.88 101.78,51.88 98.99,54.67 98.02,54.67 96.84,55.86 96.84,57.76 96.02,58.58 95.55,58.58 95.32,58.36 94.62,58.36 v4(94.31,58.04)
  BOTTOM w0.102: CN17.47 182.49,19.63 182.35,19.49 182.11,19.49 181.67,19.93 181.01,19.93 179.81,21.13 179.81,24.08 180.2,24.47 180.2,25.08 180.03,25.25 180.03,26.45 180.68,27.1 180.68,28.22 179.59,29.31 179.59,31.14 v1(179.8,31.35)
  BOTTOM w0.114: U2030.E38 94.65,57.7 v4(94.31,58.04)
CLK_PCIE_XDPN: length 1.3
  TOP w0.102: TP2025.1 94.08,60.73 v4(93.6,60.73)
  BOTTOM w0.102: v4(93.6,60.73) 94,60.33 U2030.F43
CLK_PCIE_XDPP: length 2.2
  TOP w0.102: v4(94.3,59.9) 94.18,59.9 93.81,60.26 93.21,60.26 TP2026.1
  BOTTOM w0.102: v4(94.3,59.9) 94.3,59.96 94.63,60.29 U2030.E43
CLK_VGA_N: length 59.5
  IN1 w0.089: v4(94.88,60.73) 95.09,60.53 95.09,60.34 94.97,60.22 94.83,60.22 94.42,60.63 94.42,60.88 93.98,61.32 93.38,61.32 93.19,61.51 93.19,67.63 92.78,68.05 92.78,70.19 93.19,70.6 93.19,70.95 93.84,71.6 93.84,72.8 94.12,73.08 94.12,77.02 93.43,77.71 93.43,82.31 94.11,82.98 94.11,87.36 96.33,89.59 96.33,90.64 96.68,90.99 96.68,93.6 96.86,93.78 96.86,94.6 96.68,94.78 96.68,96.89 97.78,97.98 97.78,100.48 98.52,101.21 98.52,101.3 98.68,101.46 98.68,110.79 99.13,111.24 99.13,111.84 99.37,112.07 99.57,112.07 99.67,111.97 v2(99.67,111.64)
  BOTTOM w0.102: v4(94.88,60.73) 94.88,60.7 U2030.D42 ; U8.AD8 99.74,112.03 99.67,111.97 v2(99.67,111.64)
CLK_VGA_P: length 59.6
  IN1 w0.089: v4(95.08,59.74) 94.81,60.02 94.74,60.02 94.22,60.54 94.22,60.8 93.9,61.12 93.29,61.12 92.99,61.42 92.99,67.55 92.58,67.96 92.58,70.28 92.99,70.69 92.99,71.04 93.64,71.68 93.64,72.88 93.91,73.16 93.91,76.94 93.23,77.63 93.23,82.39 93.9,83.06 93.9,87.44 96.13,89.67 96.13,90.73 96.48,91.08 96.48,93.69 96.66,93.86 96.66,94.52 96.48,94.69 96.48,96.97 97.57,98.06 97.57,100.56 98.31,101.3 98.31,101.38 98.47,101.55 98.47,110.87 98.93,111.33 98.93,111.92 99.29,112.28 99.52,112.28 v2(99.68,112.43)
  BOTTOM w0.102: v4(95.08,59.74) 95.44,59.74 95.63,59.94 95.85,59.94 U2030.C42 ; U8.AE8 99.68,112.44 v2(99.68,112.43)
CLKRUN#: length 171.7
  TOP w0.102: U37.93 198.14,26.98 197.68,26.53 197.68,25.83 197.28,25.44 196.53,25.44 196.07,24.98 196.07,23.51 196.2,23.38 196.2,21.09 196.43,20.87 v2(197,20.87)
  IN1 w0.079: 75.89,32.31 74.94,33.26
  IN1 w0.089: v2(197,20.87) 196.41,20.87 196.21,21.07 196.21,21.41 195.48,22.14 195.48,22.45 195.17,22.76 194.45,22.76 193.99,23.23 193.35,23.23 192.66,23.93 192.66,24.12 192.5,24.28 191.95,24.28 189.8,22.13 189.8,19.67 189.28,19.15 188.94,19.15 188.14,19.95 187.69,19.95 187.35,20.29 185.08,20.29 184.69,20.69 182.95,20.69 181.08,22.57 177.68,22.57 176.9,21.79 167.32,21.79 167.02,22.09 164.67,22.09 163.11,23.65 161.86,23.65 160.99,22.77 158.75,22.77 158.07,22.09 154.43,22.09 153.8,22.73 147.07,22.73 146.44,22.09 137.19,22.09 136.67,21.58 134.16,21.58 133.75,21.99 126.61,21.99 126.02,22.57 123.07,22.57 122.33,23.31 121.72,23.31 121.28,22.87 120.64,22.87 120.19,22.41 114.74,22.41 114.57,22.59 111.38,22.59 111.2,22.4 105.37,22.4 104.69,23.09 103.09,23.09 101.74,24.44 100.58,24.44 99.34,25.67 94.82,25.67 92.11,28.38 87.82,28.38 87.72,28.48 85.51,28.48 84.58,27.56 83.21,27.56 80.58,30.19 79.77,30.19 79.06,30.9 79.06,31.46 78.52,31.99 76.21,31.99 75.89,32.31 ; v1(69.3,36.08) 72.12,36.08 74.94,33.26
  BOTTOM w0.076: U2030.AW11 76.58,41.86 76.3,42.14 75.48,42.14 75.38,42.24 74.47,42.24 74.27,42.04 73.9,42.04
  BOTTOM w0.102: v1(69.3,36.08) 69.3,35.69 68.55,34.94 67.78,34.94 67.54,34.7 R2536.2 67.72,35.22 68.46,35.22 68.71,35.47 68.71,36.18 69.45,36.92 v1(69.68,36.92) 70.06,37.3 70.06,40.04 72.06,42.04 73.9,42.04
CLR_CMOS: length 176.3
  TOP w0.102: v1(173.86,26.53) 173.86,26.44 174.51,25.8 174.51,24.79 175,24.3 175,22.02 176.59,20.43 181.19,20.43 181.47,20.71 182.18,20.71 182.45,20.98 U37.19 ; v2(54.61,27.03) 56.75,29.17 56.75,29.37 57.29,29.91 57.29,32.45 57.9,33.06 57.9,42.53 61.68,46.32 61.94,46.32 Q2014.2 62.78,47.15 R2203.1 62.78,49.11 Q2013.2
  IN2 w0.089: v1(173.86,26.53) 173.34,26.53 172.57,27.3 170.19,27.3 169.77,27.72 166.72,27.72 165.48,26.48 160.4,26.48 160.07,26.15 158.24,26.15 157.78,25.69 157.78,24.48 156.91,23.61 155.39,23.61 155.28,23.5 154.09,23.5 153.89,23.3 151.56,23.3 151.34,23.07 149.65,23.07 149.02,23.7 145.43,23.7 144.58,22.84 132.41,22.84 131,24.26 127.84,24.26 127.27,23.69 121.8,23.69 120.1,21.99 108.62,21.99 105.78,24.83 104.55,24.83 102.92,26.46 101.31,26.46 100.66,27.1 99.94,27.1 99.62,27.41 99.62,27.92 99.4,28.14 99.37,28.14 98.98,28.52 98.98,28.74 98.88,28.83 96.54,28.83 96.25,28.55 96.25,27.83 95.85,27.43 92.94,27.43 92.75,27.62 87.36,27.62 86.7,26.95 81.74,26.95 81.34,26.55 76.85,26.55 76.11,27.29 76.11,28.41 75.94,28.58 75.94,28.78 73.52,31.2 70.62,31.2 70.09,30.67 69.69,30.4 69.65,30.36 69.65,30.36 69.63,30.34 69.61,30.34 65.42,26.15 63.66,26.15 63.38,26.43 54.9,26.43 54.61,26.72 v2(54.61,27.03)
CNV_BRI_DT: length 6.3
  BOTTOM w0.102: R664.2 196.35,23.2 195.96,22.81 194.41,22.81 194.37,22.85 193.66,22.85 193.41,22.59 192.47,22.59 192.26,22.38 CN17.36
CNV_BRI_RSP_L: length 1.9
  BOTTOM w0.102: CN17.22 191.94,25.88 192.15,25.67 R665.1
CNV_RF_RESET#: length 3.1
  TOP w0.102: R677.1 158.37,21.1 158.3,21.17 U35.2 157.06,21.17 156.91,21.02 156.91,20.66 157.05,20.52 U35.1
CNV_RF_RESET#_L: length 57.3
  TOP w0.102: v1(149.09,26.41) 149.09,25.4 149.88,24.62 151.06,24.62 151.39,24.29 151.39,22.73 151.75,22.36 152.95,22.36 153.33,21.98 153.55,21.98 153.78,21.75 153.78,21.69 R676.1 154.38,21.36 154.84,21.82 U35.4
  IN2 w0.089: v1(149.09,26.41) 149.65,26.41 151.47,28.22 156.09,28.22 157.21,29.35 157.21,30.44 157.64,30.87 162.02,30.87 162.24,30.64 162.24,30.49 163.4,29.33 165.37,29.33 165.86,29.82 167.83,29.82 168.01,30 171.92,30 172.53,29.39 176.47,29.39 176.87,28.99 179.89,28.99 180.85,28.03 182.45,28.03 182.71,28.28 184.34,28.28 185.02,28.96 187.03,28.96 v2(187.7,28.28)
  BOTTOM w0.102: CN17.10 189.52,28.88 189.29,29.11 188.53,29.11 v2(187.7,28.28)
CNV_RGI_DT: length 4.2
  BOTTOM w0.102: R180.2 193.57,24.55 R183.1 192.98,24.27 192.01,24.27 191.5,23.76 191.5,23.48 191.4,23.38 CN17.32
CNV_RGI_RSP_L: length 2.9
  BOTTOM w0.102: CN17.34 191.6,22.88 191.73,23 191.73,23.2 191.96,23.43 193.14,23.43 R667.1
CODEC_VREF: length 3.6
  BOTTOM w0.203: C563.2 204.12,38.43 203.09,37.4 203.09,36.9 203.66,36.33 U20.28
COMP_CORE: length 4.8
  BOTTOM w0.203: PU7000.4 139.75,50.33 139.93,50.15 139.93,50.11 140.33,49.71 141.15,49.71 141.46,49.39 141.81,49.39 141.93,49.27 PR7048.2 PC7011.1
COMP_GT: length 7.5
  BOTTOM w0.203: PU7000.26 136.95,58.11 136.74,58.31 136.4,58.31 135.59,57.49 v1(135.15,57.49) 134.33,58.32 134.33,59.28 134.08,59.52 133.5,59.52 PR7055.2 133.01,59.03 PC7017.1
COMP_SA: length 3.4
  BOTTOM w0.203: PU7000.43 142.5,54.27 142.75,54.02 143.06,54.02 PR7060.2 144.49,54.76 PC7021.1
CON_DE: length 3.5
  BOTTOM w0.102: R25278.1 R25275.2 17.05,24.64 v1(17.05,24.31) 17.38,24.31 17.9,23.79 U6502.15
CON_EQ: length 4.1
  BOTTOM w0.102: U6502.18 19.1,24.5 R25272.2 20.21,25.61 R25274.1 20.55,25.89 20.11,26.33 v1(20.11,26.57)
CPU_C10_GATE#_R: length 50.5
  TOP w0.102: PR9272.2 123.12,48.84 123.12,45.93 121.31,44.12 v1(120.93,44.12) ; v1(105.57,41.36) 105.2,41.36 PR2060.1 105.06,41.04 105.45,40.65 106.03,40.65 106.22,40.84 PQ35.4
  IN2 w0.089: v1(120.93,44.12) 116.76,44.12 116.19,43.55 116.19,42.35 117.07,41.47 118.68,41.47 119.22,40.93 119.22,40.5 119.65,40.07 119.65,34.08 119.34,33.77 110.58,33.77 108.37,31.56 106.36,31.56 106.08,31.84 106.08,32.17 105.78,32.48 105.78,34.02 106.72,34.96 106.72,40.22 v1(105.57,41.36)
CPU_DRAMRST#: length 20.4
  TOP w0.079: 75.25,41.79 75.44,41.79 76.49,42.84 77.89,42.84 v4(78.19,42.54)
  TOP w0.102: v2(71.23,40.34) 71.41,40.34 72.86,41.79 75.25,41.79
  BOTTOM w0.102: v4(78.19,42.54) 78.19,42.59 U2030.AT13 ; R2528.1 66.71,31.09 R2526.2 67.41,31.79 67.6,31.79 68.03,32.22 68.18,32.22 68.29,32.32 68.29,32.6 68.57,32.88 68.57,33.67 68.72,33.82 68.72,34.32 69.99,35.59 69.99,36.06 70.65,36.72 70.65,38.87 v1(70.82,39.04) 70.82,39.92 v2(71.23,40.34)
CPU_THRMTRIP#: length 8.6
  BOTTOM w0.076: U2030.C63 96.17,71.33 96.26,71.33 96.66,71.14 96.74,71.14 96.97,71.2 97.16,71.2 97.28,71.16 97.57,71.16 97.88,71.47
  BOTTOM w0.102: 97.88,71.47 98.24,71.83 98.86,71.83 99.22,71.46 100.14,71.46 100.39,71.21 101.31,71.21 101.76,71.67 R2476.2 102.19,72.27 102.68,72.76 R2475.2
CRT_CLK: length 15.7
  TOP w0.102: v4(89.83,38.8) 89.83,38.05 90.49,37.38 90.49,36.5 92.15,34.85 93.11,34.85 93.58,34.37 94.26,34.37 96.08,32.56 99.64,32.56 100.16,32.03 100.16,31.68 R2590.1
  BOTTOM w0.102: v4(89.83,38.8) 89.94,38.8 90.21,39.06 U2030.N7
CRT_DATA: length 17.8
  TOP w0.079: 91.11,36.14 90.66,36.59 90.66,37.45 90.21,37.9 90.21,39.72 v4(89.9,40.03)
  TOP w0.102: R2589.1 100.34,31.12 100.34,32.11 99.71,32.74 96.16,32.74 94.34,34.55 93.66,34.55 92.85,35.36 v1(92.33,35.36) 91.89,35.36 91.11,36.14
  BOTTOM w0.102: v4(89.9,40.03) 90.21,39.72 U2030.N8
CRT_HPD: length 7.8
  TOP w0.079: 91.86,36.51 91.37,36.99 91.37,38.37 90.94,38.8 v4(90.94,38.88)
  TOP w0.102: R2559.1 95.5,35.28 93.96,35.28 92.72,36.51 91.86,36.51
  BOTTOM w0.102: U2030.L7 91.23,38.9 90.96,38.9 90.94,38.88 v4(90.94,38.88)
CTL2: length 2
  TOP w0.102: U14.7 23.04,48.88 R418.2
CTL3: length 1.8
  TOP w0.102: U14.8 23.54,49.38 R417.2
D/C#: length 3.3
  TOP w0.102: PC20.2 137,33.31 137.6,33.31 138.04,32.88 v1(138.06,32.88)
  BOTTOM w0.198: v1(138.06,32.88) 138.06,32.79 137.84,32.57 137.84,32.3 PR26.1 137.48,32.29 TP9001.1
DC-DET: length 2.3
  TOP w0.102: v2(205.67,28.56) 205.42,28.82 R25495.1
  BOTTOM w0.102: R732.1 205.65,28.54 v2(205.67,28.56) 205.67,28.89 205.66,28.91 U20.4
DCPRTC: length 17.9
  TOP w0.254: v1(70.72,34.45) 70.72,34.68 70.47,34.94 69.07,34.94 64.72,30.58 v1(64.72,30.4) 64.72,29.95 64.81,29.86 C2598.1
  BOTTOM w0.254: v1(70.72,34.45) 70.72,35.19 70.88,35.34 70.88,35.98 71.51,36.61 71.51,37.9 74.86,41.25 U2030.BB10
DDCCLK_RIN: length 5.9
  TOP w0.102: Q41.4 24.3,64.36 24.42,64.48 25.91,64.48 26.01,64.38 26.01,61.74 R775.2
DDCDATA_RIN: length 6.2
  TOP w0.102: R777.2 26.42,61.13 26.42,64.54 25.6,65.36 Q41.1
DDR4_SUSON_2V5: length 356.9
  TOP w0.102: v2(190.17,23.99) 189.37,24.79 189.37,26.47 188.17,27.66 188.17,28.51 187.86,28.83 187.53,28.83 187.25,29.11 U37.122
  IN1 w0.089: v1(17.38,60.66) 17.38,61.48 22.58,66.68 22.58,69.93 19.79,72.72 19.34,72.72 18.87,73.2 14.4,73.2 13.78,72.58 v1(13.78,72.58) ; v1(66.99,125.56) 66.99,123.01 69.57,120.43 70.22,120.43 71.25,119.4 71.25,116.77 70.31,115.82 68.92,115.82 65.2,112.1 63.9,112.1 63.04,111.24 58.81,111.24 58.5,111.55 55.86,111.55 55.57,111.26 55.26,111.26 54.4,110.4 53.32,110.4 52.47,109.55 51.19,109.55 48.28,106.65 46.07,106.65 45.4,107.33 43.22,107.33 41.17,105.28 40.45,105.28 38.65,103.48 26.45,103.48 25.83,102.85 23.95,102.85 22.98,101.88 21.42,101.88 19.28,99.74 19.28,95.1 18.42,94.24 17.16,94.24 16.76,93.84 16.76,89.45 16.27,88.96 v1(15.73,88.96)
  IN2 w0.089: v1(13.78,72.58) 12.43,73.93 12.43,77.23 14.59,79.39 14.59,83.2 14.8,83.41 14.8,88.03 v1(15.73,88.96) ; v2(190.17,23.99) 189.94,23.75 185.02,23.75 184.75,24.03 177.88,24.03 177.67,24.24 170.8,24.24 170.62,24.41 164.18,24.41 163.95,24.18 161.65,24.18 160.82,23.34 158.83,23.34 157.57,22.08 156.09,22.08 155.31,21.3 153.75,21.3 153.46,21.02 149.19,21.02 148.25,21.96 146.26,21.96 142.46,18.15 124.73,18.15 124.29,18.6 119.72,18.6 118.86,19.46 103.92,19.46 101.01,22.38 101.01,22.85 100.7,23.15 100.35,23.15 98.64,24.87 93.98,24.87 93.78,25.06 91.84,25.06 91.72,25.18 82.39,25.18 81,23.79 78.19,23.79 77.43,24.55 75.75,24.55 74.54,23.33 64.35,23.33 64.35,23.33 64.3,23.33 62.57,21.6 54.16,21.6 52.21,23.56 49.62,23.56 48.19,24.98 44.05,24.98 43.52,24.45 42.45,24.45 41.82,25.08 35.04,25.08 34.15,25.97 34.15,26.19 33.84,26.49 30.03,26.49 29.29,27.23 28.79,27.23 28.51,26.95 28.51,26.61 27.87,25.97 26.3,25.97 25.64,26.63 22.97,26.63 21.98,25.64 19.52,25.64 18.68,26.48 18.68,28.34 18.25,28.77 18.25,37.23 17.54,37.93 17.54,43.39 16.43,44.51 16.43,45.35 15.65,46.12 15.65,48.35 15.12,48.88 15.12,50.05 15.56,50.48 15.56,52.64 16.27,53.36 16.27,55.1 15.63,55.74 15.63,58.76 17.38,60.51 v1(17.38,60.66)
  BOTTOM w0.102: v1(66.99,125.56) 66.33,124.9 66.33,123.81 PR9273.2
DDR_DRAMRST#: length 153.8
  TOP w0.102: U2009.P1 35.87,93.12 v2(35.8,93.19) ; v2(34.66,78.9) 34.67,78.91 35.52,78.91 35.87,79.27 U2010.P1 ; C2180.2 52.87,70.95 v2(52.87,70.96) ; U2011.P1 35.83,57.89 v2(35.44,57.5) ; U2012.P1 v2(35.47,44.28)
  IN1 w0.089: v2(38.84,32.56) 38.84,34.66 38.4,35.1 37.98,35.1 37.35,35.74 37.35,36.62 36.23,37.73 36.23,38.11 35.03,39.31 35.03,43.84 35.38,44.19 v2(35.47,44.28) 35.06,44.69 35.06,45.77 35.41,46.12 35.41,47.22 35.56,47.37 35.56,48.51 34.97,49.09 34.97,52.38 35.04,52.45 35.04,57.1 v2(35.44,57.5) 35.87,57.93 35.87,58.77 35.48,59.15 35.48,65.06 35.13,65.41 35.13,69.37 34.38,70.12 34.38,76.4 34.69,76.71 34.69,78.87 v2(34.66,78.9) 34.33,79.23 34.33,81.62 34.48,81.76 34.48,85.07 34.85,85.45 34.85,86.7 34.67,86.88 34.67,88.15 35.5,88.97 35.5,90.38 36.19,91.07 36.19,93.02 36.02,93.19 v2(35.8,93.19)
  BOTTOM w0.102: JDIM2000.108 51.8,69.46 52.87,70.52 v2(52.87,70.96) 53.61,71.7 53.61,74 54.11,74.51 54.11,85.48 54.9,86.27 54.9,89.96 53.41,91.45 53.41,93.5 53.2,93.71 53.2,96.07 52.88,96.39 49.45,96.39 49.13,96.07 49.13,95.85 49.01,95.72 46.29,95.72 44.94,94.37 37.83,94.37 36.65,93.19 v2(35.8,93.19) ; v2(38.84,32.56) 39.3,32.1 45.38,32.1 46.67,30.81 46.67,29.75 46.7,29.73 46.7,28.51 48.35,26.86 51.34,26.86 52.46,25.74 55.76,25.74 56.3,26.28 62.92,26.28 v1(63.22,26.58) 63.22,27.05 65.42,29.25 C2588.1 R2532.2 R2528.2
DDR_VTT_CTRL: length 15.2
  BOTTOM w0.076: U2030.AW67 76.79,74.12 76.79,74.82 76.68,74.93 76.45,74.93 76.4,74.97 76.4,74.97 76.23,75.15 76.23,75.39 76.35,75.51 76.35,75.82 76.16,76.01 75.66,76.01 75.55,76.12 75.55,76.44 75.37,76.62 75.37,76.75 74.99,77.13
  BOTTOM w0.254: R2450.2 68.85,83.32 68.66,83.13 Q2023.1
  BOTTOM w0.508: Q2023.1 69.48,81.65 69.48,80.22 v1(69.81,79.89) 72.83,79.89 74.99,77.74 74.99,77.13
DDR_VTTT_PG_CTRL_R: length 2.1
  BOTTOM w0.203: Q2023.3 71.31,81.82 TP2093.1 71.36,81.52 70.98,81.14 R2448.1
DE1: length 3.2
  TOP w0.102: U42.9 208.06,15.87 207.46,15.27 R1235.1 207.07,14.56 207.07,13.96 R503.2
DE2: length 4.3
  TOP w0.102: U42.8 207.87,16.37 R504.1 207.03,16.38 206.42,16.38 205.43,15.39 R505.2
DEVSLP0: length 146.3
  IN2 w0.089: v1(95.9,24.04) 96.18,23.76 99.47,23.76 100.21,23.02 100.21,22.32 101.31,21.22 101.58,21.22 103.72,19.08 118.7,19.08 119.57,18.22 124.08,18.22 124.53,17.77 142.62,17.77 145.48,20.64 153.62,20.64 153.91,20.92 155.47,20.92 156.23,21.68 157.71,21.68 158.99,22.96 161.03,22.96 161.87,23.8 164.1,23.8 164.34,24.03 170.47,24.03 170.75,23.75 174.22,23.75 174.91,23.06 175.86,23.06 176.37,23.56 180.02,23.56 180.11,23.65 184.59,23.65 184.87,23.37 189.09,23.37 193.57,18.9 195.33,18.9 196.79,17.43 197.67,17.43 199.6,15.5 199.6,13.19 200.53,12.27 201.83,12.27 202.5,12.94 204.41,12.94 204.74,13.27 205.42,13.27 v2(205.52,13.17)
  BOTTOM w0.102: R25484.2 209.75,14.21 209.47,14.49 208.77,14.49 207.37,13.09 205.6,13.09 v2(205.52,13.17) ; v1(95.9,24.04) 95.9,24.67 95.72,24.85 91.68,24.85 91.4,25.14 91.4,25.91 92.41,26.93 92.41,27.93 91.93,28.41 91.93,28.91 92.76,29.73 93.45,29.73 93.7,29.98 R2544.2 94.12,30.56 94.12,31.3 93.89,31.53 93.89,32.85 93.86,32.87 93.86,32.9 93.47,33.29 93.47,34.29 93.05,34.71 93.05,35.17 U2030.J1
DEVSLP0_R: length 3.3
  BOTTOM w0.102: HD1.5 212.72,14.32 212.61,14.21 v1(211.93,14.21) 211.92,14.21 R25484.1
DEVSLP1: length 6.1
  BOTTOM w0.079: 92.24,35.54 92.24,35.74 92.3,35.88 92.3,36.1 U2030.J2
  BOTTOM w0.102: R2557.2 93.69,30.94 93.69,32.76 93.23,33.22 93.23,34.23 92.85,34.61 92.85,34.93 92.24,35.54
DEVSLP2: length 100.5
  TOP w0.102: R645.2 31.58,3.16 31.51,3.24 v1(31.51,3.26)
  IN2 w0.089: v1(31.51,3.26) 31.51,3.24 32.14,3.24 33.08,4.18 37.32,4.18 37.86,4.72 37.86,5.88 41.6,9.62 44.03,9.62 49.13,14.72 52.26,14.72 52.64,14.34 78.55,14.34 84.27,20.05 88.07,20.05 93.25,14.87 v1(93.25,14.41)
  IN3 w0.089: v1(93.25,14.41) 93.25,17.54 91.63,19.16 91.63,21.05 v1(93.48,22.9)
  BOTTOM w0.079: 92.02,35.73 92.1,35.81 92.14,35.91 92.14,36.43 92.54,36.83 U2030.J3
  BOTTOM w0.102: 92.02,35.73 92.02,35.41 92.57,34.86 92.57,34.58 93.03,34.12 93.03,32.92 R2542.2 92.92,32.66 92.77,32.51 92.77,30.03 91.68,28.94 91.68,28.31 92.2,27.78 92.2,27.01 91.19,26 91.19,25.05 93.34,22.9 v1(93.48,22.9)
DEW1: length 4.7
  TOP w0.102: U42.16 213.08,15.37 213.8,14.65 v1(213.8,14.25) 213.68,14.12 R499.1 214.57,12.31 R500.2
DEW2: length 4.7
  TOP w0.102: R1237.2 205.43,18 v1(205.7,18.27) 206.45,18.27 R506.1 207.19,17.54 207.99,17.54 208.15,17.37 U42.6
DGPU_EDIDCLK: length 6.9
  BOTTOM w0.102: U8.A9 100.37,92.49 100.37,91.81 99.48,90.92 96.63,90.92 95.97,90.26 R363.1
DGPU_EDIDDATA: length 7.9
  BOTTOM w0.102: U8.B9 100.91,93.6 100.54,93.23 100.54,92.98 100.1,92.53 100.1,91.9 99.33,91.12 96.52,91.12 95.35,89.95 95.34,89.95 R366.1
DGPU_HOLD_RST#: length 134.8
  TOP w0.102: R2288.1 78.29,22.93 78.29,24.34 77.68,24.96 v1(77.68,25.12) 77.68,26.12 78.57,27.01 80.55,27.01 81.05,27.52 81.05,29.51 80.45,30.11 80.04,30.11 78.95,31.2 78.95,31.76 78.43,32.28 76.55,32.28 76.01,32.83 76.01,35.37 77.96,37.32 78.42,37.32 78.64,37.54 78.97,37.54 80.12,38.7 80.12,38.72 v4(80.2,38.79)
  IN1 w0.089: v1(96.02,124.03) 96.02,123.94 95.92,123.84 95.92,122.83 96,122.74 96.37,122.74 97.62,121.49 97.62,120.34 97,119.72 95.58,119.72 94.49,118.63 94.49,117.84 91.72,115.07 91.72,103.48 90.99,102.75 90.99,100.08 90.27,99.37 90.27,98.99 89.29,98.01 89.14,98.01 88.86,97.73 88.86,95.42 88.1,94.66 88.1,91.96 87.38,91.24 87.07,91.24 86.73,90.9 86.73,88.59 85.54,87.41 84.46,87.41 84.23,87.64 83.8,87.64 83.45,87.29 83.45,85.15 85.79,82.82 85.79,81.85 85.31,81.37 85.31,80.34 84.74,79.77 84.74,71.1 84.24,70.6 84.24,70.09 84.74,69.58 84.74,68.81 84.9,68.64 84.9,50.97 86.27,49.6 86.27,47.7 86.96,47.02 86.96,43.6 86.42,43.06 84.26,43.06 82.99,41.79 82.99,37.93 81.81,36.75 81.15,36.75 80.58,37.32 80.58,38.41 v4(80.2,38.79)
  BOTTOM w0.102: v1(96.02,124.03) 96.08,123.97 96.11,123.97 96.19,123.89 98.11,123.89 98.27,124.05 U6504.1 ; v4(80.2,38.79) 80.2,38.88 U2030.AP7
DGPU_OPP#: length 159.4
  TOP w0.102: v2(106.69,82.36) 106.69,81.98 107.26,81.42 107.8,81.42 Q6512.3 ; R378.1 201.25,17.15 201.05,17.35 201.05,17.87 v2(200.06,18.86) 199.91,18.71 199.91,18.38 199.71,18.18 U37.71
  IN2 w0.089: v2(200.06,18.86) 199.55,18.86 198.29,20.12 198.29,23.26 197.97,23.58 197.38,23.58 197.2,23.41 196.83,23.41 195.95,24.29 195.95,25.09 195.73,25.31 195.41,25.31 195.17,25.07 193.74,25.07 191.74,27.07 190.75,27.07 189.7,28.11 188.8,28.11 187.57,29.34 183.78,29.34 183.41,29.71 180.05,29.71 179.71,29.37 177.03,29.37 176.63,29.77 172.69,29.77 172.08,30.38 168.54,30.38 167.87,31.06 165.09,31.06 164.44,31.71 155.73,31.71 154.38,30.36 146.83,30.36 144.51,28.04 143.48,28.04 143.24,27.8 143.24,26.85 142.18,25.79 134.03,25.79 133.2,26.62 133.2,27.94 132.67,28.47 132.67,30.23 132.08,30.83 131.13,30.83 130.8,31.16 130.8,31.96 130.08,32.68 127.68,32.68 123.62,36.73 123.62,38.01 122.93,38.7 122.93,39.8 v1(123.28,40.14)
  IN3 w0.089: v2(106.69,82.36) 106.69,81.29 107.19,80.8 107.19,76.71 107.65,76.24 113.03,76.24 113.94,75.34 113.94,73.44 114.32,73.06 114.32,71.42 113.94,71.04 113.94,69.88 115.4,68.42 115.4,64.82 118.55,61.67 118.55,54.35 117.26,53.06 117.26,52.35 117.61,52 119.24,52 119.79,51.46 119.79,50.69 122.26,48.22 122.26,41.79 122.89,41.16 122.89,40.53 v1(123.28,40.14)
DGPU_OVT#_EC: length 218.7
  TOP w0.102: v1(104.84,126.04) 104.64,126.04 104.33,126.35 101.86,126.35 Q15.3 100.26,125.26 100.06,125.46 R385.2 ; U37.68 199.8,16.98 199.93,16.85 v1(200.07,16.85) 200.23,16.85 200.39,16.69 200.39,14.21 199.96,13.78 R340.1
  IN1 w0.089: v1(143.06,62.9) 143.27,63.1 143.27,63.22 142.92,64.95 142.92,65.11 142.92,67.96 142.92,68 142.92,68.33 142.92,77.39 140.02,80.3 128.13,80.3 127.32,81.11 126.55,81.11 125.93,81.74 122.25,81.74 121.3,80.79 118.1,80.79 115.4,83.49 110.5,83.49 103.75,90.24 102.34,90.24 100.8,91.78 100.8,93.87 99.96,94.71 99.96,95.87 100.26,96.18 100.26,97.64 101.26,98.64 101.26,100.24 100.98,100.52 100.98,101.8 100.37,102.41 100.37,103.4 100.18,103.6 100.18,107.69 101.53,109.04 103.9,109.04 105.2,110.34 105.2,111.99 105.01,112.18 105.01,115.74 106.28,117.01 106.28,119.9 105.99,120.18 105.99,121.94 106.24,122.18 106.24,122.51 106.37,122.63 106.37,124.58 104.91,126.04 v1(104.84,126.04)
  IN2 w0.089: v1(200.07,16.85) 200.07,16.87 200.18,16.99 200.18,17.97 200.27,18.06 200.33,18.06 200.82,18.55 200.82,19.17 200.34,19.65 199.57,19.65 198.86,20.36 198.86,23.5 198.24,24.12 198.24,25.52 197.34,26.42 196.58,26.42 196.46,26.3 195.05,26.3 194.76,26.02 194.13,26.02 193.15,27.01 193.15,28.52 191,30.67 185.5,30.67 184.41,31.77 181.56,31.77 181.56,31.77 181.44,31.77 180.84,32.37 177.8,32.37 176.99,31.56 175.03,31.56 174.67,31.21 174.4,31.21 174.08,31.53 170.7,31.53 170,32.22 165.54,32.22 164.89,32.88 161.01,32.88 158.97,34.92 155.96,34.92 155.82,34.78 149.13,34.78 149.07,34.84 146.79,34.84 143.86,37.77 143.86,38.68 144.18,39.01 144.18,44.23 144.31,44.36 144.31,46.65 146.32,48.65 146.72,48.65 147.42,49.17 148.04,49.8 148.04,50.25 146.77,51.53 146.45,51.53 145.99,51.99 145.99,54.03 144.95,55.07 144.34,55.07 143.67,55.74 143.67,60.18 143.42,60.44 143.42,62.22 143.06,62.57 v1(143.06,62.9)
DGPU_PGOK-1: length 17.8
  TOP w0.102: Q6554.6 85.08,99.09 85.31,99.32 85.31,99.67 85.52,99.88 85.94,99.88 87.2,98.62 87.2,98.45 87.71,97.94 v1(87.71,97.57) 87.71,97.41 v2(87.06,96.76)
  IN1 w0.089: v2(84.64,92.14) 84.57,92.14 83.83,92.88 83.83,95.21 85.38,96.76 v2(87.06,96.76)
  BOTTOM w0.102: R25548.1 84.45,92.33 v2(84.64,92.14) 84.84,92.33 C20020.1 85.28,90.84 Q6555.2
DGPU_POK2: length 3.6
  TOP w0.102: Q6554.2 85.73,95.76 85.48,95.5 85.21,95.5 84.96,95.25 C20021.1 85.54,95.02 85.65,95.13 86.27,95.13 R25549.1
DGPU_PROCHOT_EC#: length 20.8
  TOP w0.102: R25576.1 109.2,84.05 v2(109.08,83.93) 109.04,83.93 108.94,84.03 108.23,84.03 R25322.1 107.75,82.57 Q6512.1
  IN1 w0.089: v2(109.08,83.93) 108.49,84.52 108.49,84.96 103.6,89.85 101.99,89.85 98.84,93 v2(98.84,94.22)
  BOTTOM w0.102: v2(98.84,94.22) 99.37,94.22 99.63,94.48 99.63,95.03 U8.D7
DGPU_PSI: length 56.5
  TOP w0.102: v1(69.32,115.32) 69.4,115.24 PR9016.1 ; R376.2 90.01,95.58 90.24,95.35 91.31,95.35 91.73,95.77 92.75,95.77 93.47,95.05 v2(93.47,94.86)
  IN2 w0.089: v2(92.78,92.44) 92.78,92.51 93.47,93.2 v2(93.47,94.86) 93.47,103.93 91.75,105.65 88.78,105.65 86.33,103.2 85.16,103.2 84.79,102.82 79.62,102.82 74.44,108 73.48,108 72.63,108.85 72.63,108.93 70.89,110.67 70.47,110.67 69.84,111.31 69.84,112.72 70.88,113.76 70.88,114.55 70.11,115.32 v1(69.32,115.32)
  BOTTOM w0.102: R391.1 88.81,90.64 R25570.2 89.94,90.64 90.18,90.87 91.25,90.87 92.76,92.37 92.76,92.39 92.78,92.41 v2(92.78,92.44)
DGPU_PW_CTRL#: length 11.4
  BOTTOM w0.102: R2549.1 73.15,31.83 v1(72.32,31.83) 71.5,32.66 R2537.2 72.05,33.21 73.14,34.3 73.14,37.15 74.52,38.53 75.19,38.53 U2030.BA5
DGPU_PWR_EN: length 193.5
  TOP w0.102: PR9277.1 23.58,87.9 24.44,87.9 PR9070.2 25.11,87.74 25.87,87.74 26.2,88.07 v1(26.2,88.1)
  IN1 w0.089: 87.68,100.33 87,100.33 86.34,100.99 85.59,100.99 84.87,100.27 78.33,100.27 77.11,101.49 76.66,101.49 76.37,101.21 69.86,101.21 68,103.07 65.52,103.07 65.27,103.31 63.26,103.31 61.82,104.75 57.29,104.75 56.22,103.68 52.96,103.68 52.25,104.39 48.68,104.39 48.3,104.01 46.53,104.01 45.29,102.77 42.98,102.77 42.53,102.32 40.73,102.32 40.47,102.07 27.04,102.07 25.87,100.9 21.83,100.9 20.95,100.03 20.95,97.6 21.74,96.81 21.74,95.22 22.56,94.4 24.33,94.4 26.49,92.24 26.49,88.39 v1(26.2,88.1) ; 87.68,100.33 88.29,100.33 88.48,100.14 89.44,100.14 89.86,100.55 89.86,108.63 90.59,109.36 90.59,115.54 92.81,117.76 92.81,118.59 v1(94.01,119.78) ; 87.68,100.33 87.67,100.32 87.67,96.44 87.16,95.92 v2(87.06,95.92) 86.07,95.92 85.21,95.06 85.21,92.94 85.26,92.89 85.26,91.76 85.21,91.71 85.21,90.57 85.7,90.08 85.7,89.56 85.37,89.24 84.01,89.24 82.47,87.7 82.47,84.85 84.77,82.55 84.77,82.04 84,81.26 84,80.24 84.22,80.01 84.22,76.71 83.1,75.58 82.93,75.41 82.93,73.3 83.07,73.16 83.07,72.32 82.98,72.24 82.98,70.86 83.56,70.27 83.56,70.04 84.2,69.41 84.2,56.16 83.62,55.58 83.62,54.98 83.76,54.83 83.76,52.19 83.26,51.69 83.26,48.48 83.5,48.23 83.5,47.79 83.56,47.73 83.56,45.32 83.28,45.04 83.28,44.91 82.57,44.19 82.3,44.19 81.86,43.75 81.86,43.03 81.96,42.93 81.96,42.14 82.04,42.06 82.04,39.98 81.78,39.72 81.16,39.72 80.99,39.89 80.99,40.42 80.72,40.69 v1(80.14,40.69)
  BOTTOM w0.102: R2649.1 86.91,94.74 87.06,94.88 v2(87.06,95.92) 86.74,95.92 86.68,95.86 R2648.1 ; v1(94.01,119.78) 94.53,119.26 96.23,119.26 96.74,119.77 97.29,119.77 97.54,119.52 R323.1 ; U2030.AP8 80.14,40.5 v1(80.14,40.69)
DGPU_PWROK: length 85.4
  TOP w0.102: R25550.2 85.71,94.62 v2(85.82,94.73) ; v4(81.61,38.04) 81.61,37.87 80.63,36.89 80.63,35.39 79.97,34.73 79.97,33.11 80.71,32.37 80.71,31.03 81.93,29.81 81.93,27.14 81.06,26.28 81.06,25.53 81.49,25.1 R2613.1
  IN1 w0.089: v4(81.61,38.04) 82.41,38.83 82.41,41.97 82.15,42.22 82.15,43.01 82.06,43.11 82.06,43.59 82.3,43.84 82.77,43.84 82.92,43.68 83.26,43.68 83.57,43.99 83.57,44.4 83.49,44.48 83.49,44.98 84.4,45.88 84.4,51.01 83.93,51.48 83.93,54.9 83.88,54.95 83.88,55.6 84.36,56.09 84.36,69.49 83.83,70.03 83.83,73.87 83.93,73.97 83.93,75.3 84.39,75.75 84.39,79.89 84.98,80.48 84.98,81.51 85.15,81.68 85.15,82.63 82.66,85.12 82.66,87.62 83.51,88.46 84.51,88.46 84.78,88.19 85.21,88.19 86.08,89.06 86.08,90.24 85.94,90.38 85.94,91.35 v1(85.81,91.48) 85.64,91.65 85.64,94.55 v2(85.82,94.73)
  BOTTOM w0.102: v1(85.81,91.48) 85.81,90.75 Q6555.3 86.29,90.54 R25546.1 R25547.1 ; v4(81.61,38.04) 81.55,38.1 81.36,38.1 U2030.AM5
DISP_ON: length 7.6
  BOTTOM w0.102: R445.1 81.44,92.95 80.19,94.2 R446.2 79.93,94.48 79.93,96.29 80.76,97.12 80.76,98.11 v1(80.79,98.14) 80.95,98.31 U19.3
DMIC-DATA34: length 1.3
  BOTTOM w0.102: TP9024.1 209.64,29.06 R453.1
DMIC_CLK: length 4.1
  BOTTOM w0.102: U20.3 206.06,28.28 206.08,28.26 206.08,27.57 206.43,27.21 206.84,27.21 207.6,26.46 R461.2
DMIC_CLK_2: length 187.5
  TOP w0.102: v2(89.9,26.38) 89.9,25.92 90.44,25.39 90.44,25.14 94.04,21.53 94.04,19.33 94.56,18.81 95.77,18.81 96.06,19.11 96.06,20.52 96.56,21.02 98.93,21.02 v1(99.55,20.4)
  IN1 w0.089: v1(61.17,112.66) 60.1,113.73 50.36,113.73 49.77,113.14 v1(49.77,112.99)
  IN3 w0.089: v1(49.77,112.99) 49.77,113.14 50.2,113.57 50.2,113.75 49.8,114.16 48.61,114.16 47.76,115 42.17,115 41.2,115.97 39.44,115.97 37.48,114 v1(37.48,113.72) ; v1(61.17,112.66) 61.55,112.66 61.91,112.3 66.64,112.3 67.26,111.68 69.79,111.68 70.41,111.07 71.05,111.07 71.52,110.6 71.52,109.78 71.72,109.58 73.28,109.58 75.96,106.9 77.19,106.9 80.99,103.1 82.43,103.1 82.84,102.7 86.27,102.7 86.7,103.13 88.11,103.13 88.79,103.81 90.03,103.81 93.69,100.15 93.69,97.75 95.17,96.27 95.17,93.5 96.6,92.07 97.67,92.07 100.48,89.26 102.91,89.26 103.27,88.9 103.27,87.96 103.38,87.85 103.38,85.92 103.98,85.32 103.98,77.21 104.99,76.2 104.99,73.97 105.41,73.56 105.41,70.73 106.64,69.5 106.97,69.5 109.64,66.83 109.64,63.11 110.78,61.96 111.85,61.96 113.1,60.71 113.1,54.76 112.15,53.82 111.46,53.82 110.91,53.27 110.91,49.95 111.76,49.1 111.76,46.17 112.84,45.09 112.84,43.92 112.58,43.66 112.58,41.26 111.72,40.4 110.34,40.4 109.63,39.69 109.63,31.63 104.98,26.98 104.76,26.98 103.57,25.79 103.57,24.35 101.85,22.63 101.85,22.34 101.61,22.1 100.74,22.1 99.55,20.91 v1(99.55,20.4)
  BOTTOM w0.102: v2(89.9,26.38) 89.9,25.73 R25498.1 ; CN38.3 35.5,115.33 37.11,113.72 v1(37.48,113.72)
DMIC_CLK_2_R: length 25.6
  BOTTOM w0.102: U2030.H5 92.7,38.07 92.61,37.97 91.99,37.97 91.75,38.21 91.65,38.21 91.55,38.11 91.55,35.98 91.54,35.96 91.54,35.31 91.43,35.21 90.71,35.21 90.61,35.11 90.61,34.9 90.71,34.8 91.84,34.8 91.97,34.68 91.97,34.47 91.89,34.4 90.49,34.4 90.38,34.3 90.38,34.09 90.71,33.77 90.85,33.77 91.07,33.99 92.5,33.99 92.6,33.89 92.6,33.21 92.52,33.13 92.37,33.13 91.96,33.54 91.22,33.54 91.15,33.46 91.15,33.29 91.34,33.1 91.74,33.1 91.91,32.93 91.91,31.28 91.76,31.13 91.76,30.31 91.91,30.16 92.19,30.16 92.29,30.06 92.29,29.92 92.18,29.81 91.86,29.81 91.76,29.7 91.76,29.55 91.48,29.27 91.48,28.24 C6617.2 90.89,27.21 91.02,27.09 91.15,27.09 91.54,27.48 v1(91.74,27.48) 91.88,27.34 91.88,27.19 91.35,26.66 91.02,26.66 90.89,26.53 90.89,26.2 90.8,26.11 R25498.2
DMIC_CLK_L: length 255.9
  TOP w0.102: L12.2 52.1,111.68 51.65,112.13 v1(51.65,112.18)
  IN3 w0.089: v1(51.65,112.18) 51.65,112.48 52.87,113.71 58.59,113.71 61.29,116.41 65.38,116.41 66.22,117.24 66.22,121.18 68.4,123.36 77.56,123.36 77.66,123.25 84.7,123.25 90.17,117.79 92.47,117.79 94.93,115.33 94.93,115.02 96.55,113.4 96.55,102.54 98.71,100.38 98.71,99.41 99.78,98.34 104.52,98.34 105.04,97.81 105.04,94.56 107.5,92.1 107.5,90.8 107.67,90.63 107.67,85.98 106.18,84.49 106.18,80.99 106.72,80.45 106.72,76.52 107.46,75.77 112.83,75.77 113.47,75.14 113.47,69.69 114.93,68.23 114.93,62.08 115.3,61.71 115.3,58.29 116.29,57.29 116.62,57.29 117.44,56.47 117.44,55.45 116.79,54.8 116.79,52.15 117.41,51.53 119.05,51.53 119.32,51.26 119.32,49.62 120.59,48.35 120.59,46.14 121.79,44.94 121.79,43.02 121.71,42.94 121.71,39.54 122.19,39.05 122.5,39.05 123.94,37.61 123.94,37.3 125.14,36.1 126.21,36.1 128.52,33.8 131.29,33.8 131.6,34.11 132.79,34.11 134.67,32.22 136.04,32.22 136.89,31.37 136.89,30.29 137.44,29.74 137.93,29.74 138.12,29.93 138.12,31.44 138.56,31.88 139.17,31.88 139.26,31.96 141.24,31.96 144.68,35.41 146.27,35.41 146.59,35.09 148,35.09 148.29,35.39 155.87,35.39 156.92,34.34 156.92,33.41 157.68,32.65 159.24,32.65 159.73,33.14 163.21,33.14 163.58,32.77 164.43,32.77 167.02,30.18 169.18,30.18 169.47,30.47 175.98,30.47 177.75,32.23 180.77,32.23 181.35,31.65 182.91,31.65 183.16,31.9 184.89,31.9 185.09,32.1 187.23,32.1 188.02,32.9 190.26,32.9 191.24,33.87 192.05,33.87 192.07,33.9 192.92,33.9 193.1,33.71 195.23,33.71 196,32.95 196,32.53 197.04,31.49 197.04,30.67 197.52,30.19 197.52,28.81 199.02,27.3 202.03,27.3 202.33,27 203.48,27 203.59,27.11 204.16,27.11 204.27,27 206.12,27 v2(206.23,26.88)
  BOTTOM w0.102: R461.1 206.93,26.46 C583.2 206.66,26.46 v2(206.23,26.88)
