# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Library data of the parts (continued)
PJ9003 PR4-PR19 PR22 PR23 PR25 PR26 PR28-PR33 PR39 PR40 PR59 PR79 PR80 PR98 PR99 PR104-PR106 PR111 PR116 PR118 PR120 PR126 PR191 PR204-PR207 PR211 PR230 PR235 PR253 PR254 PR256 PR261-PR263 PR265-PR270 PR272-PR277 PR283 PR284 PR551 PR566-PR568 PR2060 PR3020-PR3022 PR6000-PR6007 PR6009-PR6025 PR6027-PR6031 PR6416-PR6418 PR7000-PR7006 PR7008-PR7020 PR7022-PR7031 PR7033-PR7069 PR7072 PR7075-PR7081 PR7084 PR7085 PR7087 PR7090-PR7092 PR7095 PR7098-PR7100 PR7102-PR7116 PR9000-PR9002 PR9004 PR9006 PR9008 PR9009 PR9011-PR9019 PR9021-PR9034 PR9067 PR9068 PR9070 PR9072-PR9082 PR9086-PR9105 PR9227 PR9244 PR9245 PR9248 PR9249 PR9255 PR9256 PR9258 PR9264 PR9265 PR9267-PR9273 PR9275 PR9277 PR9278 PR9281-PR9283 PR25541 PR25542 R36 R38 R134 R180 R183 R226 R296 R297 R299 R306 R307 R311-R326 R329-R332 R341-R359 R361-R370 R372-R374 R376 R378 R380 R382-R386 R391 R394-R399 R402-R407 R410 R411 R414-R430 R436 R439-R443 R445-R449 R451-R455 R459 R461 R462 R464 R465 R467-R469 R471-R484 R486 R487 R489-R491 R494 R495 R497-R500 R502-R513 R516-R519 R557-R562 R566 R567 R572-R576 R579 R580 R582 R583 R586 R590-R593 R596-R601 R608 R609 R638-R641 R645-R649 R651-R655 R664 R665 R667 R670-R679 R696-R703 R706-R713 R720 R732-R742 R746-R750 R894 R895 R956 R960 R1234-R1239 R1250 R1284-R1291 R2088-R2092 R2099-R2107 R2109-R2112 R2114 R2116-R2119 R2121 R2124 R2126 R2130 R2132 R2134-R2138 R2140 R2142 R2158-R2161 R2163 R2164 R2166-R2173 R2176-R2180 R2185-R2187 R2190-R2209 R2212-R2214 R2216 R2217 R2219-R2225 R2227-R2229 R2252 R2256 R2257 R2269 R2273-R2275 R2278-R2282 R2285-R2291 R2298-R2305 R2307 R2309 R2313-R2318 R2356-R2360 R2378 R2448-R2461 R2466 R2475 R2476 R2478-R2508 R2510-R2512 R2514-R2516 R2518 R2519 R2521-R2539 R2541-R2549 R2551 R2553-R2555 R2557-R2567 R2569 R2571 R2573-R2617 R2619-R2622 R2624-R2628 R2630 R2631 R2648-R2667 R6504-R6508 R6510 R6515-R6517 R6603 R9041 R9048 R25270 R25271 R25280 R25282-R25285 R25288-R25298 R25300 R25303 R25304 R25306-R25310 R25312 R25314-R25318 R25321-R25323 R25328 R25332 R25337-R25342 R25346 R25348 R25350-R25353 R25355 R25356 R25363 R25364 R25367-R25373 R25413 R25415 R25437 R25444-R25446 R25456 R25458 R25459 R25462 R25465 R25467 R25469 R25471-R25475 R25477 R25482-R25490 R25492 R25495 R25497 R25498 R25503-R25511 R25515 R25517 R25519-R25522 R25535 R25537-R25540 R25546-R25553 R25558 R25560-R25577 R25579-R25599 = RES_BGM
PL5 PL12 PL14 PL30 PL551 PL6000 PL6001 PL7000-PL7003 PL9000-PL9002 = INDUCTOR_BGM
PQ1 PQ2 PQ29 PQ30 PQ35 PQ7002 PQ9008 PQ9054 = MOS-N_8P_BGM
PQ6 PQ10 PQ12 PQ14 PQ17 PQ19 PQ25 PQ6000 PQ6001 PQ9009-PQ9011 PQ9050 PQ9084-PQ9086 Q9 Q14-Q16 Q20 Q21 Q29 Q33 Q34 Q63 Q81 Q2013 Q2014 Q2024 Q6505 Q6507 Q6509 Q6512 Q6515 Q6531 Q6533 Q6555 = MOS-N_3P_ESD_BGM
PQ7 PQ16 PQ9083 Q31 Q2023 Q6522 = DTC144EU_BGM
PQ9 PQ11 = MOS-N_3P_BGM
PQ7000 PQ7001 PQ7004 PQ9000 PQ9001 = MOS-N-Dual_10P_BGM
PQ7003 = MOS-N_8P_SCH_BGM
PR7007 PR7021 PR7032 PR9274 = Thermistor_BGM
PR7093 PR7101 = 10K-0603-1%: tolerance: 1%
PU1 = BQ24780SRUYR_BGM
PU16 = G5335QT2U_BGM
PU26 = G5416QS1U_30P_V2_BGM
PU3002 = TMP708_BGM
PU3003 = JW5222RSOTB#TRPBF_6P_V1_BGM
PU3004 = JW5213DFND_8P_BGM
PU6000 = RT6256BGQUF_12P_BGM
PU6001 PU6002 PU9002 = AOZ1331DI_BGM
PU6003 = RT6258CGQUF_12P_BGM
PU7000 = RT3602AJGQW_48P_BGM_1
PU7001-PU7004 = RT9610BZQW_BGM
PU9000 = RT8813DGQW_BGM
PU9003 = G9336ADJTP1U_BGM
PU9004 = G5335QT2U_V1_BGM
Q13 = 2N7002_3
Q27 Q41 Q2026 Q6519 Q6521 = MOS-N_Dual_6P_ESD_BGM
Q30 Q32 = MOS-P_3P_BGM
Q2025 Q6523 Q6550 = NPN_BGM
Q6508 = AP2331SA-7-01_BGM
Q6516 = MOS-P_8P_BGM
Q6518 = DTA124EU_0
Q6551 = NPN_LTC044EEBFS8TL_3P_BGM
Q6554 = NPN_Dual_6P_BGM
R340 R890 R25311 R25313 R25320 R25502 = RES_S_BGM
R450 R460 R463 R470 R589 R614 R775 R777 R25330 R25365 R25366 = SHORTPAD_BGM
R25272-R25279 R25480 = R_0
RV1 = TVS_DIODE_DUAL_BGM
RV2 RV3 = TPD4E02B04DQAR_BGM
SW1 = SW_4P_BGM
SW2 = SW_6P_R_BGM
SW3 = SW_6P_BGM
TP63 TP65-TP78 TP81 TP2022-TP2036 TP2038 TP2040 TP2042-TP2044 TP2046 TP2050 TP2051 TP2071-TP2081 TP2083-TP2086 TP2088-TP2093 TP9000 TP9001 TP9019 TP9021 TP9023 TP9024 TP9029-TP9033 TP9037-TP9041 = TP_BGM
TP9051-TP9074 = PAD
U8 = GPU_N16S-GTR_595P_BGM
U11 = NL17SZ32DFT2G_BGM
U14 = SLGC55544VTR_BGM
U15 U18 = MAX8863_2
U16 U17 = LXESEABAA6-046_0
U19 = APL3512ABI-TRG_BGM
U20 = ALC255-CG_BGM_0
U23 = PTN3366BS_BGM
U24 = RTL8111HSH-CG_BGM
U25 = NS680016_0
U32 = LIS3DHTR_BGM
U33 = NPCT750AAAYX_32P_BGM
U35 U36 = NL17SZ08DFT2G_5P_BGM
U37 = IT8987E/CX_BGM
U42 = SN75LVCP601RTJR_BGM
U2009-U2012 = DDR4_96P_BGM
U2014 U2019 U6504 U6505 = Logic_AND_BGM
U2015 U2029 = 74AUP1G07GW_BGM
U2030 = CPU_KBY_U42/U22_1356P_BGM
U2031 = SPI_WND_8P_BGM
U6502 = PI2EQX632EXUBE_0
U6503 = TPS25810RVC/SSOP_0
VRAM1 VRAM2 = GDDR5_170P_BGM
Y3 Y4 Y2002 Y2003 = CRYSTAL_4P_BGM
Y2004 = CRYSTAL_2P_BGM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-6X6-S
  round 0.991 smd: 1(6,-3)
132F18-100000-A2-R-18P-L
  rect 0.305x0.838 smd: 1(-4.25,3.175) 2(-3.75,3.175) 3(-3.25,3.175) 4(-2.75,3.175) 5(-2.25,3.175) 6(-1.75,3.175) 7(-1.25,3.175) 8(-0.75,3.175) 9(-0.25,3.175) 10(0.25,3.175) 11(0.75,3.175) 12(1.25,3.175) 13(1.75,3.175) 14(2.25,3.175) 15(2.75,3.175) 16(3.25,3.175) 17(3.75,3.175) 18(4.25,3.175)
  rect 0.787x2.007 smd: 19(-5.95,0) 20(5.95,0)
50208-00401-V02-4P-L
  rect 0.508x0.991 smd: 1(-1.2,1.95) 2(-0.4,1.95) 3(0.4,1.95) 4(1.2,1.95)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
50281-00201-001-2P-L
  rect 0.787x2.007 smd: 1(-0.625,4.05) 2(0.625,4.05)
  rect 2.007x2.489 smd: 3(-2.825,0) 4(2.825,0)
50505-00401-V01-4P-L
  rect 0.61x1.295 smd: 1(-1.5,3.25) 2(-0.5,3.25) 3(0.5,3.25) 4(1.5,3.25)
  rect 0.991x2.007 smd: 5(-4.1,0) 6(4.1,0)
50584-0280N-V02-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
51325-00401-001-4P-L
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.8,0) 6(2.8,0)
51619-04001-V04-40P-L
  rect 0.305x1.295 smd: 1(-9.75,2.8) 2(-9.25,2.8) 3(-8.75,2.8) 4(-8.25,2.8) 5(-7.75,2.8) 6(-7.25,2.8) 7(-6.75,2.8) 8(-6.25,2.8) 9(-5.75,2.8) 10(-5.25,2.8) 11(-4.75,2.8) 12(-4.25,2.8) 13(-3.75,2.8) 14(-3.25,2.8) 15(-2.75,2.8) 16(-2.25,2.8) 17(-1.75,2.8) 18(-1.25,2.8) 19(-0.75,2.8) 20(-0.25,2.8) 21(0.25,2.8) 22(0.75,2.8) 23(1.25,2.8) 24(1.75,2.8) 25(2.25,2.8) 26(2.75,2.8) 27(3.25,2.8) 28(3.75,2.8) 29(4.25,2.8) 30(4.75,2.8) 31(5.25,2.8) 32(5.75,2.8) 33(6.25,2.8) 34(6.75,2.8) 35(7.25,2.8) 36(7.75,2.8) 37(8.25,2.8) 38(8.75,2.8) 39(9.25,2.8) 40(9.75,2.8)
  rect 1.803x1.397 smd: 41(-11.4,0) 42(11.4,0)
51625-01201-001-12P-L
  rect 0.305x0.838 smd: 1(-2.75,3.555) 2(-2.25,3.555) 3(-1.75,3.555) 4(-1.25,3.555) 5(-0.75,3.555) 6(-0.25,3.555) 7(0.25,3.555) 8(0.75,3.555) 9(1.25,3.555) 10(1.75,3.555) 11(2.25,3.555) 12(2.75,3.555)
  rect 0.991x1.448 smd: 13(-4.54,0) 14(4.54,0)
196047-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-3.5,2.65) 2(-2.5,2.65) 3(-1.5,2.65) 4(-0.5,2.65) 5(0.5,2.65) 6(1.5,2.65) 7(2.5,2.65) 8(3.5,2.65)
  rect 1.803x1.397 smd: 9(-5.65,0) 10(5.65,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
196538-40041-3-40P-L
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: 41(-11.45,0) 42(11.45,0)
BGA96-MICRON-MT41J64M16JT-187EG
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA595-NVIDIA-N13P-GV2-S-A2
  round 0.381 smd: A2(-10.7,-9.9) A3(-10.7,-9.1) A4(-10.7,-8.3) A6(-10.7,-6.6) A7(-10.7,-5.8) A9(-10.7,-4.12) A10(-10.7,-3.32) A12(-10.7,-1.64) A13(-10.7,-0.84) A15(-10.7,0.84) A16(-10.7,1.64) A18(-10.7,3.32) A19(-10.7,4.12) A21(-10.7,5.8) A22(-10.7,6.6) A24(-10.7,8.3) A25(-10.7,9.1) A26(-10.7,9.9) AA1(5.8,-10.7) AA2(5.8,-9.9) AA3(5.8,-9.1) AA4(5.8,-8.3) AA5(5.8,-7.5) AA6(5.8,-6.66) AA7(5.8,-5.8) AA8(5.8,-4.96) AA9(5.86,-4.12) AA10(5.86,-3.32) AA12(5.86,-1.64) AA13(5.86,-0.84) AA14(5.86,0) AA15(5.86,0.84) AA16(5.86,1.64) AA18(5.86,3.32) AA19(5.86,4.12) AA20(5.8,4.96) AA21(5.8,5.8) AA22(5.8,6.66) AA23(5.8,7.5) AA24(5.8,8.3) AA25(5.8,9.1) AA26(5.8,9.9) AA27(5.8,10.7) AB1(6.6,-10.7) AB2(6.6,-9.9) AB3(6.6,-9.1) AB4(6.6,-8.3) AB5(6.6,-7.5) AB6(6.6,-6.6) AB7(6.66,-5.8) AB8(6.66,-4.96) AB9(6.66,-4.12) AB10(6.66,-3.32) AB11(6.66,-2.48) AB12(6.66,-1.64) AB13(6.66,-0.84) AB14(6.66,0) AB15(6.66,0.84) AB16(6.66,1.64) AB17(6.66,2.48) AB18(6.66,3.32) AB19(6.66,4.12) AB20(6.66,4.96) AB21(6.66,5.8) AB22(6.6,6.6) AB23(6.6,7.5) AB24(6.6,8.3) AB25(6.6,9.1) AB26(6.6,9.9) AB27(6.6,10.7) AC2(7.45,-9.9) AC3(7.45,-9.1) AC4(7.45,-8.3) AC5(7.45,-7.45) AC6(7.5,-6.6) AC7(7.5,-5.8) AC8(7.5,-4.96) AC9(7.5,-4.12) AC10(7.5,-3.32) AC11(7.5,-2.48) AC12(7.5,-1.64) AC13(7.5,-0.84) AC14(7.5,0) AC15(7.5,0.84) AC16(7.5,1.64) AC17(7.5,2.48) AC18(7.5,3.32) AC19(7.5,4.12) AC20(7.5,4.96) AC21(7.5,5.8) AC22(7.5,6.6) AC23(7.45,7.45) AC24(7.45,8.3) AC25(7.45,9.1) AC26(7.45,9.9) AD1(8.3,-10.7) AD2(8.3,-9.9) AD3(8.3,-9.1) AD4(8.3,-8.3) AD5(8.3,-7.45) AD6(8.3,-6.6) AD7(8.3,-5.8) AD8(8.3,-4.96) AD9(8.3,-4.12) AD10(8.3,-3.32) AD11(8.3,-2.48) AD12(8.3,-1.64) AD13(8.3,-0.84) AD14(8.3,0) AD15(8.3,0.84) AD16(8.3,1.64) AD17(8.3,2.48) AD18(8.3,3.32) AD19(8.3,4.12) AD20(8.3,4.96) AD21(8.3,5.8) AD22(8.3,6.6) AD23(8.3,7.45) AD24(8.3,8.3) AD25(8.3,9.1) AD26(8.3,9.9) AD27(8.3,10.7) AE1(9.1,-10.7) AE2(9.1,-9.9) AE3(9.1,-9.1) AE4(9.1,-8.3) AE5(9.1,-7.45) AE6(9.1,-6.6) AE7(9.1,-5.8) AE8(9.1,-4.96) AE9(9.1,-4.12) AE10(9.1,-3.32) AE11(9.1,-2.48) AE12(9.1,-1.64) AE13(9.1,-0.84) AE14(9.1,0) AE15(9.1,0.84) AE16(9.1,1.64) AE17(9.1,2.48) AE18(9.1,3.32) AE19(9.1,4.12) AE20(9.1,4.96) AE21(9.1,5.8) AE22(9.1,6.6) AE23(9.1,7.45) AE24(9.1,8.3) AE25(9.1,9.1) AE26(9.1,9.9) AE27(9.1,10.7) AF1(9.9,-10.7) AF2(9.9,-9.9) AF3(9.9,-9.1) AF4(9.9,-8.3) AF5(9.9,-7.45) AF6(9.9,-6.6) AF7(9.9,-5.8) AF8(9.9,-4.96) AF9(9.9,-4.12) AF10(9.9,-3.32) AF11(9.9,-2.48) AF12(9.9,-1.64) AF13(9.9,-0.84) AF14(9.9,0) AF15(9.9,0.84) AF16(9.9,1.64) AF17(9.9,2.48) AF18(9.9,3.32) AF19(9.9,4.12) AF20(9.9,4.96) AF21(9.9,5.8) AF22(9.9,6.6) AF23(9.9,7.45) AF24(9.9,8.3) AF25(9.9,9.1) AF26(9.9,9.9) AF27(9.9,10.7) AG2(10.7,-9.9) AG3(10.7,-9.1) AG4(10.7,-8.3) AG6(10.7,-6.6) AG7(10.7,-5.8) AG9(10.7,-4.12) AG10(10.7,-3.32) AG12(10.7,-1.64) AG13(10.7,-0.84) AG15(10.7,0.84) AG16(10.7,1.64) AG18(10.7,3.32) AG19(10.7,4.12) AG21(10.7,5.8) AG22(10.7,6.6) AG24(10.7,8.3) AG25(10.7,9.1) AG26(10.7,9.9) B1(-9.9,-10.7) B2(-9.9,-9.9) B3(-9.9,-9.1) B4(-9.9,-8.3) B5(-9.9,-7.45) B6(-9.9,-6.6) B7(-9.9,-5.8) B8(-9.9,-4.96) B9(-9.9,-4.12) B10(-9.9,-3.32) B11(-9.9,-2.48) B12(-9.9,-1.64) B13(-9.9,-0.84) B14(-9.9,0) B15(-9.9,0.84) B16(-9.9,1.64) B17(-9.9,2.48) B18(-9.9,3.32) B19(-9.9,4.12) B20(-9.9,4.96) B21(-9.9,5.8) B22(-9.9,6.6) B23(-9.9,7.45) B24(-9.9,8.3) B25(-9.9,9.1) B26(-9.9,9.9) B27(-9.9,10.7) C1(-9.1,-10.7) C2(-9.1,-9.9) C3(-9.1,-9.1) C4(-9.1,-8.3) C5(-9.1,-7.45) C6(-9.1,-6.6) C7(-9.1,-5.8) C8(-9.1,-4.96) C9(-9.1,-4.12) C10(-9.1,-3.32) C11(-9.1,-2.48) C12(-9.1,-1.64) C13(-9.1,-0.84) C14(-9.1,0) C15(-9.1,0.84) C16(-9.1,1.64) C17(-9.1,2.48) C18(-9.1,3.32) C19(-9.1,4.12) C20(-9.1,4.96) C21(-9.1,5.8) C22(-9.1,6.6) C23(-9.1,7.45) C24(-9.1,8.3) C25(-9.1,9.1) C26(-9.1,9.9) C27(-9.1,10.7) D1(-8.3,-10.7) D2(-8.3,-9.9) D3(-8.3,-9.1) D4(-8.3,-8.3) D5(-8.3,-7.45) D6(-8.3,-6.6) D7(-8.3,-5.8) D8(-8.3,-4.96) D9(-8.3,-4.12) D10(-8.3,-3.32) D11(-8.3,-2.48) D12(-8.3,-1.64) D13(-8.3,-0.84) D14(-8.3,0) D15(-8.3,0.84) D16(-8.3,1.64) D17(-8.3,2.48) D18(-8.3,3.32) D19(-8.3,4.12) D20(-8.3,4.96) D21(-8.3,5.8) D22(-8.3,6.6) D23(-8.3,7.45) D24(-8.3,8.3) D25(-8.3,9.1) D26(-8.3,9.9) D27(-8.3,10.7) E2(-7.45,-9.9) E3(-7.45,-9.1) E4(-7.45,-8.3) E5(-7.45,-7.45) E6(-7.5,-6.6) E7(-7.5,-5.8) E8(-7.5,-4.96) E9(-7.5,-4.12) E10(-7.5,-3.32) E11(-7.5,-2.48) E12(-7.5,-1.64) E13(-7.5,-0.84) E14(-7.5,0) E15(-7.5,0.84) E16(-7.5,1.64) E17(-7.5,2.48) E18(-7.5,3.32) E19(-7.5,4.12) E20(-7.5,4.96) E21(-7.5,5.8) E22(-7.5,6.6) E23(-7.45,7.45) E24(-7.45,8.3) E25(-7.45,9.1) E26(-7.45,9.9) F1(-6.6,-10.7) F2(-6.6,-9.9) F3(-6.6,-9.1) F4(-6.6,-8.3) F5(-6.6,-7.5) F6(-6.6,-6.6) F7(-6.66,-5.8) F8(-6.66,-4.96) F9(-6.66,-4.12) F10(-6.66,-3.32) F11(-6.66,-2.48) F12(-6.66,-1.64) F13(-6.66,-0.84) F14(-6.66,0) F15(-6.66,0.84) F16(-6.66,1.64) F17(-6.66,2.48) F18(-6.66,3.32) F19(-6.66,4.12) F20(-6.66,4.96) F21(-6.66,5.8) F22(-6.6,6.6) F23(-6.6,7.5) F24(-6.6,8.3) F25(-6.6,9.1) F26(-6.6,9.9) F27(-6.6,10.7) G1(-5.8,-10.7) G2(-5.8,-9.9) G3(-5.8,-9.1) G4(-5.8,-8.3) G5(-5.8,-7.5) G6(-5.8,-6.66) G7(-5.8,-5.8) G8(-5.8,-4.96) G9(-5.86,-4.12) G10(-5.86,-3.32) G12(-5.86,-1.64) G13(-5.86,-0.84) G14(-5.86,0) G15(-5.86,0.84) G16(-5.86,1.64) G18(-5.86,3.32) G19(-5.86,4.12) G20(-5.8,4.96) G21(-5.8,5.8) G22(-5.8,6.66) G23(-5.8,7.5) G24(-5.8,8.3) G25(-5.8,9.1) G26(-5.8,9.9) G27(-5.8,10.7) H2(-4.96,-9.9) H3(-4.96,-9.1) H4(-4.96,-8.3) H5(-4.96,-7.5) H6(-4.96,-6.66) H22(-4.96,6.66) H23(-4.96,7.5) H24(-4.96,8.3) H25(-4.96,9.1) H26(-4.96,9.9) J1(-4.12,-10.7) J2(-4.12,-9.9) J3(-4.12,-9.1) J4(-4.12,-8.3) J5(-4.12,-7.5) J6(-4.12,-6.66) J7(-4.12,-5.86) J21(-4.12,5.86) J22(-4.12,6.66) J23(-4.12,7.5) J24(-4.12,8.3) J25(-4.12,9.1) J26(-4.12,9.9) J27(-4.12,10.7) K1(-3.32,-10.7) K2(-3.32,-9.9) K3(-3.32,-9.1) K4(-3.32,-8.3) K5(-3.32,-7.5) K6(-3.32,-6.66) K7(-3.32,-5.86) K21(-3.32,5.86) K22(-3.32,6.66) K23(-3.32,7.5) K24(-3.32,8.3) K25(-3.32,9.1) K26(-3.32,9.9) K27(-3.32,10.7) L2(-2.48,-9.9) L3(-2.48,-9.1) L4(-2.48,-8.3) L5(-2.48,-7.5) L6(-2.48,-6.66) L22(-2.48,6.66) L23(-2.48,7.5) L24(-2.48,8.3) L25(-2.48,9.1) L26(-2.48,9.9) M1(-1.64,-10.7) M2(-1.64,-9.9) M3(-1.64,-9.1) M4(-1.64,-8.3) M5(-1.64,-7.5) M6(-1.64,-6.66) M7(-1.64,-5.86) M21(-1.64,5.86) M22(-1.64,6.66) M23(-1.64,7.5) M24(-1.64,8.3) M25(-1.64,9.1) M26(-1.64,9.9) M27(-1.64,10.7) N1(-0.84,-10.7) N2(-0.84,-9.9) N3(-0.84,-9.1) N4(-0.84,-8.3) N5(-0.84,-7.5) N6(-0.84,-6.66) N7(-0.84,-5.86) N21(-0.84,5.86) N22(-0.84,6.66) N23(-0.84,7.5) N24(-0.84,8.3) N25(-0.84,9.1) N26(-0.84,9.9) N27(-0.84,10.7) P2(0,-9.9) P3(0,-9.1) P4(0,-8.3) P5(0,-7.5) P6(0,-6.66) P22(0,6.66) P23(0,7.5) P24(0,8.3) P25(0,9.1) P26(0,9.9) R1(0.84,-10.7) R2(0.84,-9.9) R3(0.84,-9.1) R4(0.84,-8.3) R5(0.84,-7.5) R6(0.84,-6.66) R7(0.84,-5.86) R21(0.84,5.86) R22(0.84,6.66) R23(0.84,7.5) R24(0.84,8.3) R25(0.84,9.1) R26(0.84,9.9) R27(0.84,10.7) T1(1.64,-10.7) T2(1.64,-9.9) T3(1.64,-9.1) T4(1.64,-8.3) T5(1.64,-7.5) T6(1.64,-6.66) T7(1.64,-5.86) T21(1.64,5.86) T22(1.64,6.66) T23(1.64,7.5) T24(1.64,8.3) T25(1.64,9.1) T26(1.64,9.9) T27(1.64,10.7) U2(2.48,-9.9) U3(2.48,-9.1) U4(2.48,-8.3) U5(2.48,-7.5) U6(2.48,-6.66) U22(2.48,6.66) U23(2.48,7.5) U24(2.48,8.3) U25(2.48,9.1) U26(2.48,9.9) V1(3.32,-10.7) V2(3.32,-9.9) V3(3.32,-9.1) V4(3.32,-8.3) V5(3.32,-7.5) V6(3.32,-6.66) V7(3.32,-5.86) V21(3.32,5.86) V22(3.32,6.66) V23(3.32,7.5) V24(3.32,8.3) V25(3.32,9.1) V26(3.32,9.9) V27(3.32,10.7) W1(4.12,-10.7) W2(4.12,-9.9) W3(4.12,-9.1) W4(4.12,-8.3) W5(4.12,-7.5) W6(4.12,-6.66) W7(4.12,-5.86) W21(4.12,5.86) W22(4.12,6.66) W23(4.12,7.5) W24(4.12,8.3) W25(4.12,9.1) W26(4.12,9.9) W27(4.12,10.7) Y2(4.96,-9.9) Y3(4.96,-9.1) Y4(4.96,-8.3) Y5(4.96,-7.5) Y6(4.96,-6.66) Y22(4.96,6.66) Y23(4.96,7.5) Y24(4.96,8.3) Y25(4.96,9.1) Y26(4.96,9.9)
  round 0.4 smd: K10(-4,-4) K11(-4,-3) K12(-4,-2) K13(-4,-1) K14(-4,0) K15(-4,1) K16(-4,2) K17(-4,3) K18(-4,4) L10(-3,-4) L11(-3,-3) L12(-3,-2) L13(-3,-1) L14(-3,0) L15(-3,1) L16(-3,2) L17(-3,3) L18(-3,4) M10(-2,-4) M11(-2,-3) M12(-2,-2) M13(-2,-1) M14(-2,0) M15(-2,1) M16(-2,2) M17(-2,3) M18(-2,4) N10(-1,-4) N11(-1,-3) N12(-1,-2) N13(-1,-1) N14(-1,0) N15(-1,1) N16(-1,2) N17(-1,3) N18(-1,4) P10(0,-4) P11(0,-3) P12(0,-2) P13(0,-1) P14(0,0) P15(0,1) P16(0,2) P17(0,3) P18(0,4) R10(1,-4) R11(1,-3) R12(1,-2) R13(1,-1) R14(1,0) R15(1,1) R16(1,2) R17(1,3) R18(1,4) T10(2,-4) T11(2,-3) T12(2,-2) T13(2,-1) T14(2,0) T15(2,1) T16(2,2) T17(2,3) T18(2,4) U10(3,-4) U11(3,-3) U12(3,-2) U13(3,-1) U14(3,0) U15(3,1) U16(3,2) U17(3,3) U18(3,4) V10(4,-4) V11(4,-3) V12(4,-2) V13(4,-1) V14(4,0) V15(4,1) V16(4,2) V17(4,3) V18(4,4)
BGA1356-INTEL-SKYLAKE-U
  round 0.356 smd: A3(-11.314,-19.349) A70(-11.314,19.852) B2(-10.832,-19.832) B71(-10.852,20.314) BA1(10.852,-20.314) BA71(10.852,20.314) BB2(11.314,-19.852) BB70(11.314,19.852) C1(-10.349,-20.314)
  round 0.33 smd: A4(-11.314,-18.699) A69(-11.314,19.202) AY1(10.202,-20.314) AY71(10.202,20.314) B3(-10.679,-19.197) B70(-10.685,19.685) BA2(10.685,-19.685) BA70(10.685,19.685) BB3(11.314,-19.202) BB69(11.314,19.202) C2(-10.197,-19.679) C71(-10.202,20.314) D1(-9.699,-20.314)
  round 0.305 smd: A5(-11.314,-18.048) A68(-11.314,18.552) AA2(-0.511,-19.339) AA4(-0.511,-18.363) AA63(-0.596,15.112) AA64(-0.596,15.763) AA65(-0.596,16.413) AA66(-0.596,17.063) AA67(-0.596,17.713) AA68(-0.596,18.364) AA69(-0.596,19.014) AA70(-0.596,19.664) AA71(-0.596,20.314) AB4(0.152,-18.363) AB6(-0.133,-17.585) AB7(-0.133,-16.935) AB8(-0.133,-16.285) AB9(-0.133,-15.635) AB10(-0.133,-14.984) AB11(-0.133,-14.334) AB12(-0.133,-13.684) AB13(-0.133,-13.034) AB15(-0.009,-12.188) AB16(-0.009,-11.538) AB17(-0.009,-10.888) AB18(-0.009,-10.237) AB19(-0.009,-9.587) AB20(-0.009,-8.937) AB21(-0.009,-8.287) AB62(-0.138,14.644) AC3(0.815,-18.689) AC63(0.319,15.112) AC64(0.319,15.763) AC65(0.319,16.413) AC66(0.319,17.063) AC67(0.319,17.713) AC68(0.319,18.364) AC69(0.319,19.014) AC70(0.319,19.664) AC71(0.319,20.314) AD4(1.478,-18.363) AD6(0.934,-17.585) AD7(0.934,-16.935) AD8(0.934,-16.285) AD9(0.934,-15.635) AD10(0.934,-14.984) AD11(0.934,-14.334) AD12(0.934,-13.684) AD13(0.934,-13.034) AD15(0.829,-12.188) AD16(0.829,-11.538) AD17(0.829,-10.888) AD18(0.829,-10.237) AD19(0.829,-9.587) AD20(0.829,-8.937) AD21(0.829,-8.287) AD62(0.776,14.644) AE62(1.69,14.644) AE63(1.233,15.112) AE64(1.233,15.763) AE65(1.233,16.413) AE66(1.233,17.063) AE67(1.233,17.713) AE68(1.233,18.364) AE69(1.233,19.014) AF2(2.141,-19.339) AF4(2.141,-18.363) AF6(2.001,-17.585) AF7(2.001,-16.935) AF8(2.001,-16.285) AF9(2.001,-15.635) AF10(2.001,-14.984) AF11(2.001,-14.334) AF12(2.001,-13.684) AF13(2.001,-13.034) AF15(1.668,-12.188) AF16(1.668,-11.538) AF17(1.668,-10.888) AF18(1.668,-10.237) AF19(1.668,-9.587) AF20(1.668,-8.937) AF21(1.668,-8.287) AF63(2.148,15.112) AF64(2.148,15.763) AF65(2.148,16.413) AF66(2.148,17.063) AF67(2.148,17.713) AF68(1.939,18.364) AF69(1.939,19.014) AG4(2.804,-18.363) AG15(2.506,-12.188) AG16(2.506,-11.538) AG17(2.506,-10.888) AG18(2.506,-10.237) AG19(2.506,-9.587) AG20(2.506,-8.937) AG21(2.506,-8.287) AG62(2.605,14.644) AG69(2.602,18.689) AH3(3.467,-18.689) AH6(3.067,-17.585) AH7(3.067,-16.935) AH8(3.067,-16.285) AH9(3.067,-15.635) AH10(3.067,-14.984) AH11(3.067,-14.334) AH12(3.067,-13.684) AH13(3.067,-13.034) AH63(3.062,15.112) AH64(3.062,15.763) AH65(3.062,16.413) AH66(3.062,17.063) AH67(3.062,17.713) AJ4(4.13,-18.363) AJ15(3.344,-12.188) AJ16(3.344,-11.538) AJ17(3.344,-10.888) AJ18(3.344,-10.237) AJ19(3.344,-9.587) AJ20(3.344,-8.937) AJ21(3.344,-8.287) AJ62(3.519,14.644) AK6(4.007,-17.585) AK7(4.007,-16.935) AK8(4.007,-16.285) AK9(4.007,-15.635) AK10(4.007,-14.984) AK11(4.007,-14.334) AK12(4.007,-13.684) AK13(4.007,-13.034) AK15(4.182,-12.188) AK16(4.182,-11.538) AK17(4.182,-10.888) AK18(4.182,-10.237) AK19(4.182,-9.587) AK20(4.182,-8.937) AK21(4.182,-8.287) AK22(4.009,-7.596) AK23(4.009,-6.681) AK25(4.009,-5.767) AK27(4.009,-4.852) AK28(4.009,-3.938) AK30(4.009,-3.024) AK32(4.009,-2.109) AK33(4.009,-1.195) AK35(4.009,-0.28) AK37(4.009,0.634) AK38(4.009,1.548) AK40(4.009,2.463) AK42(4.009,3.377) AK43(4.009,4.292) AK45(4.009,5.206) AK46(4.009,6.12) AK48(4.009,7.035) AK50(4.009,7.949) AK52(4.009,8.864) AK53(4.009,9.778) AK55(4.009,10.692) AK56(4.009,11.607) AK58(4.009,12.521) AK60(4.009,13.436) AK62(4.144,14.46) AK63(3.976,15.112) AK64(3.976,15.763) AK65(3.976,16.413) AK66(3.976,17.063) AK67(3.976,17.713) AK68(3.829,18.364) AK69(3.829,19.339) AL2(4.793,-19.339) AL4(4.793,-18.363) AL23(4.474,-7.138) AL25(4.474,-6.224) AL27(4.474,-5.31) AL28(4.474,-4.395) AL30(4.474,-3.481) AL32(4.474,-2.566) AL33(4.474,-1.652) AL35(4.474,-0.738) AL37(4.474,0.177) AL38(4.474,1.091) AL40(4.474,2.006) AL42(4.474,2.92) AL43(4.474,3.834) AL45(4.474,4.749) AL46(4.474,5.663) AL48(4.474,6.578) AL50(4.474,7.492) AL52(4.474,8.406) AL53(4.474,9.321) AL55(4.474,10.235) AL56(4.474,11.15) AL58(4.474,12.064) AL60(4.474,12.978) AL61(4.474,13.893) AL63(4.845,15.112) AL64(4.845,15.763) AL65(4.845,16.413) AL66(4.845,17.063) AM4(5.456,-18.363) AM5(4.946,-17.654) AM7(4.946,-16.74) AM8(4.946,-15.825) AM10(4.946,-14.911) AM11(4.946,-13.996) AM13(4.946,-13.082) AM15(4.946,-12.168) AM16(4.946,-11.253) AM18(4.946,-10.339) AM20(4.946,-9.424) AM21(4.946,-8.51) AM22(4.946,-7.596) AM23(4.946,-6.681) AM25(4.946,-5.767) AM27(4.946,-4.852) AM28(4.946,-3.938) AM30(4.946,-3.024) AM32(4.946,-2.109) AM33(4.946,-1.195) AM35(4.946,-0.28) AM37(4.946,0.634) AM38(4.946,1.548) AM40(4.946,2.463) AM42(4.946,3.377) AM43(4.946,4.292) AM45(4.946,5.206) AM46(4.946,6.12) AM48(4.946,7.035) AM50(4.946,7.949) AM52(4.946,8.864) AM53(4.946,9.778) AM55(4.946,10.692) AM56(4.946,11.607) AM58(4.946,12.521) AM60(4.946,13.436) AM61(4.946,14.35) AM68(5.056,18.039) AM69(5.056,18.689) AN3(6.119,-18.689) AN5(5.597,-17.654) AN7(5.597,-16.74) AN8(5.597,-15.825) AN10(5.597,-14.911) AN11(5.597,-13.996) AN13(5.597,-13.082) AN15(5.597,-12.168) AN16(5.597,-11.253) AN18(5.597,-10.339) AN20(5.597,-9.424) AN21(5.597,-8.51) AN22(5.597,-7.596) AN23(5.597,-6.681) AN25(5.597,-5.767) AN27(5.597,-4.852) AN28(5.597,-3.938) AN30(5.597,-3.024) AN32(5.597,-2.109) AN33(5.597,-1.195) AN35(5.597,-0.28) AN37(5.597,0.634) AN38(5.597,1.548) AN40(5.597,2.463) AN42(5.597,3.377) AN43(5.597,4.292) AN45(5.597,5.206) AN46(5.597,6.12) AN48(5.597,7.035) AN50(5.597,7.949) AN52(5.597,8.864) AN53(5.597,9.778) AN55(5.597,10.692) AN56(5.597,11.607) AN58(5.597,12.521) AN60(5.597,13.436) AN61(5.597,14.35) AN63(5.597,15.264) AN65(5.597,16.179) AN66(5.597,17.093) AN68(5.719,18.364) AN69(5.719,19.014) AP4(6.782,-18.363) AP5(6.247,-17.654) AP7(6.247,-16.74) AP8(6.247,-15.825) AP10(6.247,-14.911) AP11(6.247,-13.996) AP13(6.247,-13.082) AP15(6.247,-12.168) AP16(6.247,-11.253) AP18(6.247,-10.339) AP20(6.247,-9.424) AP21(6.247,-8.51) AP22(6.247,-7.596) AP23(6.247,-6.681) AP25(6.247,-5.767) AP27(6.247,-4.852) AP28(6.247,-3.938) AP30(6.247,-3.024) AP32(6.247,-2.109) AP33(6.247,-1.195) AP35(6.247,-0.28) AP37(6.247,0.634) AP38(6.247,1.548) AP40(6.247,2.463) AP42(6.247,3.377) AP43(6.247,4.292) AP45(6.247,5.206) AP46(6.247,6.12) AP48(6.247,7.035) AP50(6.247,7.949) AP52(6.247,8.864) AP53(6.247,9.778) AP55(6.247,10.692) AP56(6.247,11.607) AP58(6.247,12.521) AP60(6.247,13.436) AP61(6.247,14.35) AP63(6.247,15.264) AP65(6.247,16.179) AP66(6.247,17.093) AP68(6.332,18.039) AP70(6.332,19.258) AR5(6.897,-17.654) AR7(6.897,-16.74) AR8(6.897,-15.825) AR10(6.897,-14.911) AR11(6.897,-13.996) AR13(6.897,-13.082) AR15(6.897,-12.168) AR16(6.897,-11.253) AR18(6.897,-10.339) AR20(6.897,-9.424) AR21(6.897,-8.51) AR22(6.897,-7.596) AR23(6.897,-6.681) AR25(6.897,-5.767) AR27(6.897,-4.852) AR28(6.897,-3.938) AR30(6.897,-3.024) AR32(6.897,-2.109) AR33(6.897,-1.195) AR35(6.897,-0.28) AR37(6.897,0.634) AR38(6.897,1.548) AR40(6.897,2.463) AR42(6.897,3.377) AR43(6.897,4.292) AR45(6.897,5.206) AR46(6.897,6.12) AR48(6.897,7.035) AR50(6.897,7.949) AR52(6.897,8.864) AR53(6.897,9.778) AR55(6.897,10.692) AR56(6.897,11.607) AR58(6.897,12.521) AR60(6.897,13.436) AR61(6.897,14.35) AR63(6.897,15.264) AR65(6.897,16.179) AR66(6.897,17.093) AR68(6.945,18.364) AR69(6.945,19.014) AT2(7.445,-19.339) AT4(7.445,-18.363) AT5(7.547,-17.654) AT7(7.547,-16.74) AT8(7.547,-15.825) AT10(7.547,-14.911) AT11(7.547,-13.996) AT13(7.547,-13.082) AT15(7.547,-12.168) AT16(7.547,-11.253) AT18(7.547,-10.339) AT20(7.547,-9.424) AT21(7.547,-8.51) AT22(7.547,-7.596) AT23(7.547,-6.681) AT25(7.547,-5.767) AT27(7.547,-4.852) AT28(7.547,-3.938) AT30(7.547,-3.024) AT32(7.547,-2.109) AT33(7.547,-1.195) AT35(7.547,-0.28) AT37(7.547,0.634) AT38(7.547,1.548) AT40(7.547,2.463) AT42(7.547,3.377) AT43(7.547,4.292) AT45(7.547,5.206) AT46(7.547,6.12) AT48(7.547,7.035) AT50(7.547,7.949) AT52(7.547,8.864) AT53(7.547,9.778) AT55(7.547,10.692) AT56(7.547,11.607) AT58(7.547,12.521) AT60(7.547,13.436) AT61(7.547,14.35) AT63(7.547,15.264) AT65(7.547,16.179) AT66(7.547,17.093) AT68(7.509,18.039) AT69(7.509,18.689) AU4(8.108,-18.363) AU5(8.198,-17.654) AU7(8.198,-16.74) AU8(8.198,-15.825) AU10(8.198,-14.911) AU11(8.198,-13.996) AU13(8.198,-13.082) AU15(8.198,-12.168) AU16(8.198,-11.253) AU18(8.198,-10.339) AU20(8.198,-9.424) AU21(8.198,-8.51) AU22(8.198,-7.596) AU23(8.198,-6.681) AU25(8.198,-5.767) AU27(8.198,-4.852) AU28(8.198,-3.938) AU30(8.198,-3.024) AU32(8.198,-2.109) AU33(8.198,-1.195) AU35(8.198,-0.28) AU37(8.198,0.634) AU38(8.198,1.548) AU40(8.198,2.463) AU42(8.198,3.377) AU43(8.198,4.292) AU45(8.198,5.206) AU46(8.198,6.12) AU48(8.198,7.035) AU50(8.198,7.949) AU52(8.198,8.864) AU53(8.198,9.778) AU55(8.198,10.692) AU56(8.198,11.607) AU58(8.198,12.521) AU60(8.198,13.436) AU61(8.198,14.35) AU63(8.198,15.264) AU65(8.198,16.179) AU66(8.198,17.093) AV3(8.799,-18.689) AV68(8.711,18.029) AV69(8.901,19.014) AV70(8.901,19.664) AW1(9.551,-20.314) AW5(8.911,-17.781) AW6(9.038,-17.13) AW7(9.363,-16.564) AW8(9.038,-15.986) AW9(9.363,-15.416) AW10(9.038,-14.753) AW11(9.363,-14.143) AW12(9.038,-13.565) AW13(9.363,-12.995) AW14(9.038,-12.332) AW15(9.363,-11.723) AW16(9.038,-11.145) AW17(9.363,-10.575) AW18(9.038,-9.912) AW20(9.363,-9.302) AW21(9.038,-8.724) AW22(9.363,-8.154) AW23(9.038,-7.466) AW25(9.363,-6.828) AW26(9.038,-6.264) AW27(9.363,-5.601) AW28(9.038,-4.988) AW29(9.363,-4.374) AW30(9.038,-3.711) AW31(9.363,-3.148) AW32(9.038,-2.485) AW33(9.363,-1.847) AW34(9.038,-1.283) AW35(9.363,-0.62) AW36(9.038,-0.007) AW37(9.363,0.607) AW38(9.038,1.269) AW39(9.363,1.833) AW41(9.038,2.471) AW42(9.363,3.108) AW43(9.038,3.672) AW44(9.363,4.335) AW45(9.038,4.949) AW46(9.363,5.562) AW47(9.038,6.163) AW48(9.363,6.727) AW49(9.038,7.355) AW50(9.363,7.984) AW51(9.038,8.548) AW52(9.363,9.149) AW53(9.038,9.762) AW54(9.363,10.375) AW55(9.038,11.038) AW56(9.363,11.602) AW57(9.038,12.24) AW59(9.363,12.877) AW60(9.038,13.441) AW61(9.363,14.104) AW62(9.038,14.718) AW63(9.363,15.331) AW64(9.038,15.994) AW65(9.363,16.558) AW66(8.9,17.093) AW67(9.371,18.018) AW68(9.622,18.622) AW69(9.536,19.267) AW70(10.035,19.685) AW71(9.551,20.314) AY2(10.034,-19.685) AY3(10.028,-19.028) AY4(10.043,-18.274) AY5(9.689,-17.665) AY8(9.689,-15.986) AY12(9.689,-13.565) AY16(9.689,-11.145) AY21(9.689,-8.724) AY26(9.689,-6.264) AY27(10.014,-5.601) AY29(10.014,-4.374) AY30(9.689,-3.711) AY34(9.689,-1.283) AY35(10.014,-0.62) AY37(10.014,0.607) AY38(9.689,1.269) AY43(9.689,3.672) AY44(10.014,4.335) AY46(10.014,5.562) AY47(9.689,6.163) AY51(9.689,8.548) AY52(10.014,9.149) AY54(10.014,10.375) AY55(9.689,11.038) AY60(9.689,13.441) AY61(10.014,14.104) AY63(10.014,15.331) AY64(9.689,15.994) AY66(9.689,17.221) AY68(10.267,18.535) B5(-10.664,-18.048) B6(-10.339,-17.467) B10(-10.339,-14.989) B14(-10.339,-12.511) B18(-10.339,-10.033) B22(-10.339,-7.555) B26(-10.339,-5.077) B30(-10.339,-2.599) B34(-10.339,-0.121) B39(-10.339,2.357) B44(-10.339,4.835) B48(-10.339,7.313) B53(-10.339,9.791) B58(-10.339,12.269) B62(-10.339,14.747) B66(-10.339,17.226) B69(-10.685,19.035) BA3(10.685,-19.035) BA5(10.626,-17.715) BA8(10.339,-15.986) BA12(10.339,-13.565) BA16(10.339,-11.145) BA21(10.339,-8.724) BA23(10.258,-7.466) BA28(10.258,-4.988) BA32(10.258,-2.485) BA36(10.258,-0.007) BA41(10.258,2.471) BA45(10.258,4.949) BA49(10.339,7.355) BA53(10.258,9.762) BA57(10.258,12.24) BA62(10.258,14.718) BA68(10.685,19.035) BB4(11.314,-18.551) BB68(11.314,18.552) C4(-10.336,-18.615) C5(-10.014,-18.048) C7(-10.014,-16.791) C8(-10.339,-16.228) C9(-10.014,-15.664) C11(-10.014,-14.313) C12(-10.339,-13.75) C13(-10.014,-13.186) C15(-10.014,-11.835) C16(-10.339,-11.272) C17(-10.014,-10.708) C19(-10.014,-9.357) C20(-10.339,-8.794) C21(-10.014,-8.23) C23(-10.014,-6.879) C24(-10.339,-6.316) C25(-10.014,-5.752) C27(-10.014,-4.401) C28(-10.339,-3.838) C29(-10.014,-3.274) C31(-10.014,-1.923) C32(-10.339,-1.36) C33(-10.014,-0.796) C36(-10.014,0.555) C37(-10.339,1.118) C38(-10.014,1.682) C40(-10.014,3.033) C41(-10.339,3.596) C42(-10.014,4.16) C45(-10.014,5.511) C46(-10.339,6.074) C47(-10.014,6.638) C50(-10.014,7.989) C51(-10.339,8.552) C52(-10.014,9.116) C54(-10.014,10.467) C55(-10.339,11.03) C56(-10.014,11.594) C59(-10.014,12.945) C60(-10.339,13.508) C61(-10.014,14.072) C63(-10.014,15.423) C64(-10.339,15.987) C65(-10.014,16.55) C67(-10.299,18.485) C68(-9.622,18.622) C70(-10.034,19.685) D3(-9.608,-19.339) D4(-9.669,-18.691) D5(-9.363,-18.09) D6(-9.323,-17.441) D7(-9.363,-16.791) D8(-9.689,-16.228) D9(-9.363,-15.664) D10(-9.323,-14.989) D11(-9.363,-14.313) D12(-9.689,-13.75) D13(-9.363,-13.186) D14(-9.323,-12.511) D15(-9.363,-11.835) D16(-9.689,-11.272) D17(-9.363,-10.708) D18(-9.323,-10.033) D19(-9.363,-9.357) D20(-9.689,-8.794) D21(-9.363,-8.23) D22(-9.323,-7.555) D23(-9.363,-6.879) D24(-9.689,-6.316) D25(-9.363,-5.752) D26(-9.323,-5.077) D27(-9.363,-4.401) D28(-9.689,-3.838) D29(-9.363,-3.274) D30(-9.323,-2.599) D31(-9.363,-1.923) D32(-9.689,-1.36) D33(-9.363,-0.796) D34(-9.323,-0.121) D36(-9.363,0.555) D37(-9.689,1.118) D38(-9.363,1.682) D39(-9.323,2.357) D40(-9.363,3.033) D41(-9.689,3.596) D42(-9.363,4.16) D44(-9.323,4.835) D45(-9.363,5.511) D46(-9.689,6.074) D47(-9.363,6.638) D48(-9.323,7.313) D50(-9.363,7.989) D51(-9.689,8.552) D52(-9.363,9.116) D53(-9.323,9.791) D54(-9.363,10.467) D55(-9.689,11.03) D56(-9.363,11.594) D58(-9.323,12.269) D59(-9.363,12.945) D60(-9.689,13.508) D61(-9.363,14.072) D62(-9.323,14.747) D63(-9.363,15.423) D64(-9.689,15.987) D65(-9.363,16.55) D66(-9.323,17.226) D67(-10.014,17.899) D68(-9.535,19.267) D69(-8.971,18.562) D71(-9.551,20.314) E1(-9.04,-20.314) E2(-9.04,-19.664) E3(-9.04,-19.014) E5(-8.591,-17.654) E6(-8.591,-16.74) E8(-8.591,-15.825) E10(-8.591,-14.911) E11(-8.591,-13.996) E13(-8.591,-13.082) E15(-8.591,-12.168) E16(-8.591,-11.253) E18(-8.591,-10.339) E20(-8.591,-9.424) E21(-8.591,-8.51) E22(-8.591,-7.596) E23(-8.591,-6.681) E25(-8.591,-5.767) E27(-8.591,-4.852) E28(-8.591,-3.938) E30(-8.591,-3.024) E32(-8.591,-2.109) E33(-8.591,-1.195) E35(-8.591,-0.28) E37(-8.591,0.634) E38(-8.591,1.548) E40(-8.591,2.463) E42(-8.591,3.377) E43(-8.591,4.292) E45(-8.591,5.206) E46(-8.591,6.12) E48(-8.591,7.035) E50(-8.591,7.949) E52(-8.591,8.864) E53(-8.591,9.778) E55(-8.591,10.692) E56(-8.591,11.607) E58(-8.591,12.521) E60(-8.591,13.436) E61(-8.591,14.35) E63(-8.655,15.315) E65(-8.655,16.331) E66(-8.655,17.347) E68(-9.363,17.899) F2(-8.466,-19.339) F4(-8.466,-18.363) F5(-7.941,-17.654) F6(-7.941,-16.74) F8(-7.941,-15.825) F10(-7.941,-14.911) F11(-7.941,-13.996) F13(-7.941,-13.082) F15(-7.941,-12.168) F16(-7.941,-11.253) F18(-7.941,-10.339) F20(-7.941,-9.424) F21(-7.941,-8.51) F22(-7.941,-7.596) F23(-7.941,-6.681) F25(-7.941,-5.767) F27(-7.941,-4.852) F28(-7.941,-3.938) F30(-7.941,-3.024) F32(-7.941,-2.109) F33(-7.941,-1.195) F35(-7.941,-0.28) F37(-7.941,0.634) F38(-7.941,1.548) F40(-7.941,2.463) F42(-7.941,3.377) F43(-7.941,4.292) F45(-7.941,5.206) F46(-7.941,6.12) F48(-7.941,7.035) F50(-7.941,7.949) F52(-7.941,8.864) F53(-7.941,9.778) F55(-7.941,10.692) F56(-7.941,11.607) F58(-7.941,12.521) F60(-7.941,13.436) F61(-7.941,14.35) F63(-8.005,15.315) F65(-8.005,16.331) F66(-8.005,17.347) F68(-8.32,18.562) G4(-7.803,-18.363) G5(-7.291,-17.654) G6(-7.291,-16.74) G8(-7.291,-15.825) G10(-7.291,-14.911) G11(-7.291,-13.996) G13(-7.291,-13.082) G15(-7.291,-12.168) G16(-7.291,-11.253) G18(-7.291,-10.339) G20(-7.291,-9.424) G21(-7.291,-8.51) G22(-7.291,-7.596) G23(-7.291,-6.681) G25(-7.291,-5.767) G27(-7.291,-4.852) G28(-7.291,-3.938) G30(-7.291,-3.024) G32(-7.291,-2.109) G33(-7.291,-1.195) G35(-7.291,-0.28) G37(-7.291,0.634) G38(-7.291,1.548) G40(-7.291,2.463) G42(-7.291,3.377) G43(-7.291,4.292) G45(-7.291,5.206) G46(-7.291,6.12) G48(-7.291,7.035) G50(-7.291,7.949) G52(-7.291,8.864) G53(-7.291,9.778) G55(-7.291,10.692) G56(-7.291,11.607) G58(-7.291,12.521) G60(-7.291,13.436) G61(-7.291,14.35) G63(-7.354,15.315) G65(-7.354,16.331) G66(-7.354,17.347) G68(-7.66,18.364) G69(-7.66,19.014) H3(-7.14,-18.689) H5(-6.641,-17.654) H6(-6.641,-16.74) H8(-6.641,-15.825) H10(-6.641,-14.911) H11(-6.641,-13.996) H13(-6.641,-13.082) H15(-6.641,-12.168) H16(-6.641,-11.253) H18(-6.641,-10.339) H20(-6.641,-9.424) H21(-6.641,-8.51) H63(-6.704,15.315) H65(-6.704,16.331) H66(-6.704,17.347) H69(-7.096,18.689) J4(-6.477,-18.363) J5(-5.99,-17.654) J6(-5.99,-16.74) J8(-5.99,-15.825) J10(-5.99,-14.911) J11(-5.99,-13.996) J13(-5.99,-13.082) J22(-6.827,-7.138) J23(-6.827,-6.224) J25(-6.827,-5.31) J27(-6.827,-4.395) J28(-6.827,-3.481) J30(-6.827,-2.566) J32(-6.827,-1.652) J33(-6.827,-0.738) J35(-6.827,0.177) J37(-6.827,1.091) J38(-6.827,2.006) J40(-6.827,2.92) J42(-6.827,3.834) J43(-6.827,4.749) J45(-6.827,5.663) J46(-6.827,6.578) J48(-6.827,7.492) J50(-6.827,8.406) J52(-6.827,9.321) J53(-6.827,10.235) J55(-6.827,11.15) J56(-6.827,12.064) J58(-6.827,12.978) J60(-6.827,13.893) J68(-6.52,18.362) K15(-5.876,-12.188) K16(-5.876,-11.538) K17(-5.876,-10.888) K18(-5.876,-10.237) K19(-5.876,-9.587) K20(-5.876,-8.937) K21(-5.876,-8.287) K22(-6.362,-7.596) K23(-6.362,-6.681) K25(-6.362,-5.767) K27(-6.362,-4.852) K28(-6.362,-3.938) K30(-6.362,-3.024) K32(-6.362,-2.109) K33(-6.362,-1.195) K35(-6.362,-0.28) K37(-6.362,0.634) K38(-6.362,1.548) K40(-6.362,2.463) K42(-6.362,3.377) K43(-6.362,4.292) K45(-6.362,5.206) K46(-6.362,6.12) K48(-6.362,7.035) K50(-6.362,7.949) K52(-6.362,8.864) K53(-6.362,9.778) K55(-6.362,10.692) K56(-6.362,11.607) K58(-6.362,12.521) K60(-6.362,13.436) K61(-6.362,14.35) K63(-6.054,15.133) K64(-6.054,15.783) K65(-6.054,16.433) K66(-6.054,17.084) K67(-6.054,17.734) K68(-5.846,18.352) K70(-5.744,19.339) L2(-5.814,-19.339) L4(-5.814,-18.363) L6(-5.34,-17.585) L7(-5.34,-16.935) L8(-5.34,-16.285) L9(-5.34,-15.635) L10(-5.34,-14.984) L11(-5.34,-14.334) L12(-5.34,-13.684) L13(-5.34,-13.034) L15(-5.038,-12.188) L16(-5.038,-11.538) L17(-5.038,-10.888) L18(-5.038,-10.237) L19(-5.038,-9.587) L20(-5.038,-8.937) L21(-5.038,-8.287) L62(-5.625,14.644) L63(-5.168,15.112) L64(-5.168,15.763) L65(-5.168,16.413) L66(-5.168,17.063) L67(-5.168,17.713) L68(-5.168,18.364) L69(-5.168,19.014) L70(-5.168,19.664) L71(-5.168,20.314) M4(-5.151,-18.363) M62(-4.71,14.644) N3(-4.488,-18.689) N6(-4.4,-17.585) N7(-4.4,-16.935) N8(-4.4,-16.285) N9(-4.4,-15.635) N10(-4.4,-14.984) N11(-4.4,-14.334) N12(-4.4,-13.684) N13(-4.4,-13.034) N15(-4.2,-12.188) N16(-4.2,-11.538) N17(-4.2,-10.888) N18(-4.2,-10.237) N19(-4.2,-9.587) N20(-4.2,-8.937) N21(-4.2,-8.287) N63(-4.253,15.112) N64(-4.253,15.763) N65(-4.253,16.413) N66(-4.253,17.063) N67(-4.253,17.713) N68(-4.253,18.364) N69(-4.253,19.014) N70(-4.253,19.664) N71(-4.253,20.314) P4(-3.825,-18.363) P15(-3.362,-12.188) P16(-3.362,-11.538) P17(-3.362,-10.888) P18(-3.362,-10.237) P19(-3.362,-9.587) P20(-3.362,-8.937) P21(-3.362,-8.287) P62(-3.796,14.644) R6(-3.333,-17.585) R7(-3.333,-16.935) R8(-3.333,-16.285) R9(-3.333,-15.635) R10(-3.333,-14.984) R11(-3.333,-14.334) R12(-3.333,-13.684) R13(-3.333,-13.034) R63(-3.339,15.112) R64(-3.339,15.763) R65(-3.339,16.413) R66(-3.339,17.063) R67(-3.339,17.713) R68(-3.339,18.364) R69(-3.339,19.014) R70(-3.339,19.664) R71(-3.339,20.314) T2(-3.162,-19.339) T4(-3.162,-18.363) T15(-2.523,-12.188) T16(-2.523,-11.538) T17(-2.523,-10.888) T18(-2.523,-10.237) T19(-2.523,-9.587) T20(-2.523,-8.937) T21(-2.523,-8.287) T62(-2.882,14.644) U4(-2.499,-18.363) U6(-2.267,-17.585) U7(-2.267,-16.935) U8(-2.267,-16.285) U9(-2.267,-15.635) U10(-2.267,-14.984) U11(-2.267,-14.334) U12(-2.267,-13.684) U13(-2.267,-13.034) U63(-2.424,15.112) U64(-2.424,15.763) U65(-2.424,16.413) U66(-2.424,17.063) U67(-2.424,17.713) U68(-2.424,18.364) U69(-2.424,19.014) U70(-2.424,19.664) U71(-2.424,20.314) V3(-1.836,-18.689) V15(-1.685,-12.188) V16(-1.685,-11.538) V17(-1.685,-10.888) V18(-1.685,-10.237) V19(-1.685,-9.587) V20(-1.685,-8.937) V21(-1.685,-8.287) V62(-1.967,14.644) W4(-1.173,-18.363) W6(-1.2,-17.585) W7(-1.2,-16.935) W8(-1.2,-16.285) W9(-1.2,-15.635) W10(-1.2,-14.984) W11(-1.2,-14.334) W12(-1.2,-13.684) W13(-1.2,-13.034) W63(-1.51,15.112) W64(-1.51,15.763) W65(-1.51,16.413) W66(-1.51,17.063) W67(-1.51,17.713) W68(-1.51,18.364) W69(-1.51,19.014) W70(-1.51,19.664) W71(-1.51,20.314) Y15(-0.847,-12.188) Y16(-0.847,-11.538) Y17(-0.847,-10.888) Y18(-0.847,-10.237) Y19(-0.847,-9.587) Y20(-0.847,-8.937) Y21(-0.847,-8.287) Y62(-1.053,14.644)
  oval 0.343x0.254 smd: A6(-10.989,-17.467) A7(-11.314,-16.791) A9(-11.314,-15.664) A10(-10.989,-14.989) A11(-11.314,-14.313) A13(-11.314,-13.186) A14(-10.989,-12.511) A15(-11.314,-11.835) A17(-11.314,-10.708) A18(-10.989,-10.033) A19(-11.314,-9.357) A21(-11.314,-8.23) A22(-10.989,-7.555) A23(-11.314,-6.879) A25(-11.314,-5.752) A26(-10.989,-5.077) A27(-11.314,-4.401) A29(-11.314,-3.274) A30(-10.989,-2.599) A31(-11.314,-1.923) A33(-11.314,-0.796) A34(-10.989,-0.121) A36(-11.314,0.555) A38(-11.314,1.682) A39(-10.989,2.357) A40(-11.314,3.033) A42(-11.314,4.16) A44(-10.989,4.835) A45(-11.314,5.511) A47(-11.314,6.638) A48(-10.989,7.313) A50(-11.314,7.989) A52(-11.314,9.116) A53(-10.989,9.791) A54(-11.314,10.467) A56(-11.314,11.594) A58(-10.989,12.269) A59(-11.314,12.945) A61(-11.314,14.072) A62(-10.989,14.747) A63(-11.314,15.423) A65(-11.314,16.55) A66(-10.989,17.226) A67(-11.314,17.901) AY7(10.014,-16.551) AY9(10.014,-15.416) AY11(10.014,-14.13) AY13(10.014,-12.995) AY15(10.014,-11.71) AY17(10.014,-10.574) AY20(10.014,-9.289) AY22(10.014,-8.154) AY25(10.014,-6.828) AY31(10.014,-3.148) AY33(10.014,-1.847) AY39(10.014,1.834) AY42(10.014,3.109) AY48(10.014,6.789) AY50(10.014,7.922) AY56(10.014,11.602) AY59(10.014,12.877) AY65(10.014,16.558) AY67(10.014,17.901) B7(-10.664,-16.791) B9(-10.664,-15.664) B11(-10.664,-14.313) B13(-10.664,-13.186) B15(-10.664,-11.835) B17(-10.664,-10.708) B19(-10.664,-9.357) B21(-10.664,-8.23) B23(-10.664,-6.879) B25(-10.664,-5.752) B27(-10.664,-4.401) B29(-10.664,-3.274) B31(-10.664,-1.923) B33(-10.664,-0.796) B36(-10.664,0.555) B38(-10.664,1.682) B40(-10.664,3.033) B42(-10.664,4.16) B45(-10.664,5.511) B47(-10.664,6.638) B50(-10.664,7.989) B52(-10.664,9.116) B54(-10.664,10.467) B56(-10.664,11.594) B59(-10.664,12.945) B61(-10.664,14.072) B63(-10.664,15.423) B65(-10.664,16.55) B67(-10.664,17.901) BA4(10.689,-18.366) BA6(10.257,-17.173) BA7(10.664,-16.61) BA9(10.664,-15.416) BA10(10.257,-14.753) BA11(10.664,-14.189) BA13(10.664,-12.995) BA14(10.257,-12.332) BA15(10.664,-11.768) BA17(10.664,-10.574) BA18(10.257,-9.912) BA20(10.664,-9.348) BA22(10.664,-8.154) BA25(10.664,-6.828) BA26(10.339,-6.165) BA27(10.664,-5.502) BA29(10.664,-4.473) BA30(10.339,-3.811) BA31(10.664,-3.148) BA33(10.664,-1.847) BA34(10.339,-1.184) BA35(10.664,-0.521) BA37(10.664,0.507) BA38(10.339,1.17) BA39(10.664,1.834) BA42(10.664,3.109) BA43(10.339,3.771) BA44(10.664,4.434) BA46(10.664,5.463) BA47(10.339,6.126) BA48(10.664,6.789) BA50(10.664,7.922) BA51(10.339,8.585) BA52(10.664,9.248) BA54(10.664,10.276) BA55(10.339,10.939) BA56(10.664,11.602) BA59(10.664,12.877) BA60(10.339,13.54) BA61(10.664,14.203) BA63(10.664,15.232) BA64(10.339,15.895) BA65(10.664,16.558) BA66(10.339,17.221) BA67(10.664,17.901) BB5(11.314,-17.786) BB6(10.989,-17.173) BB7(11.314,-16.61) BB9(11.314,-15.416) BB10(10.989,-14.753) BB11(11.314,-14.189) BB13(11.314,-12.995) BB14(10.989,-12.332) BB15(11.314,-11.768) BB17(11.314,-10.574) BB18(10.989,-9.912) BB20(11.314,-9.348) BB22(11.314,-8.154) BB23(10.908,-7.466) BB25(11.314,-6.828) BB26(10.989,-6.165) BB27(11.314,-5.502) BB29(11.314,-4.473) BB30(10.989,-3.811) BB31(11.314,-3.148) BB32(10.908,-2.484) BB33(11.314,-1.847) BB34(10.989,-1.184) BB35(11.314,-0.521) BB37(11.314,0.507) BB38(10.989,1.17) BB39(11.314,1.834) BB41(10.908,2.471) BB42(11.314,3.109) BB43(10.989,3.771) BB44(11.314,4.434) BB46(11.314,5.463) BB47(10.989,6.126) BB48(11.314,6.789) BB50(11.314,7.922) BB51(10.989,8.585) BB52(11.314,9.248) BB54(11.314,10.276) BB55(10.989,10.939) BB56(11.314,11.602) BB57(10.908,12.24) BB59(11.314,12.877) BB60(10.989,13.54) BB61(11.314,14.203) BB63(11.314,15.232) BB64(10.989,15.895) BB65(11.314,16.558) BB66(10.989,17.221) BB67(11.314,17.901)
  oval 0.254x0.343 smd: AA1(-0.51,-19.989) AB1(0.153,-20.314) AB2(0.153,-19.664) AB3(0.153,-19.013) AC1(0.815,-19.989) AC2(0.815,-19.339) AD1(1.479,-20.314) AD2(1.479,-19.664) AD3(1.479,-19.013) AF1(2.141,-19.989) AF70(1.84,19.664) AF71(1.84,20.314) AG1(2.804,-20.314) AG2(2.804,-19.664) AG3(2.804,-19.013) AG70(2.503,19.339) AG71(2.503,19.989) AH1(3.467,-19.989) AH2(3.467,-19.339) AH68(3.166,18.363) AH69(3.166,19.014) AH70(3.166,19.664) AH71(3.166,20.314) AJ1(4.13,-20.314) AJ2(4.13,-19.664) AJ3(4.13,-19.013) AK70(3.829,19.989) AL1(4.793,-19.989) AL68(4.492,18.363) AL69(4.492,19.014) AL70(4.492,19.664) AL71(4.492,20.314) AM1(5.456,-20.314) AM2(5.456,-19.664) AM3(5.456,-19.013) AM70(5.155,19.339) AM71(5.155,19.989) AN1(6.119,-19.989) AN2(6.119,-19.339) AN70(5.818,19.664) AN71(5.818,20.314) AP1(6.782,-20.314) AP2(6.782,-19.664) AP3(6.782,-19.013) AR70(6.846,19.664) AR71(6.846,20.314) AT1(7.445,-19.989) AT70(7.509,19.339) AT71(7.509,19.989) AU1(8.108,-20.314) AU2(8.108,-19.664) AU3(8.108,-19.013) AU68(8.147,18.363) AU69(8.172,19.014) AU70(8.172,19.664) AU71(8.172,20.314) AV1(8.828,-20.314) AV2(8.799,-19.364) AV71(8.901,20.314) AW2(9.363,-19.689) AW3(9.363,-19.039) E70(-9.009,19.664) E71(-8.901,20.314) F1(-8.466,-19.989) F70(-8.32,19.212) F71(-8.384,19.862) G1(-7.803,-20.314) G2(-7.803,-19.664) G3(-7.803,-19.013) G70(-7.759,19.664) G71(-7.759,20.314) H1(-7.14,-19.989) H2(-7.14,-19.339) H70(-7.096,19.339) H71(-7.096,19.989) J1(-6.477,-20.314) J2(-6.477,-19.664) J3(-6.477,-19.013) J69(-6.433,19.014) J70(-6.433,19.664) J71(-6.433,20.314) K71(-5.744,19.989) L1(-5.814,-19.989) M1(-5.151,-20.314) M2(-5.151,-19.664) M3(-5.151,-19.013) N1(-4.488,-19.989) N2(-4.488,-19.339) P1(-3.825,-20.314) P2(-3.825,-19.664) P3(-3.825,-19.013) T1(-3.162,-19.989) U1(-2.499,-20.314) U2(-2.499,-19.664) U3(-2.499,-19.013) V1(-1.836,-19.989) V2(-1.836,-19.339) W1(-1.173,-20.314) W2(-1.173,-19.664) W3(-1.173,-19.013)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DCJK-30706-00042-001-3P-SMT
  oval 1.6x2.489 hole 0.991x1.905: 1(0,8.15)
  oval 1.092x2.108 hole 0.508x1.499: 2(2.15,7.5) 3(-2.15,7.5)
  oval 1.194x3.607 hole 0.508x2.997: 4(-4.25,0) 5(4.25,0)
DDR4-D4AS0-26001-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
