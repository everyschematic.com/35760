# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCPGPPA: length 31.2
  IN2 w0.127: v4(82.46,43.29) 82.76,43.29 83.01,43.05 83.01,42.02 82.46,41.46 82.46,38.34 85.02,35.78 86.71,35.78 88.21,34.27 89.62,34.27 89.97,34.62 90.48,34.62 91.52,35.66 95.59,35.66 96.2,36.28 97.42,36.28 97.55,36.41 99.55,36.41 101.15,34.81 v1(101.15,34.32)
  BOTTOM w0.102: v1(101.15,34.32) 101.15,34.25 C2362.1
  BOTTOM w0.127: U2030.AK15 81.91,43.81 82.42,43.29 v4(82.46,43.29) ; C2362.1 100.83,33.67 101.29,33.2 R2318.1
+VCCPGPPB: length 31.2
  IN2 w0.127: v1(99.33,35.93) 99.07,36.18 97.65,36.18 97.51,36.05 96.3,36.05 95.68,35.43 91.62,35.43 90.57,34.39 90.06,34.39 89.72,34.04 87.82,34.04 87.46,34.4 86.75,34.4 86.4,34.76 86.4,35.42 86.27,35.55 84.85,35.55 82.23,38.16 82.23,41.87 82.1,42 82.1,42.89 81.98,43.01 81.98,43.7 82.1,43.83 82.74,43.83 83.21,43.36 v4(83.75,43.36)
  BOTTOM w0.127: R2317.1 101.38,35.44 C2361.1 100.08,35.93 v1(99.33,35.93) ; U2030.AG15 83.75,43.61 v4(83.75,43.36)
+VCCPGPPC: length 20.2
  TOP w0.381: v4(86.49,44.79) 86.41,44.79 85.92,44.3 85.92,43.92 86.12,43.71 86.12,43.17 85.15,42.2 85.15,42.18 85.13,42.16 85.13,37.83 84.67,37.38 84.67,33.29 84.72,33.25 84.72,32.31 84.71,32.29 84.71,31.82 84.78,31.74 84.78,29.11 v1(85.03,28.87) 84.64,28.47 C2358.1 84.64,26.83 R2314.1
  BOTTOM w0.254: U2030.Y16 86.58,44.79 v4(86.49,44.79)
+VCCPGPPD: length 17
  TOP w0.381: C2357.1 86.04,31.94 86.42,32.32 v1(86.42,33.15) 86.42,33.31 85.36,34.38 85.36,37.07 86.19,37.91 86.24,37.95 86.24,42.6 86.61,42.97 86.61,44.03 v4(86.51,44.13)
  TOP w0.508: C2357.1 87.14,30.09 R2313.1
  BOTTOM w0.254: U2030.Y15 86.59,44.13 v4(86.51,44.13)
+VCCPGPPE: length 34.4
  TOP w0.127: R2315.1 102.59,35.61 C2359.1 v1(102.08,37.81)
  IN2 w0.127: v1(102.08,37.81) 102,37.88 98.06,37.88 97.32,37.15 96.03,37.15 95.28,36.4 91.22,36.4 90.17,35.36 89.66,35.36 89.32,35.01 88.66,35.01 87.16,36.51 85.43,36.51 83.3,38.64 83.3,41.26 84.39,42.36 85.2,42.36 85.65,42.8 86.16,42.8 88.12,44.76 v4(88.16,44.76)
  BOTTOM w0.127: v4(88.16,44.76) 88.28,44.76 U2030.T16
+VCCPGPPF: length 15
  TOP w0.508: v4(84.79,44.12) 84.79,43.03 83.91,42.14 83.91,36.28 83.42,35.8 83.42,31.3 84.06,30.67 R2299.1
  BOTTOM w0.254: v4(84.79,44.12) 84.73,44.12 U2030.AF16
+VCCPGPPG: length 34.3
  TOP w0.127: R2316.1 103.6,31.92 103.54,31.98 C2360.1 102.93,32.97 v1(101.76,34.14)
  IN2 w0.127: v1(101.76,34.14) 101.76,34.52 99.65,36.64 97.46,36.64 97.32,36.51 96.11,36.51 95.49,35.89 91.43,35.89 90.38,34.85 89.87,34.85 89.53,34.5 88.38,34.5 86.88,36 85.18,36 82.69,38.49 82.69,41.37 84.18,42.87 84.99,42.87 v4(85.59,43.46)
  BOTTOM w0.127: U2030.AD15 85.24,43.81 85.25,43.8 v4(85.59,43.46)
+VCCPLL: length 21.7
  TOP w0.508: R2506.2 110.14,49.1 109.99,48.95 v1(109.1,48.95) 108.37,49.68 C20022.2 107.98,49.68 107.18,50.47 106.93,50.47 C2580.2 106.49,50.91 97.85,50.91 96.5,49.56 92.77,49.56 v4(91.91,48.7)
+VCCPRIM_3P3: length 42.3
  TOP w0.127: R2300.2 102.81,34.19 v1(102.8,34.21) ; v4(83.14,47.4) 83.62,47.4 C2275.2
  IN2 w0.127: v1(102.8,34.21) 102.44,34.21 99.75,36.9 96.14,36.9 95.39,36.15 91.32,36.15 90.28,35.1 89.77,35.1 89.42,34.76 88.56,34.76 87.06,36.26 85.32,36.26 83.04,38.54 83.04,41.37 84.29,42.61 85.1,42.61 85.54,43.06 86.06,43.06 87.26,44.26 87.26,44.84 87.67,45.25 87.67,46.24 v4(88.16,46.74)
  IN3 w0.127: v4(88.16,46.74) 87.57,46.74 86.91,47.4 v4(83.14,47.4)
  BOTTOM w0.127: v4(83.14,47.4) 83.03,47.4 U2030.AJ21 ; v4(88.16,46.74) 88.07,46.74 U2030.V19
+VCCPRTC: length 28.4
  TOP w0.635: R2214.1 62.67,40.75 63.8,40.75 64.12,41.07 64.5,41.07 64.92,41.49 C2301.2 C2295.1 66.81,42.71 66.88,42.65 71.3,42.65 72.03,43.38 73.7,43.38 v2(74,43.68)
  IN1 w0.457: v4(81.36,47.04) 81.36,47.26 80.69,47.93 80.69,48.2 80.25,48.64 79.58,48.64
  IN1 w0.508: 79.58,48.64 77.8,48.64 77.11,49.32 76.22,49.32 75.53,48.63 75.53,46 74,44.48 v2(74,43.68)
  BOTTOM w0.178: U2030.BB14 75.06,43.68 v2(74,43.68)
  BOTTOM w0.305: U2030.AK19 81.36,46.93 v4(81.36,47.04)
+VCCPRTCPRIM_3P3: length 22
  TOP w0.254: R2586.1 67.71,22.13 66.75,23.08 C2601.2 66.27,24.17 C2603.1 66.27,25.69 v1(66.27,25.69) 66.27,26.16 66.99,26.88 66.99,30.01 67.76,30.78 67.76,31.14 67.55,31.36 67.55,31.9 68.78,33.13 71.92,33.13 74.13,35.34 74.13,37.29 v1(73.99,37.42)
  BOTTOM w0.254: U2030.AK17 81.95,45.11 v4(82.27,45.42)
+VCCPSPI: length 20.9
  TOP w0.508: R2212.2 84.88,25.22 84.03,26.07 84.03,27.06 83.15,27.95 83.15,30.72 82.66,31.2 82.66,36.18 83.16,36.68 83.16,42.33 83.18,42.35 83.18,42.84 83.11,42.91 83.11,43.94 83.16,43.99 v4(83.16,44.16)
  BOTTOM w0.305: v4(83.16,44.16) 82.86,44.46 U2030.AJ16
+VCCRTC_2: length 53.2
  TOP w0.508: v1(47.94,24.19) 48.09,24.19 48.33,23.95 R2378.1
  IN1 w0.508: v1(47.94,24.19) 47.94,23.25 47.53,22.85 47.53,17.34 46.76,16.57 46.76,14.31 45.92,13.47 45.92,12.83 44.03,10.93 42.48,10.93 36.89,5.35 v1(35.14,5.35)
  IN2 w0.508: v1(35.14,5.35) 34.64,5.85 26.24,5.85 22.85,2.45 18.2,2.45 17.41,3.24 15.17,3.24 v1(15.12,3.29)
  BOTTOM w0.508: v1(15.12,3.29) 15.12,3.95 14.93,4.15 CN1.1
+VCCSA: length 10.9
  TOP w0.254: R2193.1 103.24,48.49 v1(103.06,48.68)
  BOTTOM w0.127: 92.42,51.76 U2030.K28 ; U2030.K28 92.42,52.37 ; U2030.K28 92.73,52.06 ; U2030.K28 92.12,52.06 ; U2030.K25 92.42,49.93 ; U2030.K25 92.12,50.23 ; U2030.K25 92.73,50.23 ; 92.58,51.6 U2030.J27 ; U2030.J27 93.19,51.6 ; U2030.J27 92.89,51.3 ; U2030.J27 92.89,51.91 ; U2030.J22 93.03,48.86 93.18,49.01 ; U2030.J22 92.66,48.86 92.57,48.96 ; U2030.J22 92.89,49.18 ; 92.12,52.98 U2030.K30 92.42,52.67 ; 92.42,49.62 U2030.K23 92.73,49.32 ; 93.05,49.32 U2030.G23 93.35,49.62 ; 92.58,49.78 U2030.J23 ; U2030.J23 92.89,49.47 ; U2030.J23 93.19,49.78 ; U2030.J23 92.89,50.08 ; 93.05,50.23 U2030.G25 93.35,49.93 ; 93.35,51.76 U2030.G28 93.05,52.06 ; 93.35,51.45 U2030.G27 93.05,51.15 ; 92.73,51.15 U2030.K27 ; U2030.K27 92.12,51.15 ; U2030.K27 92.42,51.45
  vias: v1(82.59,50.11) v1(82.59,49.46) v1(113.14,42.2) v1(113.42,42.81) v1(114.06,42.79) v1(114.41,42.12) v1(114.69,42.81) v1(115.33,42.81) v1(115.68,42.23) v1(116.88,42.91) v1(117.51,42.91) v1(118.15,42.91) v1(118.78,42.91) v1(119.42,42.91) v1(123.4,39.43) v1(123.4,38.8) v1(124.03,40.05) v1(124.06,39.42) v1(124.09,38.79) v1(124.75,39.43) v1(124.75,38.8) v4(82.41,50.71) v4(83.75,50.46) v4(87.16,51.73) v4(87.77,51.12) v4(88.92,51.2) v4(89.95,51.27) v4(90.97,51.29) v4(91.64,52.69) v4(91.64,52.05) v4(91.61,51.11) v4(91.61,50.49) v4(91.93,49.94) v4(93.68,51.61)
+VCCSTG: length 17.6
  TOP w0.508: v4(93.69,46.99) 96.68,46.99 v4(98.13,48.44) 98.13,46.85 97.37,46.08 97.37,45.57 97.89,45.05 98.43,45.05 99.13,45.75 v1(100.54,45.75) 100.88,45.75 C2308.2 102.47,45.17 C2309.2 102.83,45.17 103.73,44.27 R2209.2
  BOTTOM w0.203: U2030.A22 98.13,48.45 v4(98.13,48.44)
  BOTTOM w0.254: U2030.G20 93.69,46.91 v4(93.69,46.99)
+VDD33_12: length 16.3
  IN2 w0.508: v1(96.73,90.41) 96.84,90.51 96.84,91.26 96.31,91.79 96.31,93.07 96.79,93.55 98.27,93.55 98.37,93.44 99.11,93.44 99.76,94.09 101.53,94.09 101.92,94.47 101.92,95.87
  BOTTOM w0.356: v1(102.17,97.52) 102.68,98.03 103.23,98.03 U8.G12 ; v1(101.32,97.48) U8.G10
  BOTTOM w0.508: v1(96.73,90.41) 96.73,88.79 v1(96.72,88.78) 96.32,88.38 96.3,88.38 R25566.2 R25565.2
+VDD33_34: length 17.1
  TOP w0.254: C401.1 C394.1 97.78,98.63 97.42,99 95.74,99 92.38,102.36 C392.1 88.56,102.36 R25567.2 R25568.2 ; C401.1 99.37,98.63 v2(99.69,98.96) ; C401.1 99.05,97.94 C398.1
  BOTTOM w0.254: v2(99.69,98.96) 99.69,98.31 U8.G8 100.13,97.87 U8.G9
+VDDQ: length 103.2
  TOP w0.508: R2135.1 65.8,85.1 66.36,85.66 66.36,91.68 67.85,93.17 67.85,96.67 67.12,97.4 67.12,98.79 65.93,99.98 64.96,99.98 65.97,101 65.97,104.52 v1(66.86,105.41)
  TOP w0.762: 48.04,95.49 48.04,95.17 49.24,93.97 51.27,93.97 ; 64.96,99.98 63.36,98.38 63.36,97.5 62.83,96.96 61.94,96.96
  IN1 w0.508: v1(67.63,125.59) 67.63,125.11 68.63,124.1 68.63,122.15 69.8,120.98 70.45,120.98 71.8,119.62 71.8,116.54 70.19,114.93 70.19,113.88 67.7,111.39 67.7,105.92 67.19,105.41 v1(66.86,105.41)
  IN1 w0.762: 49.29,55.94 50.05,56.7 50.05,58.51 48.73,59.83 48.73,60.9 44.41,65.21 44.41,69.66 46.54,71.79 46.54,72.86 46.14,73.27 46.14,74.33 47.81,76.01 48.7,76.01 50.02,77.33 50.02,94.91 49.31,95.62
  vias: v1(47.61,96.25) v1(48.27,96.28) v2(48.22,55.33) v2(48.7,54.8)
+VDDQ_VTT: length 135
  TOP w0.508: C2080.1 C2066.1 R2102.1 R2103.1 R2106.1 R2105.1 35.91,99.78 R2107.1 37.91,99.78 R2104.1 ; R2137.1 28.94,63.23 v1(28.56,63.61)
  IN2 w0.508: v1(30.62,32.14) 30.62,31.33 32.52,29.42 39.51,29.42 40.12,28.82 44.11,28.82 44.61,28.31 45.32,28.31 45.93,28.92 47.2,28.92 v1(48.3,30.01) v1(48.93,30.01)
  IN2 w0.762: 38.98,109.21 37.17,107.4 24.55,107.4 19.54,102.4 19.54,97.13 ; 51.95,113.27 52.61,113.93 58.86,113.93 60.23,115.3 65.68,115.3 67.35,116.97 67.35,117.72 68.39,118.76
  BOTTOM w0.508: v1(28.36,86.78) 27.44,85.86 27.44,84.01 29.12,82.33 29.12,81.01 29.45,80.68 29.45,76.49 29.14,76.18 29.14,74.69 29.51,74.32 29.51,72.82 29.12,72.43 29.12,64.17 v1(28.56,63.61) 29.12,63.05 29.12,58.7 27.93,57.51 27.93,54.06 27.49,53.63 27.49,44.61 27.8,44.31 27.8,41.54 28.71,40.63 28.71,39.23 29.73,38.21 29.73,33.59 30.62,32.7 v1(30.62,32.14)
  vias: v1(18.35,96.53) v1(18.88,96.1) v1(69.3,119.19) v1(69.28,118.55)
+VDDQC: length 13.2
  TOP w0.508: C2255.2 81.92,48.85 v4(82.41,48.85)
  IN1 w0.508: v2(80.83,58.9) 80.83,58.73 81.6,57.96 81.6,49.35 82.1,48.85 v4(82.41,48.85)
  BOTTOM w0.254: v2(80.83,58.9) 81.11,58.62 U2030.AM40
  BOTTOM w0.305: v4(82.41,48.85) 81.6,48.85 U2030.AL23
+VIN: length 60.8
  TOP w0.198: PR2.1 54.12,114.01 52.62,114.01 52.05,114.58 52.05,116.16 52.21,116.32 PR3.2
  TOP w0.254: v1(122.19,125.61) 122.19,124.94 PR9102.1
  IN2 w0.254: v1(122.19,125.61) 122.1,125.7 107.93,125.7 107.58,125.35 98.41,125.35 92.79,119.72 89.03,119.72 85.07,123.68 73.85,123.68 72.27,125.26 v2(72.27,125.61)
  vias: v1(54.81,116.93) v1(55.43,117.66) v1(55.43,117.03) v1(55.43,116.39) v1(56.07,117.66) v1(56.07,117.03) v1(56.07,116.39) v1(56.7,117.72) v1(56.73,117.08) v1(56.73,116.45) v1(64.82,120.89) v1(64.82,120.26) v1(64.82,119.62) v1(64.83,118.99) v1(79.39,14.08) v1(80,14.29) v1(80.33,14.85) v1(80.42,104.89) v1(80.61,15.43) v1(80.63,14.08) v1(81.05,104.89) v1(81.69,104.89) v1(82.32,104.89) v1(82.98,104.89) v1(118.73,38.49) v1(118.73,37.86) v1(118.73,37.22) v1(121.49,73.91) v1(122,74.43) v1(122.57,75.02) v1(123.24,75.59) v1(123.78,76.15) v1(125.36,46.77) v1(126.25,46.77) v1(127.14,46.77) v1(127.72,36.3) v1(128.03,46.77) v1(128.13,36.89) v1(128.1,35.61) v1(128.39,36.29) v1(128.78,36.9) v1(128.76,35.63) v1(128.92,46.77) v1(129.11,36.26) v1(129.4,35.66) v1(130.21,46.09) v1(130.49,46.67) v1(130.85,46.09) v1(131.13,46.67) v1(131.48,46.09) v1(132.35,73.21) v1(132.35,72.55) v1(132.73,71.92) v1(132.73,71.28) v1(132.98,73.21) v1(132.98,72.55) v1(133.62,73.21) v1(133.62,72.55) v1(138.1,63.88) v1(138.74,63.88) v1(141.03,35.62) v1(141.64,35.37) v2(70.59,125.61) v2(71.45,125.6)
+VIN_BLIGHT:
  vias: v1(63.94,108.22) v1(63.92,107.56) v1(64.48,107.81) v1(64.55,108.52)
AVDD2: length 3.9
  BOTTOM w0.203: L28.2 209.74,33.64 209.54,33.84 208.58,33.84 208.36,33.63 U20.40
  BOTTOM w0.508: C845.1 210.12,34.53 210.03,34.44 L28.2
DVDD_IO: length 3.3
  BOTTOM w0.203: v2(203.07,27.69) 203.07,28.4 203.66,28.99 U20.9
  BOTTOM w0.305: v2(203.07,27.69) 202.29,26.91 C584.1
GND: length 1760
  TOP w0.102: TP9052.1 17.13,54.92 v1(17.13,54.67) ; v1(16.01,50.81) 15.73,51.08 15.73,51.76 TP9056.1 ; v1(16.65,33.97) 16.47,33.97 TP9069.1 ; 17.24,34.43 17.06,34.6 TP9063.1 ; v1(16.46,37.75) 16.04,37.33 TP9074.1 ; CN3.4 14.6,31.38 TP9068.1 ; TP9072.1 16.4,36.1 v1(16.57,36.1) 16.88,36.1 17.1,35.89 TP9066.1 ; TP9054.1 16.17,55.96 v1(16.13,56) 16.05,56.08 TP9060.1 ; v1(15.75,53.47) 15.77,53.47 15.8,53.45 TP9057.1 ; v4(93.65,61.72) 93.65,61.72 C2207.1 ; TP9062.1 16.05,57.53 v1(16.18,57.66)
  TOP w0.203: PU9002.11 22.54,95.39 22.69,95.54 v1(22.69,95.62) ; 17.77,54.8 17.77,54.8 17.6,54.63 17.17,54.63 v1(17.13,54.67) ; 17.77,54.8 17.77,55.15 18.04,55.43 U16.8 ; 17.77,54.8 17.93,54.63 U16.9 ; v1(20.61,34.68) 20.51,34.58 U17.3 ; v1(47.39,16.31) 47.61,16.09 C6606.1 ; v1(128.51,16.55) 128.51,17.08 C745.1 ; v1(13.1,78.51) 13.32,78.51 D13082.1 ; v1(214.82,10.82) 214.68,10.68 R25485.2 ; v2(190.99,11.97) 190.99,13.08 191.25,13.34 U37.49 ; R25311.2 200.83,15 v1(200.81,15.02) ; PU6001.11 PU6001.15 ; C2363.1 R2302.2 63.05,29.43 63.72,28.76 R2309.1 ; C6600.2 C6602.2 209.06,13.7 v1(209.34,13.43) ; v1(13.14,76.19) 13.77,76.19 D13085.1 ; v2(202.75,24.7) 202.75,24.55 202.4,24.2 202.14,24.2 201.86,23.91 200.91,23.91 200.11,24.71 200.11,25.11 199.89,25.33 199.89,25.98 199.69,26.18 U37.91 ; D13086.1 13.38,74.29 13.14,74.53 v1(13.14,74.92) ; U37.27 182.4,17.78 182.14,17.51 180.01,17.51 179.73,17.23 v2(179.73,16.79) ; R2219.2 v1(35.52,32.73) ; PU6002.11 v1(20.23,27.27) ; PU26.26 67.06,119.7 v1(67.14,119.62) ; v1(46.85,112) 46.65,111.81 C638.1 46.65,110.74 v1(46.49,110.58) ; U16.3 20.73,55.03 v1(20.86,54.9) ; PU26.28 66.79,120.5 ; Q6554.1 85.08,95.77 84.88,95.57 84.62,95.57 84.3,95.24 v1(84.3,94.91) 84.64,94.57 C20021.2 ; v1(140.65,56.37) 141.03,56.76 PC7003.1 ; v1(13.27,79.36) 13.66,79.75 D13081.1 ; U37.1 182.27,28.18 v2(182.02,28.43) ; R2203.2 63.23,47.87 63.37,47.72 63.95,47.72 v2(64.1,47.87) ; v1(34.1,3.26) 34.1,3.3 34.25,3.45 34.54,3.45 34.69,3.31 C786.1 ; U37.104 194.45,30.62 194.27,30.8 v2(194.27,30.98)
  TOP w0.254: v1(175.91,18.58) 176.69,18.58 R890.2 ; v2(34.98,47.05) 35.79,47.05 36.57,46.27 36.57,44.78 U2012.N1 ; v2(37.05,37.9) 37.05,37.96 36.72,38.28 U2012.N9 ; v4(79.48,46.1) 79.8,45.78 R2199.2 ; U2012.D8 v2(43.47,38.68) U2012.E8 ; C6573.2 184.77,31.28 v2(184.42,30.92) ; PC276.2 64.37,125.42 v1(64.37,125.59) ; R25298.2 178.26,21.2 v1(178.27,21.2) ; v2(33.48,58.3) 33.89,57.89 U2011.T1 ; C6562.1 178.87,23.1 179.12,22.84 179.94,22.84 180.44,22.34 C6571.2 ; U2012.H1 40.67,45.45 41.31,46.1 v2(41.31,46.22) ; PR6012.2 141.1,31.21 141.9,30.42 141.9,29.58 v1(141.97,29.5) ; R2558.2 97.52,33.51 v1(97.57,33.56) ; C2280.1 82.21,46.09 81.4,45.28 v4(81.4,45.25) ; v1(164.65,18.02) C731.2 ; v2(193.69,30.98) 193.69,31.18 194.02,31.51 R25316.2 R25303.2 194.17,32.88 v2(194.22,32.93) ; v1(82.33,60.75) 82.33,60.69 81.74,60.1 C2188.2 ; U2010.K1 39.43,79.66 v2(39.43,79.7) 39.47,79.74 40.22,79.74 U2010.H1 ; Y4.4 46.38,112.47 v1(46.85,112) 46.85,112.51 46.8,112.56 46.8,114.13 46.62,114.31 43.9,114.31 43.65,114.06 v1(43.65,112.86) ; U32.10 56.08,16.94 55.92,16.78 v1(55.92,15.02) ; C354.2 111.27,108.2 110.76,107.7 110.76,107.58 ; v1(27.35,8.24) 27.35,8.76 EC11.2 ; R654.1 22.19,8.22 v1(22.21,8.24) ; R2186.2 64.86,62.39 v2(64.86,62.19) ; C6565.2 200.67,26.3 v2(200.52,26.45) 200.43,26.54 C2607.2 ; U2009.K1 39.07,92.63 v2(39.44,93) ; v1(49.85,18.86) 49.85,18.86 50.1,18.6 R589.1 51.21,18.87 C6604.2 ; U42.18 U42.21 ; U42.21 U42.3 ; U42.21 U42.13 ; U2010.K9 38.66,73.3 v2(38.66,73.34) ; U33.16 123.94,22.21 ; PC268.1 60.49,125.46 v1(59.97,124.95) ; v2(191.26,31.97) 191.32,31.92 191.32,31.85 191.63,31.54 C6575.2 ; 66.79,120.5 66.9,120.61 67.32,120.61 v1(67.37,120.67) 67.47,120.77 PR253.1 ; v4(92.06,37.14) 91.81,37.39 C2599.2 ; v2(37.14,72.41) 36.67,72.87 U2010.N9 ; C512.2 19.67,40.27 v1(19.26,39.86) ; U2012.K9 39.56,37.79 v2(39.56,37.68) ; v4(79.51,62.64) 79.84,62.98 81.45,62.98 C2174.1 ; v1(57.42,15.02) 57.42,16.29 57.08,16.63 U32.12 ; v1(67.85,114.12) 67.91,114.17 68.68,114.17 69.17,113.69 PC9023.2 ; v2(35.4,80.66) 35.84,80.66 36.67,79.83 U2010.N1 ; v1(169.68,19.51) 169.68,19.09 C726.2 169.86,18.71 170.11,18.46 170.62,18.46 170.72,18.56 C721.2 C724.2 ; U2009.T1 33.76,93.07 v2(33.76,93.1) ; C20024.2 151.39,22.05 152.77,22.05 v1(153.3,21.53) ; C804.2 194.96,12.21 194.65,11.9 193.53,11.9 193.18,12.25 C6569.2 C6570.2 192.9,10.56 v2(192.92,10.53) ; v2(63.89,38.87) 63.51,38.87 R2609.1 ; v1(37.25,26.94) 37.25,27.24 PC561.2 ; v1(38.37,4.86) 38.72,4.86 C785.1 ; v2(39.5,51.88) 39.46,51.88 U2011.K9 ; v1(22.59,13.22) 22.22,12.85 Q6519.1 ; U36.3 149.81,20.24 149.24,19.67 v1(149.24,19.54) 149.24,18.78 149.01,18.56 C733.2 C732.2 ; C6578.2 C6577.2 180.35,17.82 180.02,18.15 179.11,18.15 v2(179,18.26) ; PR230.2 138.65,34.31 139.13,34.78 v1(139.38,34.78) ; 124.44,19.21 U33.23 122.57,19.21 122.31,18.95 122.31,18.63 122.09,18.4 C741.2 C744.2 ; v1(96.72,35.03) 96.7,35.05 R2559.2 ; v2(34.91,59.6) 36.11,59.6 36.67,59.03 U2011.N1 ; C6574.2 186.6,31.91 186.37,32.14 v2(186.37,32.55) ; U2019.3 62.61,33.02 63.13,32.49 64.27,32.49 64.5,32.72 C2369.1 64.88,33.36 v1(64.98,33.46) ; v2(36.24,51.06) U2011.N9 ; U32.13 57.58,16.87 58.05,16.39 v1(58.05,15) ; U23.17 19.01,75.58 18.96,75.53 18.5,75.53 17.91,74.93 C618.1 ; v1(40.3,26.86) 40.14,27.01 40.14,27.04 39.86,27.32 39.84,27.32 39.83,27.32 PC581.2 ; v4(79.44,43.41) 79.13,43.72 R2204.2 ; v2(179.57,24.81) 179.92,24.47 C1190.2 180.01,24.19 181.27,24.19 C1189.2 ; v2(57.62,24.22) 56.99,23.59 C6605.2 56.99,23.12 55.58,21.71 U32.5 ; v1(43.65,112.86) 43.83,112.69 43.83,111.67 44.1,111.4 C639.1 ; v1(43.65,112.86) 44.35,113.57 Y4.2 ; U2014.3 110.74,32.13 v1(110.81,32.19) ; C6563.2 182.17,32.13 v2(182.21,32.17) 182.51,32.17 R25320.2 ; C6599.2 C6598.2 C6601.2 216.19,16.91 v1(216.65,16.45) v1(216.65,15.81) ; v1(139.38,34.15) 139.47,34.24 PQ17.1 ; v1(165.54,18.02) C725.2 C727.2 ; PC9004.2 68.42,112.63 67.77,113.29 v1(67.77,113.49) ; v1(140.31,64.72) 140.31,64.76 139.86,65.21 PR9098.1 ; v2(44.25,72.48) U2010.C9 ; v1(65.7,125.59) 65.65,125.55 PC283.2 ; PC9013.2 71.29,116.58 71.29,116.74 70.35,117.69 69.22,117.69 v1(68.81,118.1) ; v2(45.86,86.52) 45.86,86.55 U2009.A8 ; v2(33.39,79.4) 34.16,79.4 U2010.T1 ; U2009.K9 v2(39.47,86.56) ; v2(208.1,18.05) R506.2
  TOP w0.305: v2(43.47,73.3) U2010.D8 ; C729.2 v1(162.88,18.02) ; v2(44.26,56.65) 43.87,57.04 U2011.D2 ; U2011.H1 40.22,58.34 v2(39.44,58.34) 39.07,57.97 U2011.K1 ; PC6017.1 143.98,33.41 v1(144.31,33.74) ; U2011.B2 v2(45.06,57.5) ; v2(131.41,112.61) 131.8,112.61 131.85,112.67 C480.1 ; U2011.C9 v2(45.07,51.09) ; U2009.B2 v2(45.07,92.16) ; v2(43.47,78.9) U2010.E1 U2010.F1 ; C730.2 v1(163.76,18.02) ; v2(37.04,85.77) 37.04,85.78 U2009.N9 ; U2012.K1 39.44,45.05 v2(39.44,45.13) ; v1(9.84,16.12) RV3.8 RV3.3 12,16.12 12.13,16.24 v1(13.14,16.24) ; v2(42.51,77.19) 42.56,77.19 U2010.E3 ; U2011.E3 43.07,55.71 v2(42.92,55.56) ; U2011.F1 42.36,57.89 42.48,58.01 42.95,58.01 U2011.E1 43.39,58.21 v2(43.39,58.36) ; U2010.E8 v2(42.67,73.3) ; v2(43.45,92.96) 43.45,92.8 43.21,92.56 U2009.E1 42.95,92.67 42.48,92.67 42.36,92.56 U2009.F1 ; U2012.C9 44.54,38.15 44.54,36.9 v2(44.37,36.72) ; Q6521.4 58.13,108.72 v1(58.13,108.06) ; U2010.B2 v2(45.07,78.9) ; v2(36.75,93.93) 36.67,93.85 U2009.N1 ; R2161.1 94.94,76.73 v4(95.28,76.73) ; U2010.A8 46.79,73.7 47.04,73.44 48.6,73.44 48.97,73.81 v2(48.97,73.95) ; U2012.F1 42.27,44.82 43.05,45.6 v2(43.11,45.6) ; U2012.B2 v2(45.07,44.28) ; C428.1 101.78,109.09 102.31,108.56 C402.2 ; U2009.A2 v2(46.69,91.33) ; U2012.D2 43.83,43.88 v2(43.47,44.24) 43.07,44.64 U2012.E1 ; U2009.H9 v2(41.08,86.56) ; U2010.H9 U2010.G8 v2(41.87,73.3) ; U14.14 17.93,48.88 17.77,49.03 17.18,49.03 16.82,49.4 R415.1 ; U2012.A8 46.27,39.05 v2(46.63,38.68) ; U2010.D2 v2(44.27,78.1) ; v4(83.18,46.74) 83.01,46.74 82.4,47.35 C2274.1 ; v2(33.46,44.68) 33.46,44.68 U2012.T1 ; U2009.E3 v2(42.68,91.35) ; U2009.D2 v2(44.27,91.36) ; U2009.E8 v2(43.47,86.56) U2009.D8 ; U2011.A8 45.86,51.88 v2(45.86,51.86) ; U2012.H9 40.88,38.49 40.88,38.5 41.47,39.08 U2012.G8 41.5,39.08 v2(41.9,38.68) ; v2(42.67,42.68) U2012.E3 ; U2011.E8 v2(43.47,51.89) U2011.D8 ; U2009.G8 v2(41.87,86.56) ; U2011.A2 46.27,57.04 v2(46.65,56.67) ; U2009.H1 v2(40.67,93.16) ; U2009.C9 v2(45.07,85.75) ; U2012.A2 v2(46.66,43.49) ; U2011.G8 v2(41.87,51.89) ; v2(41.85,50.41) 41.75,50.41 U2011.H9
  TOP w0.356: C496.1 131.3,87.12 v2(131.41,87.01) ; v1(136.21,101.58) Q20.1 ; v2(132.21,116.61) 131.6,117.22 C492.1 ; C477.1 128.2,105.42 v2(128.21,105.41) ; v2(133.81,115.81) 134.44,115.18 C481.1 ; C371.2 100.52,99.55 100.44,99.63 v2(100.44,99.66) ; C491.1 140.28,94.14 v2(140.21,94.21) ; v2(135.41,109.46) 134.93,109.46 C482.1 ; C478.1 139.26,86.81 139.26,86.35 v2(139.41,86.21) ; C495.1 130.78,108.47 131.24,108.47 v2(131.41,108.64) ; C475.2 126.21,105 v2(126.63,105.42) ; v2(133.01,116.61) 133.61,117.21 C493.1 ; v2(128.21,86.21) 128.08,86.34 C483.1 ; v2(138.61,113.41) 138.62,113.4 C498.1 ; C501.2 135.99,90.21 v2(135.41,90.21)
  TOP w0.381: v1(104.34,17.26) 104.34,16.02 ; 104.34,16.02 103.95,15.63 PC11.2 ; 104.34,16.02 PC10.2 ; PC7023.2 145.64,53.34 v1(145.27,53.71) ; C374.1 108.78,104 v2(109.41,103.36) ; v2(101.28,103.2) 101.07,102.98 C459.1 ; v1(25.84,90.03) 25.24,90.03 PC9054.2 ; v2(106.61,104.31) 106.61,104.19 105.99,103.57 C415.1 ; v2(41.85,50.41) 41.85,49.24 41.35,48.75 R2191.2 ; v2(106.36,99.02) 106.36,100.11 v2(106.48,100.23) ; v2(106.36,99.02) 106.36,98.54 106.61,98.28 C453.1 ; v2(106.36,99.02) 105.88,99.02 105.46,99.44 C386.1 ; C386.1 104.65,99 C380.1 C375.1 C378.2 C371.2 ; C386.1 104.53,100 v2(104.53,100.23) 104.45,100.23 C421.1 103.96,100.87 v2(103.56,101.26) ; v1(26.22,26.78) 25.82,26.38 PC6052.2 ; v4(94.34,56.2) 94.76,55.78 C2270.1 95.69,55.78 v4(95.91,56.01) 96.23,56.33 C2177.1 ; v1(82.31,51.6) 82.58,51.33 82.73,51.33 C2248.2 83.09,51.32 C2240.2 ; C2064.2 37.83,101.33 v1(37.22,100.72) ; v2(55.39,33.2) 55.39,32.56 C2343.2 ; C2295.2 C2301.1 63.84,41.74 v2(63.52,41.42) ; C2352.2 88.62,30.09 88.89,29.83 v2(89.22,29.83) ; C457.1 100.25,100.3 v2(99.86,99.91) ; v2(52.78,63.09) 52.78,62.47 C2228.1 ; C695.2 65.86,20.81 66.28,21.22 v1(66.28,21.32) ; C379.1 119.96,117.66 C377.1 120.4,117.52 v1(120.93,118.05) ; v2(129.03,90.22) 128.98,90.28 C502.2 ; C6610.1 178.86,21.2 v1(178.27,21.2) ; v1(105.7,29.04) 105.7,29.24 C2321.1 ; PC6009.2 149.39,35.19 148.76,35.82 148.76,35.82 v2(148.75,35.81) ; v2(56.3,90.83) 56.28,90.81 56.28,90.23 C2106.2 ; v1(27.09,5.07) 26.53,5.62 EC10.2 ; v2(89.24,100.52) 89.24,100.75 90.07,101.58 C392.2 ; v2(104.53,104.23) 104.81,104.51 C357.1 ; C675.1 9.69,21.88 v1(10.25,22.44) 10.7,21.98 C676.1 ; Q81.1 25.9,39.67 25.44,39.2 C1044.2 ; v2(102.64,104.35) 102.56,104.27 C365.1 C418.1 103.01,102.73 v2(103.53,103.25) 103.95,102.84 C408.1 104.11,102.74 104.52,102.33 104.52,102.26 v2(104.54,102.24) 104.56,102.22 C373.1 105.21,101.85 105.53,101.53 v2(105.53,101.39) 105.86,101.06 C407.1 106.17,100.51 106.2,100.51 v2(106.48,100.23) ; v1(175.69,23.48) 175.69,23.96 175.81,24.09 Q6509.1 ; v2(181.67,30.36) 181.69,30.35 D65.2 C6572.2 ; v1(214.82,14.72) 214.69,14.85 R497.2 ; C458.1 97.37,100.54 v2(97.13,100.78) ; v2(107.57,101.27) 107.89,100.94 C352.1 ; C394.2 98.02,99.41 97.7,99.73 97.46,99.73 v2(97.14,100.05) ; Q6519.4 23.54,11.32 23.05,10.83 23.02,10.83 v1(23,10.81) ; v2(109.41,103.36) 109.45,103.36 C444.1 109.92,104.88 C439.1 109.84,104.89 v2(109.41,105.32) 109.41,105.4 C448.1 109.91,106.02 110.76,106.88 C372.1 110.76,107.58 110.32,108.02 C366.2 110.24,108.15 109.66,108.72 v2(109.66,108.83) 109.59,108.75 109.09,108.75 108.94,108.6 C399.2 ; v2(109.41,103.36) 109.8,102.98 C353.1 ; v2(106.27,111.63) 106.37,111.53 C20003.1 ; J2000.2 53.69,25.56 55.31,25.56 55.43,25.69 C2419.2 55.83,25.91 56.64,26.72 C2418.2 56.64,27.82 v1(56.5,27.95) ; C443.1 108.75,100.44 v2(108.42,100.11) 109.02,99.51 C447.1 109.02,99.17 C455.1 ; v1(52.54,106.21) 52.63,106.3 C6616.1 ; C526.1 24.04,33.9 24.18,34.05 v1(24.73,34.05) ; R510.1 49.66,102.45 v1(50.15,102.45) ; v2(107.77,99.22) 107.77,99.15 108,98.92 C449.1 ; R2563.1 90.38,33.11 v1(90.31,33.18) 90.08,33.18 89.61,32.72 R2227.2 ; PR120.2 26.41,28.34 v1(26.38,28.31) PC6053.2 PC6051.2 ; v1(86.92,99.84) 86.99,99.78 87.48,99.78 R394.2 ; Q6521.1 56.61,110.19 56.1,110.69 v1(56.1,110.79) ; C505.2 134.44,98.03 134.94,98.53 v1(134.94,98.67) 134.55,99.05 R410.1 ; C2353.2 51.43,30.09 51.5,30.01 v2(51.6,30.01) 51.62,29.99 R2279.2 ; v1(61.4,112.05) 61.75,112.4 Q6522.1 ; v1(146.54,49.87) 146.43,49.87 PC7009.2 ; v1(67.22,30.92) 67.17,30.92 66.28,30.03 C2348.1 ; R678.2 148.67,25.5 148.48,25.69 v2(148.48,26.38) 148.48,26.62 148.18,26.92 R679.1 ; PC6229.1 162.49,25.89 PR283.2 161.77,25.61 v2(161.77,24.98) ; v1(71.17,20.13) 71.11,20.06 71.11,19.48 C699.2 ; C614.2 C613.2 22.58,64 20.89,62.32 v1(20.45,62.32) ; C454.1 C353.1 ; C353.1 109.8,102.27 C445.1 108.62,102.23 108.51,102.23 v2(108.5,102.24) 107.89,102.85 C351.1 ; v2(106.48,100.23) 106.48,100.21 C450.1 ; C2121.1 97.27,80.59 v1(97.27,80.87) ; C2309.1 101.51,44.39 C2308.1 101.19,44.39 v1(100.7,44.88) 99.99,44.88 C2292.1 ; C696.2 76.07,19.56 75.69,19.94 v1(75.69,20.14) ; C2601.1 67.53,24.24 C2603.2 67.05,26.11 v1(67.19,26.25) ; v1(58.13,108.06) 58.08,108.02 R442.2 ; C409.1 101.19,104.89 v2(100.6,104.3) ; v1(90.77,80.67) 90.65,80.67 90.03,81.29 C2150.1 ; PC152.2 v1(124.17,57.96) ; C2335.1 104.46,25.86 104.53,25.79 ; C2209.2 56.18,89.5 v2(56.15,89.53) ; v1(22.13,46.57) 23.45,46.57 R416.2 ; v1(43.29,26.87) 43.73,27.31 PR567.1 ; v1(112.51,84.26) 112.51,83.53 112.88,83.15 R352.1 ; v1(35.49,119.37) 35.49,120.23 34.9,120.82 HE1.3 ; v2(106.63,102.31) 106.63,102.3 107.09,101.84 C369.1 ; C461.2 98.61,103.14 98.01,103.74 C419.2 ; PC9000.2 79.5,111.03 79.06,111.47 v1(78.55,111.47) 78.47,111.47 78.11,111.11 PR9034.2 ; v2(99.86,99.91) 99.37,99.91 99.05,99.59 C401.2 ; v2(99.86,99.91) 100.19,99.91 v2(100.44,99.66) ; v4(84.82,46.74) 84.53,47.04 C2275.1 ; D33.1 151.17,20.25 v1(151.17,19.52) ; v2(196.68,32.37) 196.46,32.15 C6580.1 ; v1(100.52,101.33) 100.4,101.45 C460.1 ; PC9062.2 PC9063.2 ; v1(112.52,85.2) 111.77,85.2 111.47,84.89 111.47,83.65 110.91,83.09 R350.1 R351.1 ; R2194.2 105.57,50.08 v1(106.08,49.57) 106.48,49.57 C2580.1 ; v1(42.76,116.14) 42.48,115.86 C20000.2 ; 42.81,99.48 43.11,99.77 C643.2 C641.2 ; C6568.1 194.41,11.08 v2(194.41,10.53) ; C518.1 23.6,54.22 v1(23.49,54.33) ; C2171.2 41.63,83.2 v2(41.63,83.43) ; v1(22.67,59.14) 22.49,59.14 22.2,59.43 C522.2 ; v4(80.81,50.66) 81.57,49.9 C2255.1 ; R749.2 16.62,83.37 v1(16.34,83.09) ; v1(82.32,55.26) 81.99,54.93 C2211.1 ; v1(53.05,108.8) 53.05,109.26 C548.2 ; R25270.2 59.76,110.1 v1(59.76,110.76) 59.76,111.14 R25369.2 ; v2(52.29,92.66) 52.29,92.44 52.78,91.95 C2136.1 ; R2221.2 39.45,33.22 C2317.2 ; C743.2 129.96,19.67 130.47,20.19 v1(130.47,20.41) D22.1 ; v1(36.43,100.72) 36.43,101.02 C2065.2 ; C398.2 97.83,97.67 v2(97.13,98.37) ; v4(80.8,51.59) 80.8,51.48 81.36,50.92 C2246.1 ; v2(206.08,15.4) 206.13,15.4 R504.2 206.68,14.96 R1235.2 ; PC299.2 68.16,118.35 68.14,118.33 PC285.1 68.46,117.74 v1(68.81,118.1) ; C550.2 60.96,99.42 C545.2 ; v2(202.46,18.53) L11.2 ; C2342.2 56.58,32.48 v2(56.58,33.22) ; v2(102.64,106.34) 102.33,106.03 C432.1 ; v1(98.69,30.24) 98.69,30.74 98.32,31.11 R2585.1 ; C2229.1 81.87,53.88 v1(82.32,53.43) ; C376.2 100.32,95.98 v2(100.49,95.81) ; R1236.2 206.68,17.17 206.26,17.58 v2(206.14,17.58) ; v4(89.04,37.15) 89.35,36.84 R2207.1 ; C20002.1 106.06,107.71 105.68,107.33 v2(105.59,107.33) 105.2,106.93 C406.1 ; v2(45.66,49.65) 45.57,49.65 R2190.2 ; C2360.2 102.15,31.88 102.65,31.38 R2580.1 103.35,30.87 v1(103.64,31.16) ; v2(37.35,84.02) 38.53,82.83 C2135.2 ; v2(51.64,43.98) 51.52,44.1 C2251.2 ; Q2013.1 64.21,47.98 v2(64.1,47.87) ; PR9104.2 119.53,123.69 C20006.1 120.3,123.94 v1(120.36,123.89) ; C2266.1 28.79,44.92 v2(28.61,44.74) ; C364.2 98.03,111.58 v2(97.18,111.58) ; v1(26.15,33.13) 26.15,32.63 PQ16.1 ; v1(64.15,27.29) 64.19,27.29 C2347.1 64.81,27.91 C2598.2 64.17,28.76 64.16,28.74 R2309.1 ; v2(103.48,107.18) 103.44,107.14 C413.2 104.51,106.25 v2(104.53,106.23) ; C430.1 101.78,101.56 101.41,101.18 v2(101.41,101.17) ; C6583.1 v1(17.05,6.29) ; v2(107.4,105.23) 107.44,105.27 C412.1 ; C616.2 v1(11.46,85.34) ; v1(28.94,3.26) 29.36,2.84 R2660.2 ; v2(107.4,107.11) 107.4,107.01 C367.1 ; v1(166.54,24.88) 166.23,24.88 165.96,24.6 PC229.2 165.96,24.02 165.54,23.61 v1(164.78,23.61) ; PC562.2 34.54,27.62 v1(33.42,27.62) ; C636.2 44.35,109.65 44.35,110.54 v1(44.38,110.58) ; C368.1 101.27,106.97 v2(100.62,106.32) ; C2579.1 101.05,46.91 v1(100.99,46.97) ; v2(104.59,110.83) 103.81,110.04 C20004.2 ; C513.1 24.06,51.67 24.06,51.67 v1(22.86,51.67) ; C424.1 109.15,107.56 v2(109.41,107.29) ; v1(51.5,102.42) 51.27,102.65 C546.1 ; C533.2 21.48,38.73 21.02,38.26 v1(21.02,37.81) ; Q34.1 v1(11.74,5.2) ; C585.2 202.75,29.22 C596.2 v1(202.75,30.69) ; R2223.2 v2(43.14,32.51) ; v1(11.12,20.2) 11.02,20.1 D18.1 11.44,19.47 11.63,19.65 D16.1 C691.1 ; C2145.1 96.67,77.5 v4(96.59,77.57) 96.66,77.64 PR7052.2 ; C2198.1 93.21,57.07 v4(93.6,57.07) 93.69,56.99 C2235.1 ; R2197.1 77.63,46.55 78.07,46.1 v4(78.18,46.1) ; C597.1 212.37,28.47 v1(212.28,28.56) ; C411.1 v2(102.45,100.11) ; C521.2 22.38,56.53 v1(22.67,56.53) ; v1(55.18,105.62) 55.4,105.84 C558.2 ; C1210.2 202.69,21.67 202.28,22.07 C1208.1 202.36,22.59 v2(202.36,23.55) ; v2(116.01,104.13) 116.01,104.6 116.68,105.27 118.17,105.27 118.81,104.63 R317.2 ; v1(10.43,12.38) 11.06,13.02 C692.1 D17.1 ; C494.1 131.41,91.8 v2(131.41,91.81) ; C484.2 138.67,109.47 v2(138.61,109.41) ; C395.2 103.37,107.94 v2(102.52,107.94) 102.49,107.97 C402.2 ; v2(105.6,105.12) 105.99,105.51 C410.1 105.99,105.69 v2(106.53,106.23) ; PC293.2 52.38,124.28 52.59,124.07 v1(53.1,124.07) ; v1(17.27,73.93) 17.5,74.15 C618.1 ; PC9014.1 72.1,106.12 v1(72.1,105.65) ; C2063.2 31.19,100.75 v1(31.25,100.75) ; PC7087.1 93.43,79.58 R2160.1 92.47,78.62 92.47,78.14 92.02,77.69 v4(91.88,77.69) ; v1(31.56,12.08) 31.56,11.82 PQ12.1 ; v1(207.45,10.51) C6607.2 ; v1(16.01,50.81) 16.65,51.46 C510.1 ; D6542.2 v1(15.66,8.9) ; C440.1 123.25,94.1 v1(123.25,94.6) ; C506.2 v1(132.26,103.75) R25282.1 ; v2(55.79,45.22) 55.79,45.46 C2252.2 ; v1(78.83,24.9) 78.69,25.04 R2651.1 ; v1(96.51,30.09) 96.56,30.14 R2560.1 ; C383.1 116.64,117.4 v1(116.45,117.21) ; R2213.2 80.16,25.25 79.84,24.93 79.82,24.93 v1(79.79,24.9) ; D19.1 13.54,13.61 v1(13.12,14.03) ; R2222.2 v2(44.28,32.52) ; Q6515.1 v1(14.14,9) ; v1(23.29,85.89) C619.2 ; v1(178.38,24.85) 178.38,23.84 C6562.1 ; PC7007.2 146.1,50.52 v1(146.61,50.52) ; PR118.2 v1(6.83,23.65) ; C2128.1 C2119.1 91.43,81.33 v1(90.8,81.33) ; C2374.2 181.16,19.03 v2(181.42,19.29) ; R2577.1 v1(92.16,30.62) ; R1234.2 v1(215.71,14.72)
  TOP w0.457: C500.2 137.74,116.68 v2(137.81,116.61) ; v2(137.01,105.41) 137.01,105.4 C442.1 ; C441.1 140.21,105.4 v2(140.21,105.41) ; v1(121.09,94.58) 120.61,94.09 R319.1
  TOP w0.508: R499.2 213.14,12.42 v1(213.04,12.32) ; C2110.2 51.3,88.02 v2(51.54,87.78) ; v2(56.49,35.22) 56.49,35.62 C2339.2 ; C2132.2 52.37,86.93 52.76,87.32 v2(52.76,87.77) ; C2167.1 33.49,63.48 v2(33.62,63.62) ; C2306.2 61.43,80.68 61.17,80.43 v2(61.17,80.17) ; C2265.1 78.81,49.75 v2(78.84,49.78) ; v2(48.63,58.38) 49.1,58.85 C2289.2 ; PQ9084.1 121.77,122.15 v1(122.06,121.86) ; v1(109.51,16.93) 109.41,17.03 PD4.2 ; PC7096.1 120.79,78.2 v1(120.79,77.76) ; C2066.2 C2080.2 30.39,98.88 v1(30.39,98.31) ; v2(56.51,76.72) 56.51,77.16 C2157.2 56.29,77.75 C2153.2 ; v2(52.8,85.47) 52.8,85.05 52.57,84.82 R2138.2 ; v1(66.23,106.16) 66.23,107.18 C536.2 C537.2 ; C6582.1 16.95,16.89 v1(16.49,17.35) ; C2085.2 36.8,97.61 36.8,97.61 36.79,97.61 C2086.1 35.72,97.91 v1(35.72,98.28) ; v1(107.96,17.16) 107.96,17.9 PD3.2 ; C2104.1 30.09,80.12 C2105.2 30.44,79.08 30.76,79.4 v2(33.39,79.4) ; C2334.2 52.23,39.97 v2(52.23,40.5) ; PC9060.2 v1(23.91,89.19) ; PR7061.2 114.57,45.76 v1(113.98,46.34) ; PC9059.2 v1(22.9,89.19) ; v2(61.94,80.17) 62.54,80.78 R2142.2 R2132.2 ; R2134.2 51.2,85.84 v2(51.57,85.46) ; v1(23.07,97.65) 23.43,97.29 PC9063.2 ; C2166.2 v2(34.63,63.67) ; v1(20.35,89.19) 20.39,89.19 20.9,89.7 PC9053.2 ; R748.2 R507.2 20.89,84.87 v1(20.92,84.9) ; C20023.1 103.06,47.07 102.9,46.91 C2579.1 ; v1(22.69,35.8) 22.28,35.8 C532.2 ; C1044.2 24.94,39.85 v1(24.75,40.04) ; C2088.2 34.54,97.59 33.97,98.16 v1(33.97,98.26) ; C414.2 106.37,109.48 C20003.1 ; v2(35.86,49.36) 36.23,49.36 36.96,48.64 C2191.1 ; PC7084.2 123.76,78.52 124.47,79.23 ; v2(91.23,108) 90.78,108.44 C429.1 90.24,108.1 89.98,107.83 C462.2 ; v2(40.25,46.84) 39.8,47.29 C2230.1 ; C2131.2 C2124.2 v2(28.41,70.22) ; R415.1 15.62,49.4 v1(15.56,49.47) ; C545.2 60.96,98.45 61.33,98.08 v1(61.33,97.74) ; v2(126.43,92.06) 126.62,92.26 C479.1 ; PC9064.2 v1(21.88,89.19) ; v1(85.28,32.06) 85.41,31.93 85.41,29.6 85.69,29.31 C2357.2 85.99,29.26 85.99,28.6 C2358.2 ; C438.1 121.75,94.1 v1(121.75,94.6)
  IN1 w0.102: 76.99,42.7 76.99,42.85 77.09,42.95 77.62,42.95 78.09,43.41 v4(79.44,43.41)
  IN1 w0.127: v4(79.48,46.1) 79.96,46.59 81.56,46.59 81.88,46.27 81.88,45.74 v4(81.4,45.25) 81.4,45.14 81.01,44.76 79.72,44.76 79.49,44.53 v4(79.49,44.29) 79.49,43.47 v4(79.44,43.41)
  IN1 w0.254: 76.99,42.7 76.5,42.21 v4(76.5,38.85) 76.5,37.67 77.09,37.08 v1(77.09,34.93) 77.23,34.79 77.23,34.74 77.51,34.46 77.51,33.59 77.79,33.31 77.79,32.56 77.53,32.31 76.36,32.31 76.11,32.56 76.11,34.12 75.35,34.89 v1(75.35,35.13) 75.35,36.59 75.08,36.85 75.08,42.39 v4(76.36,43.67) 76.36,45.76 v4(76.49,45.89) 76.71,46.1 v4(78.18,46.1) v4(78.83,46.1) v4(79.48,46.1)
  BOTTOM w0.089: 96.41,35.74 96.41,36 96.57,36.16 96.57,36.45 96.35,36.67 96.35,36.9
  BOTTOM w0.102: v2(108,95.82) 107.59,96.23 U8.E17 ; v1(87.08,56.6) 87.56,56.6 87.62,56.65 v1(88.02,56.65) ; U2030.C1 96.41,35.74 ; 96.35,36.9 96.07,37.17 U2030.C5 96.07,38.64 96.4,38.96 96.4,39.32 96.28,39.43 96.2,39.51 96.19,39.51 96.18,39.52 95.91,39.52 95.74,39.35 95.74,39.04 95.38,38.68 U2030.D6
  BOTTOM w0.127: U2030.D34 95.29,55.88 94.76,55.35 94.37,55.35 U2030.F35
  BOTTOM w0.152: v2(74.16,69.58) 74.18,69.56 75.06,69.56 U2030.BB60
  BOTTOM w0.157: v2(73.68,52.06) 73.8,52.19 75.07,52.19 U2030.BB30
  BOTTOM w0.178: v2(83.8,77.14) 83.8,77.11 83.78,77.09 83.78,76.89 83.56,76.67 83.56,75.99 U2030.AG71 ; U2030.AT71 78.55,76.63 v2(78.68,76.76) ; U2030.BB26 75.07,49.83 73.97,49.83 v2(73.92,49.78) ; U2030.AV68 77.35,74.03 77.75,74.03 77.78,74 78.04,74 78.09,74.04 78.21,74.04 U2030.AT68 ; v2(74.29,59.67) 74.31,59.66 74.96,59.66 75.03,59.73 75.03,59.73 U2030.BB43 ; U2030.F4 U2030.F2 U2030.F1 ; U2030.H71 93.16,76.48 v4(93.26,76.59) ; U2030.BB34 75.07,54.82 73.32,54.82 v2(73.3,54.8) ; v2(74.14,57.17) 75.07,57.17 U2030.BB38 ; U8.P26 115.05,103.85 115.84,103.85 116.01,104.03 v2(116.01,104.13) ; U2030.BB55 74.09,66.94 v2(74.08,66.93) ; U2030.AM71 80.9,76.27 80.9,76.92 v2(80.74,77.09)
  BOTTOM w0.198: PC6.1 131.84,27.99 131.84,28.37 132.18,28.71 PU1.22 133.28,28.71 PU1.36
  BOTTOM w0.203: v1(137.73,60.44) 137.73,60.18 PC423.2 ; U2030.B39 96.74,58.02 97.26,58.02 97.29,58.05 97.54,58.05 97.75,57.84 97.8,57.84 ; v4(79.5,71.73) 79.16,71.4 U2030.AR63 U2030.AT63 ; PC7104.2 142.41,41.51 142.32,41.6 v1(141.72,41.6) ; PC7019.2 144.29,50.76 146.37,50.76 v1(146.61,50.52) ; PR10.2 109.64,21.64 PJ1.1 ; v1(13.17,82.07) 13.36,82.27 D13087.1 ; v1(99.78,75.17) 99.83,75.22 C2543.2 ; v1(13.14,74.92) 13.25,75.03 D13089.1 ; v1(13.14,76.19) 13.28,76.33 D13084.1 ; D13083.1 13.47,78.51 v1(13.1,78.51) ; U2030.AW21 77.02,47.67 77.05,47.7 77.05,47.99 77.02,48.02 U2030.AW23 77.02,48.99 77.05,49.02 77.05,49.32 77.02,49.35 U2030.AW26 77.02,50.12 77.05,50.15 77.05,50.61 77.02,50.64 U2030.AW28 77.02,51.4 77.05,51.43 77.05,51.88 77.02,51.91 U2030.AW30 77.02,52.67 77.05,52.71 77.05,53 77.02,53.03 U2030.AW32 77.02,53.88 77.07,53.93 77.07,54.27 77.02,54.32 U2030.AW34 77.02,55.2 77.05,55.23 77.05,55.53 77.02,55.56 U2030.AW36 77.02,56.43 77.05,56.46 77.05,56.75 77.02,56.78 U2030.AW38 ; U6502.3 v1(20.59,22.24) ; C734.2 199.26,19.68 199.26,20.64 199.06,20.84 R25506.1 ; PU6000.8 144.6,33.45 v1(144.31,33.74) 144.19,33.74 PC6022.2 ; 77.07,57.32 77.1,57.35 77.1,57.92 77.02,58 U2030.AW41 77.02,58.93 77.06,58.97 77.06,59.24 77.02,59.29 U2030.AW43 77.02,60.16 77.05,60.19 77.05,60.48 77.02,60.51 U2030.AW45 77.02,61.38 77.05,61.41 77.05,61.71 77.02,61.74 U2030.AW47 77.02,62.55 77.05,62.58 77.05,62.87 77.02,62.9 U2030.AW49 ; 77.07,57.32 U2030.AW38 ; 77.07,57.32 U2030.AW38 ; U2030.K70 91.8,74.84 91.91,74.74 U2030.K68 ; U2030.AT68 78.94,74.04 78.99,74 79.27,74 79.32,74.04 U2030.AP68 80.19,74.04 80.23,74 80.48,74 80.52,74.04 U2030.AM68 ; v1(135.5,51.17) 135.25,50.92 PC7063.2 ; v2(95.44,88.03) 95.54,88.12 R25552.1 ; D13088.1 13.78,79.87 v1(13.27,79.36) ; U2030.AW51 77.02,64.97 77.05,65 77.05,65.3 77.02,65.33 U2030.AW53 77.02,66.2 77.05,66.23 77.05,66.52 77.02,66.55 U2030.AW55 77.02,67.39 77.1,67.47 77.1,67.69 77.02,67.77 U2030.AW57 77.02,68.6 77.13,68.71 77.13,69.01 77.02,69.12 U2030.AW60 77.02,69.93 77.05,69.96 77.05,70.25 77.02,70.28 77.02,70.52 ; D13090.1 12.76,73.15 v1(12.59,72.98) ; U2030.B14 96.11,43.78 95.67,43.78 U2030.D14 ; v1(22.59,14.49) 22.96,14.86 U6503.12 ; U2030.AW62 77.02,71.15 77.05,71.18 77.05,71.48 77.02,71.51 U2030.AW64 ; U2030.AV1 77.23,35.07 v1(77.09,34.93) ; U2030.AW64 77.06,72.03 ; U2030.AW64 77.06,72.03 ; 77.06,72.03 77.06,72.81 77.16,72.91 U2030.AW66 ; v1(132.29,52.21) PR7104.1 ; v1(212.3,38.04) 212.34,38.04 212.71,38.4 CN35.20 ; U2030.D47 95.42,62.95 95.38,62.99 U2030.D48 ; CN10.A12 7.56,18.65 ; U2030.AW14 77.02,43.18 77.05,43.15 77.05,42.86 77.02,42.83 U2030.AW12 ; U2030.AW66 76.5,73.09 U2030.AY66 76.37,73.22 75.72,73.22 U2030.BA66 ; U2030.AW66 77.34,73.28 77.55,73.48 v4(77.55,73.54) 77.35,73.74 U2030.AV68 ; v1(143.19,60.07) 143.44,60.32 PC7005.2 ; v4(84.06,35.18) 83.98,35.26 83.98,35.95 U2030.AF1 U2030.AF2 ; U2030.AW8 77.07,39.96 77.07,38.92 U2030.AW6 ; U2030.B34 96.73,56.21 97.62,56.21 97.67,56.26 ; v1(142.93,56.81) 143.59,56.81 PC7029.1 ; PC7025.1 137.6,48.6 v1(137.33,48.87) ; v4(80.15,71.73) 80.15,71.6 U2030.AP63 ; U8.AF8 100.07,115.01 v1(100.14,115.07)
  BOTTOM w0.229: v1(47.39,16.31) 47.26,16.44 45.01,16.44 44.67,16.78 PU6003.8
  BOTTOM w0.254: v2(197.21,10.51) 197.12,10.6 C805.1 ; JDIM2000.64 51.25,80.46 51.45,80.65 51.89,80.65 52.71,81.47 v2(52.71,81.61) ; U2030.AF2 U2030.AF4 ; U2030.AF4 84.43,38.15 v4(84.53,38.15) ; U2030.AF4 83.21,38.35 83.14,38.41 U2030.AH6 ; CN16.45 v1(28.85,8.23) ; JDIM2000.103 57.31,70.7 57.2,70.6 56.6,70.6 56.38,70.82 v2(56.38,71.08) 56.38,71.19 56.89,71.7 JDIM2000.99 ; v4(93.66,48.88) 93.66,48.98 U2030.F23 ; v4(93.66,48.88) 93.35,48.57 U2030.G22 U2030.K22 ; v4(93.66,48.88) 94,48.54 U2030.F22 ; U2030.AG19 83.51,46.41 v4(83.18,46.74) ; v1(87.31,48.03) 86.99,47.71 U2030.Y21 U2030.AB21 ; U2030.AN63 80.18,71.68 v4(80.15,71.73) ; U2030.AN23 80.27,49.51 v4(80.27,49.77) 79.81,49.32 U2030.AP23 ; JDIM2000.226 51.69,37.95 52.13,38.39 v2(52.13,38.49) 52.13,38.7 51.87,38.95 JDIM2000.222 ; U2030.G48 93.81,62.57 v4(94.91,62.57) ; v2(51.69,52.46) JDIM2000.168 ; U2030.AW10 77.32,41.25 v4(77.51,41.44) ; U2030.AW10 77.02,40.85 77.17,40.7 77.17,40.16 U2030.AW8 ; U2030.AW10 U2030.BA10 ; U2030.AD19 85.15,46.41 v4(84.82,46.74) 85.14,47.06 U2030.AD20 ; U8.H23 v2(112.93,98.37) ; U2030.U67 88.41,73.71 v4(88.08,73.39) ; CN35.14 212.47,41.4 212.4,41.46 212.02,41.46 211.59,41.03 v1(211.59,40.47) ; v1(33.03,7.68) 33.03,8.14 33.35,8.46 CN16.27 ; JDIM2000.193 56.63,46.2 55.79,45.36 v2(55.79,45.22) ; CN29.21 53.85,107.74 53.05,108.53 v1(53.05,108.8) ; U2030.B62 95.9,70.75 v4(95.9,70.75) U2030.D62 ; U2030.J38 93.6,58.01 ; 93.6,58.01 93.6,57.94 U2030.F38 ; 93.6,58.01 93.6,58.07 U2030.F40 ; v1(90.77,75.29) 90.77,74.82 U2030.N68 ; v1(212.35,34.89) 212.36,34.9 CN35.27 ; U2030.BA18 76.29,46.09 v4(76.49,45.89) 76.69,46.09 U2030.AW18 ; U2030.F38 94,57.47 v4(93.6,57.07) ; U2030.F38 94.41,57.14 94.79,57.14 95.04,57.39 95.04,58.01 U2030.D39 95.61,58.13 v4(95.83,58.13) 96,58.13 96.23,58.36 U2030.B39 ; U2030.K64 U2030.K65 91.98,72.43 v4(91.66,72.75) 91.86,72.95 91.98,72.95 U2030.K66 ; 97.67,56.26 97.76,56.35 98.41,56.35 98.99,56.92 101.46,56.92 102.22,57.69 102.22,60.36 103.42,61.56 C2564.1 103.85,62.7 104.1,62.95 v1(104.1,62.96) 104.35,63.21 104.35,64.15 104.53,64.32 v1(104.53,64.71) ; v4(81.46,37.16) 81.93,37.63 U2030.AJ4 ; v4(81.46,37.16) 81.27,36.97 U2030.AL2 ; v4(81.46,37.16) 81.46,37.44 U2030.AL4 ; v4(94.91,62.57) 94.97,62.64 U2030.D47 ; v4(94.91,62.57) 94.65,62.32 U2030.E46 ; JDIM2000.1 59.49,96.21 60.18,95.52 ; R25551.1 93.13,89.9 92.93,90.1 v2(92.62,90.1) 92.67,90.06 92.67,88.93 92.36,88.62 R25492.2 ; v1(84.73,70.18) 84.82,70.18 U2030.AD62 ; v4(95.28,76.73) 94.96,76.41 U2030.E71 ; U2030.G63 93.41,71.45 v4(93.13,71.73) ; JDIM2000.2 51.43,95.95 51.45,95.98 51.77,95.98 52.12,95.63 v2(52.12,95.49) 52.12,95.33 51.74,94.95 JDIM2000.6 ; v4(79.44,60.72) 79.44,60.82 79.16,61.1 U2030.AR45 ; U2030.BA41 75.8,58.47 v4(76.44,58.47) 77.02,58.47 U2030.AW41 ; JDIM2000.65 57.26,80.21 v2(57.14,80.08) ; U2030.L4 92.06,37.45 v4(92.06,37.14) 92.06,36.85 U2030.L2 ; v2(65.95,46.72) C2575.1 C2577.1 ; U2030.B18 96.1,45.97 95.94,45.82 v1(95.9,45.82) 95.53,45.82 U2030.D18 ; v1(100.32,38.84) 100.32,39.6 C2583.2 ; U2030.AV69 77.16,74.56 v4(77.2,74.51) 77.35,74.37 U2030.AV68 ; JDIM2000.230 51.96,36.95 53.31,38.31 v2(53.31,38.5) ; C2582.2 99.55,40.83 98.61,41.77 v4(98.2,42.18) ; U2030.AM45 81.13,61.21 U2030.AL45 81.57,60.75 U2030.AM43 ; U2030.BA28 v4(76.44,51.01) U2030.AW28 ; U2030.AD13 85.13,43.08 U2030.AF15 84.35,43.81 v4(83.98,44.18) ; U8.B5 97.58,93.18 v2(97.34,92.94) ; U2030.E65 94.71,72.54 v4(94.43,72.83) 93.93,72.83 U2030.G66 ; U2030.F28 94,52.08 v4(93.56,52.52) ; JDIM2000.82 52.07,75.95 52.36,76.25 v2(52.36,76.56) 52.36,76.74 51.97,77.14 51.44,77.14 51.26,76.95 JDIM2000.78 ; v4(78.83,62.64) 78.83,62.68 79.16,63.01 U2030.AR48 ; v4(83.46,74.04) 83.32,74.04 U2030.AH67 ; JDIM2000.202 51.61,43.95 v2(51.64,43.98) ; v4(80.14,57.01) U2030.AN37 v4(80.14,56.18) ; v2(56.96,45.23) 57.47,45.23 57.5,45.2 JDIM2000.197 ; 99.86,85.49 99.83,85.52 Y3.4 ; 99.86,85.49 v1(100.75,85.49) v1(102.66,85.49) 102.95,85.78 102.95,87.23 103.13,87.41 103.13,88.2 ; 99.86,85.49 99.12,85.49 98.87,85.74 98.87,88.62 R331.2 ; U2030.BB64 75.04,71.86 74.39,71.86 v2(74.24,71.71) ; v1(104.53,64.71) 104.53,65.14 104.1,65.57 101.68,65.57 101.42,65.31 101.42,63.97 v1(101.33,63.88) ; v1(104.53,64.71) 104.1,64.71 103.88,64.93 Y2002.4 ; U2030.AA65 86.33,72.74 v4(86.21,72.74) ; JDIM2000.89 56.08,74.2 55.26,73.38 v2(55.26,73.07) ; R183.2 191.92,25.41 189.83,25.41 189.47,25.77 v2(189.47,27.24) 189.5,27.24 189.86,26.88 CN17.18 ; v4(93.65,61.72) 93.65,61.51 U2030.G45 ; U2030.C25 96.07,50.48 v4(95.83,50.72) ; U2030.AT2 78.8,36.85 v4(78.8,37.15) 78.62,37.34 U2030.AT4 79.16,38.18 U2030.AR5 ; JDIM2000.217 57.04,40.2 v2(56.95,40.11) ; v1(99.17,27.74) 99.17,26.49 99.07,26.39 96.4,26.39 96.14,26.65 v1(96.14,27.1) ; v1(99.17,27.74) 99.17,28.58 98.9,28.85 C2589.2 98.9,29.74 98.69,29.95 v1(98.69,30.24) 98.69,30.39 98.46,30.62 98.46,32.68 v1(97.57,33.56) 97.57,34.18 v1(96.72,35.03) 96.71,35.04 96.41,35.34 U2030.C1 ; v1(99.17,27.74) 98.65,28.26 Y2003.4 ; U2030.AP10 79.52,40.79 v4(79.52,40.67) 79.16,40.32 U2030.AR8 ; v2(56.41,87.76) 56.41,87.65 57.35,86.7 JDIM2000.39 ; v4(95.83,50.72) 95.63,50.92 U2030.D26 ; v4(95.83,50.72) 95.42,50.31 U2030.D25 ; v4(92.31,42.47) 92.05,42.74 U2030.J13 92.49,43.36 92.49,43.62 U2030.H15 ; Y2002.2 v1(101.33,63.88) ; v1(101.33,63.88) 101.33,63.31 100.89,62.87 C2563.1 v1(100.89,60.69) 101.18,60.4 101.18,58.27 100.98,58.07 98.59,58.07 98.36,57.84 97.8,57.84 ; v1(133.31,16.47) 133.31,16.52 133.85,17.06 CN15.7 ; v4(78.79,66.24) 78.79,66.35 79.14,66.69 U2030.AR55 79.16,66.83 v4(78.85,67.14) 78.85,67.27 U2030.AT56 78.83,67.93 v4(78.83,68.06) ; 182.4,15.63 182.05,15.97 182.05,16.76 182.42,17.13 CN17.57 ; 182.4,15.63 182.17,15.4 182.17,14.38 182.42,14.13 CN17.69 ; 182.4,15.63 CN17.63 184.04,15.63 v2(184.42,15.26) ; v2(181.67,30.36) 181.67,30.19 182.23,29.63 CN17.7 ; v4(95.91,56.01) 95.51,56.01 U2030.D34 ; v2(105.45,96.65) U8.E14 ; U2030.F13 94.37,43.29 v4(94.37,43.36) 94.65,43.64 U2030.E15 ; R2524.2 102.04,36.25 v1(101.41,36.88) 101.29,37 101.18,37.11 C2587.2 ; JDIM2000.234 51.79,35.95 52.12,35.62 v2(52.12,35.49) 52.12,35.34 51.74,34.95 JDIM2000.238 ; JDIM2000.214 51.19,40.95 51.22,40.98 51.89,40.98 52.23,40.64 v2(52.23,40.5) 52.23,40.32 51.87,39.95 JDIM2000.218 ; C665.2 210.5,27.32 209.89,27.93 209.89,28.21 209.66,28.43 209.04,28.43 C580.2 ; JDIM2000.56 51.3,82.46 51.37,82.38 52.23,82.38 52.89,83.05 v2(52.89,83.3) ; v2(181.42,19.29) 181.8,18.91 182.05,18.91 182.33,18.63 CN17.51 ; JDIM2000.40 51.92,86.45 52.76,87.3 v2(52.76,87.77) ; v1(105.04,67.07) 105.04,66.24 105.01,66.21 ; U2030.K61 92.42,70.7 v4(92.56,70.84) 92.27,71.13 U2030.K63 ; JDIM2000.239 56.89,34.71 56.49,35.1 v2(56.49,35.22) 56.49,35.35 56.9,35.77 57.35,35.77 57.41,35.71 JDIM2000.235 ; v2(51.63,78.56) 51.53,78.46 JDIM2000.72 ; v2(48.95,75.06) 49.05,74.95 JDIM2000.86 ; JDIM2000.61 56.82,81.21 55.95,82.08 v2(55.95,82.33) ; JDIM2000.60 51.38,81.46 v2(51.54,81.61) ; JDIM2000.201 55.76,44.2 55.16,43.6 v2(55.16,43.24) 55.16,42.89 55.84,42.2 JDIM2000.209 ; U2030.AR16 79.46,44.45 79.49,44.42 v4(79.49,44.29) ; v1(35.14,7.63) 35.14,8.06 34.85,8.35 CN16.21 ; U2030.AK22 81.82,48.18 81.61,48.18 v4(81.56,48.13) ; v4(81.4,45.25) 81.4,45.28 U2030.AK18 82.01,45.89 82.58,45.89 U2030.AJ18 82.86,45.91 83.41,45.91 U2030.AG18 ; U2030.AR50 78.95,64.16 78.95,64.65 U2030.AR52 ; v1(36.74,12.23) 36.74,11.01 36.35,10.62 CN16.15 ; JDIM2000.9 57.27,94.21 v2(56.82,94.66) ; 77.02,70.52 U2030.AW62 76.52,70.72 v4(76.49,70.69) 76.49,70.7 76.48,70.72 U2030.BA62 ; U2030.F68 94.38,74.58 v4(94.84,75.03) 95.03,74.84 U2030.D69 ; C841.2 38.01,116.67 37.6,117.08 CN38.6 ; C2593.1 67.76,33.54 68.04,33.82 68.04,34.37 v1(67.93,34.48) ; v2(107.63,93.2) 107.63,93.71 U8.B17 ; CN35.17 212.54,39.9 212.48,39.84 v1(211.64,39.84) ; v1(96.14,27.1) 96.17,27.07 96.85,27.07 Y2003.2 ; v1(96.14,27.1) 96.14,27.45 96.34,27.65 C2591.2 96.34,29.93 v1(96.51,30.09) 96.51,32.79 96.08,33.22 v1(96.08,33.64) 95.9,33.82 95.41,33.82 94.52,34.71 94.52,36 U2030.F1 ; U2030.T4 89.22,37.33 v4(89.04,37.15) 89.04,36.84 U2030.T2 ; U2030.E18 94.65,45.51 v4(94.93,45.23) ; v4(97.79,38.28) 97.46,37.95 U2030.A5 ; JDIM2000.210 51.72,41.95 52.12,42.36 v2(52.12,42.49) 52.12,42.7 51.86,42.95 JDIM2000.206 ; U2030.BA2 75.38,36.07 75.21,35.91 U2030.BA1 75.21,35.27 v1(75.35,35.13) ; U2030.D10 95.78,41.01 v4(95.87,41.1) 95.96,41.01 U2030.B10 ; v4(83.98,48.14) 84.08,48.24 84.74,48.24 85.23,47.75 U2030.AD21 ; U2030.AK16 81.99,44.46 v4(82.32,44.79) ; U2030.F37 94.34,56.29 v4(94.34,56.2) 94,55.86 U2030.F35 ; JDIM2000.73 56.28,78.2 55.28,77.2 v2(55.28,76.69) 55.28,76.62 56.69,75.2 JDIM2000.85 ; v4(77.51,41.44) 77.86,41.09 U2030.AU10 ; v4(77.51,41.44) 77.21,41.75 77.21,42.03 77.02,42.22 U2030.AW12 ; PU9004.19 v1(137.06,69.54) ; v1(106.44,63.89) 106.44,64.07 105.93,64.58 R2488.2 ; JDIM2000.192 51.26,46.45 51.32,46.51 51.92,46.51 52.31,46.11 v2(52.31,45.97) 52.31,45.84 51.92,45.45 JDIM2000.196 ; JDIM2000.69 56.58,79.21 55.97,79.82 v2(55.97,80.08) ; JDIM2000.248 51.56,32.45 v2(51.63,32.53) ; U2030.G58 93.6,68.78 v4(93.6,68.98) 93.6,69.18 U2030.G60 ; U2030.D30 95.38,53.4 v4(95.89,53.4) 96.4,53.4 U2030.B30 ; U2030.AP70 v4(79.73,74.64) U2030.AP68 ; U2030.B22 U2030.D22 95.38,48.41 94.94,47.96 v4(94.94,47.94) 94.94,47.84 94.65,47.56 U2030.E21 ; CN10.1 8.33,12.7 v1(8.57,12.94) 8.24,13.27 7.73,13.27 7.61,13.15 CN10.A1 ; v2(56.57,96.18) 56.57,96.1 57.46,95.21 JDIM2000.5 ; v2(116.14,93.08) 116.14,93.42 U8.B27 ; v2(63.52,41.42) 63.89,41.79 R2510.1 R2505.2 ; JDIM2000.176 52.2,50.46 52.87,49.79 v2(52.87,49.51) ; U2030.F42 93.6,59.77 v4(93.6,59.83) 93.6,60.04 U2030.G43 ; JDIM2000.81 56.95,76.2 56.51,76.65 v2(56.51,76.72) 56.51,76.78 56.98,77.26 57.41,77.26 57.46,77.2 JDIM2000.77 ; v2(185.1,28.43) 185.1,27.44 184.29,26.63 CN17.19 ; U2030.F4 94.59,37.64 95.38,38.42 U2030.D6 ; v2(52.19,90.82) 52.19,90.65 51.5,89.95 JDIM2000.26 49.2,89.95 48.87,90.29 48.87,90.69 49.13,90.95 JDIM2000.22 ; U2030.AM61 U2030.AM60 81.03,69.44 80.61,69.01 v4(80.12,69.01) ; v2(57.08,38.93) 57.16,38.93 57.39,38.71 JDIM2000.223 ; JDIM2000.247 56.97,32.71 56.58,33.1 v2(56.58,33.22) 56.58,33.59 56.8,33.81 57.37,33.81 57.48,33.71 JDIM2000.243 ; U8.E25 113.74,96.67 v2(113.74,96.73) ; U2030.AA68 86.19,73.9 v4(86.19,73.42) ; JDIM2000.175 56.76,50.71 v2(56.4,50.34) ; CN17.13 182.32,28.13 v2(182.02,28.43) ; v2(92.41,95.13) 92.76,94.79 92.76,94.56 93.12,94.19 93.85,94.19 94.21,93.83 U8.B1 ; U2030.AM21 81.11,47.68 v4(81.56,48.13) ; JDIM2000.244 51.59,33.45 51.62,33.48 v2(51.63,33.48) ; U8.B20 109.99,92.67 v2(109.89,92.57) ; U6504.3 99.86,125.8 v1(99.68,125.97) ; JDIM2000.48 51.95,84.45 52.8,85.31 v2(52.8,85.47) ; U2030.B53 96.16,66.03 v4(95.82,66.03) 95.62,66.03 U2030.D53 95.37,65.78 U2030.E53 ; JDIM2000.27 57.13,89.7 56.3,90.54 v2(56.3,90.83) ; v2(76.86,76.75) 77.05,76.56 77.16,76.45 U2030.AV71 U2030.AV70 ; U2030.AE64 84.88,71.82 84.88,72.36 U2030.AE65 84.86,72.44 84.86,73.03 U2030.AE66 84.85,73.09 84.85,73.69 U2030.AE67 U2030.AE68 U2030.AE69 85.06,75.25 v2(85.28,75.25) ; v1(95.62,28.74) 95.34,28.74 95.03,28.43 R2581.1 ; U2030.U64 88.12,72.13 v4(88.07,72.13) ; v4(91.88,77.69) 91.83,77.64 91.83,76.01 U2030.K71 ; v4(81.56,48.13) 81.88,47.82 U2030.AK21 ; U2030.AK8 81.76,40.01 81.73,40.01 v4(81.61,40.13) ; v1(37.12,7.25) 37.85,7.98 CN16.9 ; v2(195.05,20) 195.34,20.29 195.34,21.56 Q31.1 ; C385.2 88.38,105.93 89.49,104.82 89.49,104.48 89.74,104.22 PR9031.1 ; 103.13,88.2 103.11,88.19 Y3.2 ; 103.13,88.2 103.13,89.02 102.78,89.37 C463.2 102.46,90.06 102.17,90.35 v2(102.17,91.16) ; JDIM2000.167 57.27,52.71 57.13,52.84 57.13,53.11 56.84,53.39 56.17,53.39 56.01,53.24 v2(56.01,52.89) 56.01,52.64 56.94,51.71 JDIM2000.171 ; v2(55.75,40.1) 55.75,40.37 56.59,41.2 JDIM2000.213 ; JDIM2000.102 48.83,70.95 48.38,70.5 v2(48.38,68.99) ; v4(87.79,40.39) 87.77,40.37 U2030.W9 ; PU7003.9 127.75,77.78 PU7003.6 ; JDIM2000.19 57.52,91.7 57.27,91.95 56.94,91.95 56.44,92.45 v2(56.44,92.69) ; R332.2 R331.2 ; R331.2 99.11,89.37 v2(99.25,89.37) C464.2 99.9,90.3 101.51,91.91 v2(101.53,91.91) ; U2030.AW18 77.12,46.19 77.12,46.92 77.02,47.03 U2030.AW21 ; U2030.AW18 77.11,46 77.11,44.94 U2030.AW16 ; v2(184.97,24.37) 184.97,23.89 184.22,23.13 CN17.33 ; U2030.U10 88.31,41 v4(87.79,41) ; CN29.12 49.35,108.18 49.01,108.52 v1(47.94,108.52) 48.19,108.27 48.19,107.96 47.85,107.62 CN29.9 ; U2030.U69 88.14,74.67 v1(88.07,74.67) ; CN10.4 8.13,19.1 v1(8.57,18.66) 8.44,18.53 7.68,18.53 7.56,18.65 ; v1(213.04,12.32) HD1.9 ; JDIM2000.93 57.51,73.2 57.19,73.52 56.72,73.52 56.43,73.22 v2(56.43,73.04) ; v2(200.88,20.86) 200.88,20.85 200.81,20.78 200.81,20 C737.1 200.69,19.59 199.32,19.59 C734.2 ; 58.45,37.71 57.5,37.71 57.01,38.2 56.54,38.2 56.14,37.8 v2(56.14,37.68) 56.14,37.58 57.02,36.71 JDIM2000.231 ; R2543.1 v1(95.46,31.5) R2545.1 ; U2030.AF17 84.4,45.1 84.72,44.79 v4(84.81,44.79) 84.84,44.76 85.14,44.46 U2030.AD16 ; U2030.F27 93.72,50.87 v4(93.72,50.7) ; U2030.AT58 78.65,68.65 78.85,68.86 v4(78.85,68.95) ; U2030.G52 93.35,64.7 v4(93.61,64.44) ; JDIM2000.36 51.29,87.45 51.54,87.71 v2(51.54,87.78) ; v2(111.2,110.78) 111.03,110.78 111,110.81 110.41,110.81 U8.AB20 ; v4(80.8,51.59) 81.11,51.28 U2030.AM27 ; JDIM2000.51 57.25,83.7 v2(56.65,84.31) ; U2030.D45 95.38,61.47 U2030.D44 95.67,60.84 v1(95.87,60.63) 96.01,60.78 96.34,60.78 U2030.B44 ; C524.2 203.01,22.82 202.36,23.47 v2(202.36,23.55) ; U2030.F32 94,53.9 v4(93.55,54.35) ; v2(48.97,73.95) JDIM2000.90 ; CN16.57 25.85,8.44 v1(26.05,8.24) ; v1(140.12,44.04) 140.12,44.47 PC7027.1 ; U2030.BA57 U2030.AW57 77.35,68.24 v4(77.53,68.06) ; U2030.AW45 U2030.BA45 ; U2030.AW53 v4(76.49,65.76) U2030.BA53 ; C559.2 86.14,99.03 85.76,99.41 v1(85.76,99.45) ; U2030.AW23 v4(76.44,48.53) U2030.BA23 ; JDIM2000.107 56.27,69.7 56.08,69.51 v2(56.08,69.23) ; CN14.5 58.45,21.54 58.74,21.83 59.47,21.83 59.64,22 EC8.2 ; v4(93.66,39.68) 93.66,39.84 U2030.F8 ; JDIM2000.98 51.7,71.95 52.16,72.42 v2(52.16,72.53) 52.16,73.01 51.88,73.29 51.52,73.29 51.19,72.95 JDIM2000.94 ; U2030.W6 87.26,38.27 86.63,37.64 U2030.AA4 86.57,37.33 v4(86.39,37.15) 86.57,36.97 U2030.AA2 ; v1(90.79,72.09) 90.46,72.41 U2030.N65 ; JDIM2000.181 57.41,49.2 57.31,49.31 56.75,49.31 56.47,49.03 v2(56.47,48.76) 56.47,48.65 56.91,48.2 JDIM2000.185 ; CN16.51 v1(27.35,8.24) ; v4(93.55,54.35) 94,54.79 U2030.F33 ; v4(93.55,54.35) U2030.J32 ; U2030.BB6 U2030.BA6 76.15,38.83 76.17,38.85 v4(76.5,38.85) ; JDIM2000.188 51.85,47.46 52.16,47.77 v2(52.16,48.07) 52.16,48.28 51.8,48.65 51.44,48.65 51.25,48.46 JDIM2000.184 ; v2(97.13,98.37) 97.11,98.35 95.55,98.35 U8.H2 ; U2030.AW14 v4(76.36,43.67) U2030.BA14 ; U8.U23 112.53,106.29 v2(112.14,106.68) ; v2(52.14,51) 52.14,51.21 51.9,51.46 JDIM2000.172 ; v1(67.22,30.92) 67.22,30.47 R2532.1 C2588.2 ; U2030.BA49 75.84,63.24 v4(76.28,63.24) 76.4,63.36 U2030.AW49 ; v2(116.44,111.6) 116.26,111.41 115.16,111.41 U8.AC26 ; JDIM2000.68 51.81,79.46 52.21,79.85 v2(52.21,79.97) ; JDIM2000.15 59.74,92.7 59.94,92.91 ; v4(94.92,68.05) 95.14,68.27 95.38,68.27 ; U2030.D66 95.6,73.01 v4(95.88,73.01) 96.18,73.01 U2030.B66 ; JDIM2000.43 57.5,85.7 57.2,86.01 56.75,86.01 56.36,85.62 v2(56.36,85.5) 56.36,85.42 56.77,85.01 57.03,85.01 57.33,84.7 JDIM2000.47 ; CN29.6 46.35,107.57 46.1,107.83 45.1,107.83 44.85,107.57 CN29.3 44.85,106.46 v1(45.02,106.29) ; v2(112.11,100.83) U8.L23 112.95,101.67 113.71,101.67 U8.L25 ; U2030.E11 94.66,42 94.66,41.86 v4(94.93,41.59) 95.02,41.69 U2030.D11 ; v2(56.15,89.53) 56.97,88.7 JDIM2000.31 59.54,88.7 59.68,88.57 59.68,87.96 59.42,87.7 JDIM2000.35 ; v2(52.28,70.96) 52.28,70.95 52.23,70.9 52.23,70.5 51.69,69.95 JDIM2000.106 ; HD1.12 v1(214.82,10.82) ; JDIM2000.10 51.93,93.95 52.29,93.59 v2(52.29,92.66) 52.29,92.61 51.64,91.95 JDIM2000.18 49.27,91.95 49.04,92.18 49.04,92.7 49.29,92.95 JDIM2000.14 ; U2030.D14 95.03,43.84 95.03,44.46 v4(95.25,44.69) ; CN16.33 v1(31.85,8.24) ; R2502.2 63.84,44.03 v2(63.49,44.39) ; JDIM2000.251 57.47,31.71 57.25,31.93 56.19,31.93 55.39,32.72 v2(55.39,33.2) ; JDIM2000.205 57.16,43.2 57.07,43.29 v2(56.91,43.29) ; U2030.E50 94.75,63.95 U2030.D48 95.7,63.31 v1(95.9,63.51) 96.2,63.51 U2030.B48 ; v1(88.07,75.31) 88.13,75.31 U2030.U70 ; CN17.39 184.36,21.63 v2(184.4,21.59) 184.4,20.38 184.15,20.13 CN17.45 ; v1(135.35,16.47) CN15.4 ; v1(74.47,45.91) 74.9,45.91 U2030.BB18 ; U2030.U63 88.41,71.11 v1(88.07,71.45) ; v2(53.41,32.56) 53.41,32.24 52.62,31.45 JDIM2000.252 ; U2030.B58 95.38,68.27 ; 95.38,68.27 U2030.D58 ; CN24.1 46.45,11.52 46.7,11.26 v1(48.1,11.26) ; U2030.R13 89.54,43.11 v4(89.97,43.11) 90.31,43.11 U2030.N13 ; U2030.G55 93.35,66.49 v4(93.6,66.23) ; v1(106.65,70.79) 106.65,70.21 106.26,69.81 106.08,69.81 105.84,69.57 C2559.1 105.63,69.44 U2029.3 ; U2030.A67 97.42,73.9 97.67,74.15 97.67,74.15 97.92,74.41 v4(98.11,74.41) ; C2362.2 100.09,33.37 100.09,34.25 99.05,35.29 v1(99.05,35.31) ; JDIM2000.180 51.67,49.46 v2(51.7,49.48) ; U8.Y26 115.12,108.5 116.54,108.5 116.85,108.81 v2(116.85,108.96) ; v2(51.73,83.3) 51.57,83.46 JDIM2000.52 ; v2(57.12,82.33) 57.25,82.21 JDIM2000.57 ; v4(78.91,41.53) 78.91,41.75 U2030.AR11 ; C2573.1 v2(64.1,47.87) ; v1(112.46,92.32) 112.64,92.5 112.64,93.67 U8.B23 ; U2030.AW36 77.02,55.99 v4(76.44,55.99) 75.8,55.99 U2030.BA36 ; U2030.AP63 79.53,71.68 v4(79.5,71.73) ; U2030.BA32 v1(76.44,53.52) U2030.AW32 ; v4(91.71,73.41) 92.04,73.73 U2030.K67 92.11,74.14 U2030.K68 ; U2030.U66 88.17,72.75 v4(88.07,72.75) ; v1(74.05,74.2) 74.29,74.2 74.58,73.9 U2030.BB67 ; JDIM2000.44 51.56,85.45 v2(51.57,85.46) ; U2030.AR43 79.31,60.14 79.81,59.64 U2030.AP42 ; U2030.AG20 83.5,47.06 v4(83.18,46.74) ; v4(83.18,46.74) 83.04,46.74 U2030.AJ20 ; JDIM2000.23 60,90.7 ; CN16.39 v1(30.35,8.22) ; C780.2 136.85,20.32 CN15.1 136.85,17.07 137.27,16.65 137.29,16.65 v1(137.48,16.47) ; v2(55.3,48.74) 55.3,48.42 56.51,47.2 JDIM2000.189 ; R2453.2 v1(97.27,80.87) ; HD1.6 v1(213.14,13.82) ; v2(52.35,89.52) 52.35,89.21 52.1,88.95 JDIM2000.30 ; 77.46,29.97 76.97,29.48 76.97,27.5 77.23,27.24 80.84,27.24 81.1,27.5 81.1,29.42 80.55,29.97 C2596.1 80.31,30.27 80.09,30.49 v1(80.09,31.21) 80.09,31.77 79.78,32.08 79.16,32.7 78.16,32.7 77.51,33.35 76.44,33.35 76.18,33.1 76.19,32.62 76.63,32.18 77.48,32.18 77.74,31.93 v1(77.74,31.25) 77.63,31.15 C2595.2 77.46,29.97
  BOTTOM w0.305: VRAM2.U1 139.81,116.2 v2(140.21,116.61) ; U2030.A70 U2030.B71 96.91,77.25 v4(96.59,77.57) ; v4(85.66,39.36) 85.54,39.48 85.36,39.48 U2030.AD8 ; U2030.AN58 80.12,68.18 v4(80.12,68.1) 80.18,68.05 80.78,68.05 81.18,68.06 81.58,68.06 U2030.AL58 ; v4(81.61,40.13) 81.56,40.17 U2030.AM8 ; U8.H25 114.53,99.17 v2(114.53,99.21) ; v1(13.14,16.24) 12.13,16.24 12,16.12 RV3.3 RV3.8 v1(9.84,16.12) ; U2030.J28 92.89,52.52 v4(93.56,52.52) ; U2030.AU38 v4(77.55,57.96) ; U2030.AR28 v4(79.49,52.52) U2030.AP28 ; U8.B14 105.02,93.83 v2(104.65,93.46) ; U2030.AT42 78.8,59.67 v4(78.8,59.8) 79.01,59.59 79.01,59.59 U2030.AR42 ; v2(136.21,83.01) 136.22,83.01 VRAM1.E1 ; v4(80.86,42.46) 80.86,42.67 U2030.AM13 ; U2030.AR15 79.16,43.69 v4(79.44,43.41) 78.28,43.41 U2030.AU15 ; U2030.J8 91.86,40.17 U2030.L8 91.22,39.53 v4(90.94,39.53) ; v4(84.54,41.28) 84.32,41.28 U2030.AF10 ; v4(80.15,55.25) 80.15,55.12 U2030.AN33 ; v2(112.87,114.02) U8.AF23 ; U2030.J42 v4(93.6,59.83) ; U2030.G10 93.35,40.98 94,40.33 U2030.F8 94.23,39.95 94.23,39.61 94.58,39.26 U2030.E6 ; 93.55,38.55 93.34,38.33 v4(93.34,37.81) ; 93.55,38.55 93.55,39.06 U2030.G6 93.66,39.57 v4(93.66,39.68) ; 93.55,38.55 U2030.G5 ; VRAM2.L10 135.01,109.06 v2(135.41,109.46) 135.81,109.06 VRAM2.M10 ; U2030.AR23 v2(78.84,49.78) U2030.AT23 ; U2030.AG17 83.6,45.11 83.75,44.96 v4(83.93,44.79) 83.88,44.79 U2030.AG16 ; v2(99.96,93.31) 99.96,93.72 U8.B8 ; U2030.AN32 80.12,54.23 v4(80.12,54.39) ; U2030.AP35 v4(79.49,56.18) v4(80.14,56.18) 80.14,56.04 U2030.AN35 ; U8.U26 114.91,106.21 114.53,105.83 v2(114.53,105.81) ; U8.AG26 114.93,114.45 v2(115.34,114.86) ; v1(98.51,81.93) 98.43,82.01 98.28,82.01 97.85,82.43 C2541.1 97.8,82.41 R2449.2 96.3,82.41 96.07,82.17 95.77,82.17 95.35,81.75 C2149.1 ; U2030.J35 93.54,56.18 U2030.F37 94,56.67 v4(93.6,57.07) ; v2(159.24,28) 159.24,27.48 159.45,27.28 U2031.4 159.45,24.61 PC242.2 ; U2030.AL35 v1(82.32,55.26) ; U2030.AP32 79.63,54.15 v4(79.47,54.39) ; v4(79.51,62.64) 79.57,62.58 80.65,62.58 U2030.AM46 81.13,62.12 U2030.AL48 ; U2030.AL66 v4(80.76,72.66) 81,72.41 U2030.AL65 U2030.AL64 ; U2030.N6 90.15,38.1 89.71,38.1 U2030.R6 89.08,38.1 v4(88.98,38.1) ; U2030.AR35 v4(78.84,56.18) ; v4(80.81,50.66) 80.97,50.44 U2030.AM25 ; v1(97.45,114.86) 97.45,113.76 U8.AF5 ; U2030.AL32 v1(82.32,53.43) ; R311.2 103.07,117.2 v1(103.22,117.2) ; U8.A26 115.33,93.03 115.38,93.08 v2(116.14,93.08) ; v4(78.84,65.33) U2030.AR52 ; U2030.AK69 82.13,75.24 v4(82.13,74.85) 82.13,74.47 U2030.AK68 ; U8.AB24 113.33,110.38 v2(113.73,110.78) ; R2455.1 96.28,80.27 95.9,79.89 v1(95.72,79.89) 95.35,80.27 C2148.1 ; U2030.AL45 82.33,60.75 v1(82.33,60.75) ; U2030.AJ15 82.92,43.61 83.08,43.45 83.08,43.05 U2030.AH13 82.62,42.6 v4(82.58,42.6) 82.48,42.5 82.48,42.09 U2030.AK11 ; U8.A2 94.19,93.03 93.64,93.57 92.76,93.57 v2(92.62,93.72) ; v4(78.82,61.7) 78.82,61.81 79.13,62.12 U2030.AR46 ; U2030.AB8 86.57,39.72 v4(86.79,39.93) ; U2030.AN30 80.14,53.44 v4(80.14,53.45) ; v4(78.79,66.24) 78.79,66.12 79.13,65.78 U2030.AR53 ; U2030.AM55 80.96,66.9 80.96,66.97 80.81,67.19 v4(80.8,67.2) ; U2030.AL38 v1(82.36,57.09) ; U2030.AK63 82.73,71.76 U2030.AH64 83.02,71.76 83.35,72.09 v4(83.44,72.09) 83.46,72.07 83.46,71.57 U2030.AF63 U2030.AH63 ; v2(138.61,84.61) 138.6,84.61 VRAM1.C3 ; U8.Y23 v2(112.11,109.11) ; VRAM1.B10 139.01,90.6 v2(138.61,90.21) ; v4(80.14,52.52) U2030.AN28 ; PU7002.9 118.96,68.87 PU7002.6 ; U2030.AL52 v4(80.76,64.41) ; U2030.J25 v4(92.2,50.69) ; v1(10.58,10.2) 11.36,10.2 11.89,10.73 RV1.3 ; v4(77.52,54.39) 77.74,54.07 77.8,53.99 U2030.AU32 ; CN29.18 52.35,106.4 v1(52.54,106.21) ; v4(80.88,66.24) 81.24,66.24 U2030.AL55 ; U2030.AP38 v4(80.14,57.01) U2030.AN38 ; U2030.AT28 v4(78.84,52.52) ; U2030.AP58 v4(79.5,68.95) ; U2030.AL28 82.3,51.6 v1(82.31,51.6) 82.31,51.4 U2030.AK27 ; v4(85.61,44.78) 85.75,44.78 U2030.AB16 85.96,44.35 85.96,43.92 U2030.AB15 ; U2030.AT35 v4(78.19,56.18) ; CN10.2 8.26,14.9 8.95,14.21 v1(9.03,14.21) ; CN29.15 50.85,107.82 50.76,107.91 v1(50.76,107.96) ; PU7004.9 140.48,41.62 PU7004.6 ; U8.P23 v2(112.11,103.31) ; PU7001.6 132.86,50.36 v1(132.89,50.39) ; U2030.N10 90.46,41.06 90.85,41.44 91.18,41.44 U2030.L11 91.74,42 U2030.J11 92.05,41.88 92.39,41.54 v4(92.39,41.49) ; VRAM2.T5 138.61,113.4 v2(138.61,113.41) ; U2030.E56 94.65,67.46 95.08,67.03 v4(95.08,66.95) ; v1(8.95,17.41) 8.46,17.41 CN10.3 ; U2030.W13 87.59,43.3 v4(87.94,43.3) 88.07,43.3 U2030.T15 ; U2030.AG21 v4(83.98,48.14) ; U2030.AR58 v4(78.85,68.95)
  BOTTOM w0.33: VRAM2.C1 128.98,115.83 v2(129.01,115.83) ; VRAM2.T10 139.01,109.01 v2(138.61,109.41) ; v2(137.01,84.61) 136.62,85 VRAM1.E3 ; VRAM1.E12 136.61,92.2 v2(136.21,91.81) ; v2(138.61,107.81) 138.22,108.2 VRAM2.R11 ; v2(137.01,105.41) 136.62,105.8 VRAM2.N14 ; v2(137.81,83.01) 138.21,83.4 VRAM1.C1 ; VRAM2.K1 133.82,115.81 v2(133.81,115.81) 133.81,115.8 VRAM2.K2 ; v2(131.26,109.46) 131.35,109.46 VRAM2.G10 ; VRAM1.M10 131.02,90.6 v2(131.41,90.21) 131.81,90.6 VRAM1.L10 ; VRAM1.T5 127.82,86.6 v2(128.21,86.21) ; VRAM2.A3 126.65,114.96 v2(126.62,114.96) ; VRAM1.R12 128.62,92.2 v2(129.01,91.81) 128.61,91.4 VRAM1.R11 ; VRAM2.K14 133.85,106.16 v2(133.81,106.16) 134.21,106.55 VRAM2.K13 ; v2(128.21,94.21) 128.61,93.81 VRAM1.R14 ; v2(137.01,91.01) 137.41,90.61 VRAM1.D10 ; v2(137.01,106.97) 137.01,107 VRAM2.N12 ; v2(137.81,105.41) 138.21,105.8 VRAM2.R14 ; v2(137.81,109.41) 137.41,109.01 VRAM2.P10 ; VRAM2.D10 129.41,109.01 129.01,109.41 v2(129.01,109.46) ; v2(132.21,94.21) 132.61,93.81 VRAM1.K14 ; v2(136.21,94.21) 136.61,93.81 VRAM1.E14 ; v2(126.43,92.06) 126.57,92.2 VRAM1.U12 ; VRAM1.K1 132.61,83.41 v2(132.21,83.81) 132.61,84.2 VRAM1.K2 ; v2(134.61,93.41) 134.21,93.01 VRAM1.H13 ; VRAM1.C14 138.21,93.81 v2(137.81,94.21) ; v2(140.21,84.61) 139.82,85 VRAM1.A3 ; VRAM1.M5 131.01,86.6 v2(131.41,87.01) 131.81,86.61 VRAM1.L5 ; VRAM1.K13 132.61,93.01 v2(132.21,93.41) ; v2(140.21,114.21) 139.82,114.6 VRAM2.U3 ; VRAM1.T10 127.81,90.59 v2(127.42,90.19) ; VRAM2.J1 133.41,116.21 v2(133.01,116.61) ; VRAM2.G5 131.81,113 131.42,112.61 v2(131.41,112.61) 131.41,112.61 131.02,113 VRAM2.F5 ; v2(130.21,105.27) VRAM2.E14 ; v2(130.61,85.41) 130.21,85 VRAM1.N3 ; VRAM2.A12 126.66,107.75 v2(126.66,107.78) ; v2(133.01,109.46) 133.01,109.41 133.41,109.01 VRAM2.J10 ; VRAM1.R3 128.64,85 v2(129,85.37) 128.61,85.76 VRAM1.R4 ; v2(128.21,105.41) 128.61,105.8 VRAM2.C14 ; v2(137.81,116.61) 138.21,116.21 VRAM2.R1 ; v2(140.21,105.41) 139.82,105.8 VRAM2.U14 ; v2(139.41,83.01) 139.81,83.4 VRAM1.A1 ; v2(127.39,85.38) VRAM1.U3 ; VRAM2.C11 128.61,108.17 128.22,107.78 v2(128.21,107.78) 128.59,107.4 VRAM2.C12 ; v2(133.81,83.81) 134.21,84.2 VRAM1.H2 ; v2(126.5,93.53) 126.77,93.8 VRAM1.U14 ; v2(140.21,94.21) 139.81,93.8 VRAM1.A14 ; VRAM1.F5 135.81,86.61 v2(135.41,87.01) 135.01,86.61 VRAM1.G5 ; v2(131.41,108.64) 131.06,109 VRAM2.F10 ; VRAM2.A14 127.01,105.8 v2(126.63,105.42) ; v2(129.82,116.59) VRAM2.E1 ; VRAM1.C11 138.21,91.41 v2(137.81,91.81) ; VRAM2.R12 138.6,107.01 v2(138.61,107.01) ; VRAM1.A12 139.82,92.2 v2(140.21,91.81) ; VRAM1.J1 133.42,83.4 v2(133.81,83.01) 134.21,83.4 VRAM1.H1 ; VRAM2.B5 127.81,113 128.2,113.4 v2(128.21,113.4) 128.21,113.4 VRAM2.C4 ; v2(132.21,116.61) 132.61,116.21 VRAM2.H1 ; VRAM2.E3 130.21,114.61 129.86,114.96 v2(129.81,114.96) ; v2(128.21,114.96) 128.26,114.96 128.61,114.61 128.61,114.6 VRAM2.C3 ; VRAM1.C12 138.21,92.21 v2(137.81,92.61) ; VRAM1.U1 v2(126.6,82.99) ; VRAM1.N12 130.21,92.21 v2(129.81,92.61) ; v2(129.82,94.19) VRAM1.N14 ; VRAM2.H14 132.57,105.8 v2(132.21,106.16) 132.21,106.2 VRAM2.H13 ; v2(136.21,116.56) 136.26,116.56 136.61,116.21 VRAM2.N1 ; v2(134.61,94.21) 134.21,93.81 VRAM1.H14 ; VRAM1.G10 135.02,90.6 v2(135.41,90.21) 135.81,90.6 VRAM1.F10 ; VRAM2.U12 140.21,107.8 v2(140.21,107.81) ; VRAM2.R4 138.21,113.8 v2(138.61,114.21) 138.22,114.6 VRAM2.R3 ; VRAM2.M5 135.81,113 v2(135.41,112.61) 135.02,113 VRAM2.L5 ; VRAM1.R1 128.61,83.4 v2(128.21,83.01) ; VRAM1.N1 130.21,82.89 v2(129.79,82.47) ; v2(139.41,86.21) 139.02,86.6 VRAM1.B5 ; v2(129.03,90.22) VRAM1.P10 ; VRAM2.A1 v2(126.57,116.64)
  BOTTOM w0.356: v2(112.07,95.84) 111.68,96.23 U8.E22 ; v1(132.9,98.67) 132.9,98.17 R405.1 ; v2(138.61,85.41) 138.22,85.8 VRAM1.C4 ; R315.1 120.1,99.05 120.58,99.53 v1(120.58,100.06) ; v2(128.21,108.64) 128.2,108.64 127.84,109 VRAM2.B10 ; VRAM2.H2 VRAM2.H1
  BOTTOM w0.381: v1(212.28,28.56) 212.28,27.09 211.48,26.29 C665.2 ; v2(94.81,109.1) 95.13,108.79 U8.Y2 ; C2590.1 65.07,28.22 v1(64.15,27.29) ; v2(97.12,105.8) 97.52,106.21 U8.U5 ; U8.K13 v2(104.53,100.23) U8.L14 105.53,101.23 v2(105.53,101.39) 105.87,101.73 U8.M15 106.06,101.73 v2(106.63,102.31) 107.03,102.7 U8.N16 U8.P17 U8.R18 109.41,105.11 v2(109.41,105.32) ; v2(102.67,93.2) 102.67,93.71 U8.B11 ; U8.AF11 102.55,113.63 v2(102.95,113.22) 102.94,113.22 U8.AE11 ; C567.2 207.36,37.96 v1(207.58,37.96) ; v2(107.09,112.43) 107.11,112.43 U8.AE17 ; Q6550.1 89.73,101.47 89.24,100.98 89.24,100.7 ; v1(48.68,12.91) 49.31,13.55 PC6039.1 ; U8.E2 94.45,96.28 v2(94.4,96.33) ; v2(195.05,20) 195.05,19.75 195.61,19.19 EC12.2 ; v2(89.22,29.83) 88.52,30.53 R2567.1 ; U8.AF14 105.41,113.25 v2(105.41,113.23) ; v2(58.69,24.19) 58.69,23.93 59.64,22.97 EC8.2 60.73,22.52 C752.1 ; C631.2 40.32,105.95 v1(40.32,106.18) ; C634.2 44.08,105.45 v1(44.13,105.4) ; C2594.1 92.37,30.82 v1(92.16,30.62) ; C20025.1 56.45,104.38 56.88,104.81 v2(56.88,105.19) ; v2(100.6,104.3) U8.R10 U8.T11 v2(102.64,106.34) U8.U12 v2(103.48,107.18) U8.V13 ; v1(12.25,22.86) 12.92,22.19 EC6500.2 ; R2566.1 88.91,26.56 v2(88.91,26.4) ; C446.1 120.52,103.33 v1(120.23,103.62) 119.94,103.33 C451.1 ; R356.1 89.72,98.79 v2(89.32,99.19) 89.94,99.81 C20016.1 ; v1(90.31,33.18) 90.28,33.16 R2565.1 R2564.1 ; v2(91.23,107.39) 90.61,107.39 90.16,106.94 R25587.1 90.16,105.85 R313.2 ; C529.1 205.5,24.04 v2(206.02,24.56) ; PR211.1 136.65,34.26 136.32,34.59 v1(136.32,34.86) ; VRAM1.J10 133.41,90.66 v2(133.79,91.05) ; PC7024.2 145.08,53.51 v1(145.27,53.71) ; v1(99.15,70.31) 99.87,70.31 100.2,69.97 R2481.1 100.69,69.97 101.15,69.51 R2480.1 ; v1(71.82,114.74) 71.77,114.79 71.23,114.79 PR9030.1 ; v2(102.52,107.94) 102.24,107.94 U8.V11 U8.U10 v2(100.62,106.32) ; v1(100.7,117.05) 100.7,117.77 C452.1 101.45,119.18 101.45,120.27 101.65,120.46 102.57,120.46 103.03,120 R325.1 ; U8.N10 101.03,102.94 v2(101.28,103.2) 101.82,103.73 U8.P11 102.03,103.74 v2(102.64,104.35) 103.02,104.73 U8.R12 U8.T13 v2(104.53,106.23) U8.U14 105.59,107.29 v2(105.59,107.33) 105.63,107.33 U8.V15 ; U8.AD15 v2(106.28,112.44) ; v2(206.09,26.31) 206.18,26.22 206.18,26.18 206.68,25.68 C583.1 ; R2561.2 84.94,32.4 v1(85.28,32.06) ; C844.1 196.23,31.91 v2(196.68,32.37) ; v1(95.07,118.18) 95.21,118.18 95.59,117.79 R396.2 ; v1(178.21,31.37) 178.21,31.38 FAN3.4 ; v1(105.93,66.05) 105.98,66 C2562.1 ; v2(97.12,104.17) 97.53,103.76 U8.P5 ; v2(89.27,95.79) 89.32,95.74 R354.1 ; 89.24,100.7 v2(89.24,100.52) ; 89.24,100.7 88.82,101.12 C20017.2 ; Q6555.1 v2(83.01,91.19) ; U8.AD16 v2(106.27,111.63) ; U8.AE20 110.01,112.83 v2(110.41,112.43) ; R2584.1 82.52,30.44 83.46,31.38 C2602.2 83.98,31.51 v1(84.1,31.63) ; U8.AD19 v2(109.52,112.4) ; C603.2 v1(116.85,25.13) ; v2(104.61,111.63) 104.21,112.03 U8.AD13 ; C578.2 203.69,25.67 v2(204.07,25.67) 204.52,26.11 C587.1 ; R2583.1 93.19,28.06 v1(93.2,28.04) 93.19,28.03 93.19,27.49 R2582.1 ; v2(201.75,26.39) 202.13,26.01 C584.2 ; VRAM2.N3 136.61,114.6 v2(137.01,115.01) ; v2(84.64,92.72) 85.03,93.11 C20020.2 ; U8.K15 106.03,99.78 v2(106.48,100.23) 106.98,100.73 U8.L16 v2(107.57,101.27) U8.M17 108.03,101.77 v2(108.5,102.24) 108.54,102.24 U8.N18 109.41,103.12 v2(109.41,103.36) ; R2537.1 70.72,32.13 68.54,29.96 68.54,27.88 67.55,26.88 66.85,26.88 C2592.1 66.84,26.71 67.19,26.36 v1(67.19,26.25) ; v2(89.31,97.45) 89.64,97.78 R355.1 ; v2(97.13,98.37) 97.53,98.77 U8.H5 ; v1(76.08,30.1) 76.08,30.78 R2541.2 76.57,30.8 76.69,30.93 R2587.2 ; v2(100.49,95.81) U8.E8 ; U8.L5 97.53,101.18 v2(97.13,100.78) ; U8.AC2 95.13,111.3 v2(94.83,111.6) ; v2(157.16,28.46) 156.94,28.68 PC6026.2 ; v1(135.46,42.67) 135.46,43.14 136.71,44.39 PR7033.2 ; U8.L18 109.03,100.73 108.42,100.12 v2(108.42,100.11) 108.42,100.11 108.03,99.73 U8.K17 107.77,99.47 v2(107.77,99.22) ; v1(48.19,11.95) 47.81,11.95 47.39,12.37 47.39,13.29 PR6031.1 ; U8.AC5 v2(97.18,111.58) ; CN13.1 205.82,15.14 v2(206.08,15.4) ; U8.L10 101.36,101.06 101.36,101.08 101.41,101.13 v2(101.41,101.17) 101.42,101.18 101.46,101.18 101.48,101.21 101.5,101.21 U8.M11 U8.N12 103.53,103.23 v2(103.53,103.25) 103.55,103.25 104.03,103.73 U8.P13 v2(104.53,104.23) U8.R14 105.03,104.73 105.42,105.12 v2(105.6,105.12) 106.03,105.55 U8.T15 v2(106.53,106.23) U8.U16 107.4,107.1 v2(107.4,107.11) 107.74,107.44 107.74,107.44 U8.V17 ; PU3003.2 164.48,23.3 v1(164.78,23.61) ; R326.2 89.86,88.62 89.46,89.02 R398.1 89.18,89.67 v1(88.83,89.67) 88.48,89.67 88.21,89.4 R25546.2 ; v1(94.76,104.15) 95.13,103.79 U8.P2 ; v1(118.88,25.1) 119.47,24.51 C601.2 ; v2(89.27,96.63) 89.97,96.63 R353.1 ; U8.E20 109.99,96.19 v2(110.39,95.79) ; v2(89.34,92.82) 89.34,92.94 89.98,93.59 R357.1 ; U8.AD22 111.26,111.66 v2(111.26,111.61) ; v2(103.8,112.42) 103.78,112.42 U8.AD12 ; v1(206.64,20.23) 206.64,20.72 207.19,21.27 U18.2 ; v1(143.65,44.89) 143.2,44.89 PC7012.2 ; v1(139.33,61.46) 139.52,61.65 PC9074.2 ; v2(111.2,110.78) 111.63,111.21 U8.AC22 ; v2(202.36,23.55) 202.14,23.34 C736.2 ; PC9029.2 69.12,111.34 69.18,111.28 69.18,110.07 v1(69.1,109.99) 69.1,109.61 69.09,109.6 PC9027.2 ; v1(105.7,29.04) 105.61,29.13 105.61,30.14 105.9,30.42 106.23,30.42 106.94,31.13 PQ14.1 108.21,30.37 PQ19.1 ; R25272.1 19.4,25.97 19.4,26.88 19.78,27.27 v1(20.23,27.27) ; v2(102.92,95.86) U8.E11 ; v2(107.95,111.61) 108.35,112 U8.AD18 ; U8.AB14 v2(104.59,110.83) ; SW1.3 196.54,25.39 v2(196.54,24.87) ; VRAM2.E12 130.23,107.4 v2(130.61,107.78) ; v1(99.28,121.14) 99.32,121.18 100.17,121.18 U11.3 ; v2(200.52,26.45) 200.22,26.75 R734.2 ; v2(89.27,94.12) 89.31,94.12 89.91,94.73 R358.1 ; U8.L2 95.06,101.25 v2(94.72,101.59) ; U8.AE14 105.41,112.45 v2(105.41,112.43) ; v1(144.66,36.36) 144.43,36.12 PC6023.2 ; v2(19.49,19.72) 19.52,19.72 19.58,19.66 R25277.1 ; C20005.1 103.21,122.85 103.72,122.34 v1(103.77,122.34) ; U8.AF17 107.5,113.63 107.1,113.23 107.09,113.23 v2(107.09,113.23) ; v1(113.16,14.99) 113.16,15.81 PJ1.9 ; C565.2 208.72,38.64 208.82,38.75 v1(208.82,39) ; PR9077.2 72.21,105.02 71.93,104.75 PQ9009.1 71.37,105.2 71.82,105.65 v1(72.1,105.65) ; v2(17.51,19.73) 17.51,19.52 17.02,19.03 R25279.1 ; v1(132.14,54.09) 132.22,54.17 PC7018.2 ; v2(57.62,24.22) 57.04,23.64 57.04,23 56.96,22.93 EC7.1 ; v1(129.88,80.83) 129.62,80.57 C497.1 ; PR9274.2 v1(80.52,117.16) ; v2(109.41,107.29) 109.41,107.11 U8.U18 U8.T17 107.9,105.73 v2(107.4,105.23) 107.4,105.1 U8.R16 107.03,104.73 v2(106.61,104.31) 106.03,103.73 U8.P15 U8.N14 105.02,102.73 104.54,102.25 v2(104.54,102.24) U8.M13 v2(103.56,101.26) U8.L12 102.45,100.15 v2(102.45,100.11) 102.41,100.11 U8.K11 ; U8.Y5 v2(97.1,109.12) ; C602.2 v1(118.25,25.13) ; U8.AA7 98.93,109.83 98.93,110.12 99.2,110.39 U8.AB7 v2(99.65,110.81) U8.AC8 ; U8.AD21 v2(111.23,112.43) ; C604.2 v4(115.45,25.13) ; v1(11.77,17.79) 11.88,17.9 PQ9050.1 ; U8.AG2 94.76,114.06 v2(94.76,114.06) 94.33,113.63 U8.AF1 ; v2(97.17,96.73) 97.58,96.32 U8.E5 ; v1(212.4,30.92) 212.18,30.7 C595.2 R479.2 ; U8.AB17 v2(107.13,110.77) ; U8.U2 95.13,106.16 v1(94.76,105.8) ; U8.AF20 v2(110.39,113.23) ; R25275.1 v1(17.09,26.42) ; v2(180.45,31.38) 181.77,31.38 ; U8.AB11 v2(102.97,110.81)
  BOTTOM w0.508: C515.1 19.27,37.81 19.27,39.86 v1(19.26,39.86) U15.2 ; v1(122.31,39.53) 122.37,39.47 PR273.2 ; CN1.2 13.67,6.66 v1(12.99,5.98) ; v1(151.95,24.29) 151.98,24.29 152.4,24.72 CN19.2 ; PQ9010.1 76.78,101.57 76.78,101.12 v1(76.83,101.07) 76.83,101.06 PQ9011.1 ; C750.1 67.08,23.02 C749.1 67.08,22.35 66.28,21.55 v1(66.28,21.32) ; v1(18.03,57.84) 18.64,57.23 C514.1 ; CN38.1 33.9,116.63 v1(34.58,117.31) ; C2143.1 92.55,85.46 v1(92.53,85.44) ; 82.94,99.27 82.94,97.95 82.34,97.36 U19.2 ; v1(207.45,10.51) 207.89,10.95 CN13.5 ; v1(130.73,120.88) 130.58,120.73 C487.2 ; R2492.2 v1(101.38,56.39) ; v1(38.27,105.98) 38.27,106.95 38.9,107.58 U25.25 ; v1(30.64,17.46) 30.31,17.13 C6547.2 ; R406.1 131.24,102.85 131.51,103.11 v1(131.51,103.75) ; v1(139.74,41.61) 139.97,41.37 PU7004.9 141.48,41.37 v1(141.72,41.6) ; C2361.2 100.36,34.66 v1(99.71,35.32) ; CN13.6 200.22,11.92 199.8,12.33 199.45,12.33 v1(199.37,12.26) ; v1(90.87,29.09) 90.89,29.07 C6617.1
  vias: v1(1.03,26.76) v1(2.37,122.11) v1(3.08,21.88) v1(3.59,43.72) v1(3.87,46.32) v1(4.35,111.92) v1(4.91,26.76) v1(5.83,11.42) v1(5.95,111.95) v1(6.21,67.6) v1(6.49,62.19) v1(7.43,86.93) v1(7.78,121.93) v1(9.18,26.07) v1(9.26,45.93) v1(9.33,42.84) v1(9.49,67.35) v1(9.87,81.9) v1(9.97,70.45) v1(9.99,62.88) v1(10.4,120.53) v1(12.41,25.72) v1(12.86,0.93) v1(13.68,120.51) v1(14.08,16.45) v1(14.08,14.69) v1(14.21,119.06) v1(14.18,45.53) v1(14.18,44.87) v1(14.18,44.23) v1(14.18,43.6) v1(14.21,24.8) v1(14.49,17.56) v1(15.05,113.75) v1(15.04,89.18) v1(15.17,113.12) v1(15.47,89.73) v1(15.51,80.38) v1(15.51,78.35) v1(15.51,76.31) v1(15.68,113.85) v1(15.86,113.24) v1(15.99,84.96) v1(16.1,90.37) v1(16.1,89.59) v1(16.14,22.49) v1(16.24,24.4) v1(16.55,85.91) v1(16.57,85.28) v1(16.7,28.79) v1(17.21,117.94) v1(17.22,52.24) v1(17.21,0.93) v1(17.26,29.15) v1(17.26,28.48) v1(17.89,51.36) v1(18.45,22.24) v1(18.78,98.82) v1(18.78,98.16) v1(18.78,97.52) v1(18.98,34.38) v1(19.11,82.28) v1(19.22,55.16) v1(19.62,49.14) v1(19.62,48.12) v1(20,73.67) v1(20.13,48.63) v1(20.15,10.63) v1(20.41,117.94) v1(20.64,49.14) v1(20.64,48.12) v1(20.79,10.63) v1(20.93,72.81) v1(21.01,42.1) v1(21.25,33.62) v1(21.3,56.68) v1(21.35,7.3) v1(21.4,72.39) v1(21.39,54.54) v1(21.42,10.81) v1(21.49,51.23) v1(21.57,52.09) v1(21.65,93.59) v1(21.84,71.93) v1(21.75,55.27) v1(22.01,28.15) v1(22.01,27.27) v1(22.01,26.38) v1(22.08,31.1) v1(22.11,30.4) v1(22.34,43.65) v1(22.54,93.59) v1(22.54,45.71) v1(22.57,70.93) v1(22.74,31.1) v1(22.74,24.22) v1(22.77,22.16) v1(23.33,60.72) v1(23.43,93.59) v1(23.63,117.94) v1(24.04,36.33) v1(25.18,3.24) v1(25.92,3.26) v1(26.33,104.43) v1(26.33,22.5) v1(26.38,25.54) v1(26.48,11.97) v1(26.58,85.84) v1(26.55,85.15) v1(26.55,84.52) v1(26.55,83.78) v1(26.6,35.95) v1(26.76,97.37) v1(26.81,82.21) v1(26.81,80.25) v1(26.81,78.35) v1(26.86,96.73) v1(26.86,96.1) v1(27.14,95.52) v1(27.11,76.52) v1(27.21,117.89) v1(27.19,74.46) v1(27.32,34.38) v1(28.18,11.95) v1(28.43,104.43) v1(28.39,84.82) v1(28.41,84.14) v1(29.02,19.97) v1(29.17,5.07) v1(29.3,12.94) v1(29.65,19.97) v1(29.78,25.46) v1(29.93,24.29) v1(29.96,12.94) v1(30.08,5.07) v1(30.29,19.97) v1(30.67,117.92) v1(30.92,85.04) v1(31.43,28) v1(31.61,12.81) v1(32.04,14.69) v1(32.17,5.07) v1(32.29,12.84) v1(32.9,91.26) v1(32.95,12.86) v1(33.08,4.69) v1(33.23,100.75) v1(33.23,32.47) v1(33.62,31.08) v1(34.28,31.08) v1(34.66,11.85) v1(35.14,100.75) v1(35.14,4.69) v1(35.34,24.04) v1(35.4,104.48) v1(36,24.04) v1(36.13,119.37) v1(36.33,13.42) v1(36.64,122.34) v1(37.22,4.69) v1(38.09,24.14) v1(38.34,98.26) v1(38.25,20.26) v1(38.25,19.63) v1(38.89,20.26) v1(38.89,19.63) v1(39.51,19.91) v1(39.58,32.6) v1(40.02,20.5) v1(40.19,24.12) v1(40.37,32.62) v1(40.65,20.5) v1(40.91,110.86) v1(40.93,110.2) v1(40.85,100.87) v1(41.15,32.63) v1(41.29,20.5) v1(41.39,31.2) v1(41.89,32.61) v1(41.92,20.5) v1(42.02,31.2) v1(42.43,98.82) v1(42.56,20.5) v1(42.66,31.2) v1(43.09,98.82) v1(43.24,106.29) v1(43.22,104.53) v1(43.19,20.48) v1(43.29,31.2) v1(43.75,98.82) v1(43.9,14.11) v1(44,19.93) v1(44.41,98.82) v1(44.64,19.93) v1(44.99,104.56) v1(45.78,32.63) v1(46.32,8.93) v1(46.32,8.29) v1(46.42,32.6) v1(46.95,101.76) v1(46.95,8.93) v1(46.95,8.29) v1(47.31,122.46) v1(47.31,121.83) v1(47.31,121.19) v1(47.27,120.54) v1(47.59,8.93) v1(47.59,8.29) v1(47.91,120.46) v1(48.17,101.13) v1(48.56,120.44) v1(49.46,10.93) v1(49.87,27.98) v1(50.14,97.53) v1(50.4,113.12) v1(50.99,112.2) v1(51.01,27.98) v1(51.42,107.96) v1(51.78,110.07) v1(51.9,96.99) v1(53.02,15.02) v1(53.1,124.7) v1(53.55,12.97) v1(53.66,15) v1(55.28,124.47) v1(55.28,123.84) v1(56.04,97.73) v1(56.32,100.34) v1(58.1,97.75) v1(58.41,100.34) v1(58.71,14.97) v1(58.83,119.01) v1(58.83,118.38) v1(58.85,117.69) v1(58.89,12.94) v1(59.19,97.74) v1(59.46,119.01) v1(59.46,118.38) v1(59.49,117.69) v1(60.1,119.01) v1(60.1,118.38) v1(60.12,117.69) v1(60.46,100.34) v1(60.62,103.85) v1(60.73,118.38) v1(60.76,117.69) v1(61.12,103.41) v1(61.43,117.64) v1(62.06,117.92) v1(62.88,110.48) v1(64.2,104.18) v1(64.68,13.04) v1(68.31,125.59) v1(71.33,12.89) v1(71.46,96.83) v1(72.1,96.83) v1(72.42,77.31) v1(72.86,96.83) v1(73.01,110.76) v1(73.06,110.02) v1(73.13,20.13) v1(73.33,125.56) v1(73.54,118.38) v1(73.54,117.41) v1(73.85,111.52) v1(73.76,20.13) v1(73.87,110.81) v1(73.9,110.04) v1(73.96,125.56) v1(73.96,117.89) v1(74.32,124.95) v1(74.53,76.38) v1(74.6,125.56) v1(74.58,124.35) v1(74.81,111.52) v1(74.84,110.76) v1(74.81,110.04) v1(74.95,124.95) v1(75.23,125.56) v1(75.21,124.35) v1(75.59,124.95) v1(75.85,124.35) v1(75.87,125.56) v1(76.22,124.99) v1(76.5,125.56) v1(76.48,124.35) v1(76.85,124.89) v1(77.27,124.38) v1(77.33,100.67) v1(77.4,92.8) v1(77.85,92.3) v1(78.25,78.85) v1(78.42,125.16) v1(78.83,34.47) v1(79.41,20.03) v1(79.69,12.97) v1(79.92,108.04) v1(79.92,107.4) v1(79.92,106.77) v1(80.06,93.01) v1(80.27,119.3) v1(80.27,118.67) v1(80.27,118.03) v1(80.54,92.53) v1(80.55,108.04) v1(80.55,107.4) v1(80.55,106.77) v1(80.61,99.63) v1(80.94,124.9) v1(80.9,119.3) v1(80.9,118.67) v1(80.9,118.03) v1(81.19,108.04) v1(81.19,107.4) v1(81.19,106.77) v1(81.82,108.04) v1(81.82,107.4) v1(81.82,106.77) v1(81.83,94.06) v1(82,33.4) v1(82.03,31.46) v1(82.31,93.59) v1(83.5,124.9) v1(84.34,82.28) v1(84.34,52.82) v1(84.44,107.3) v1(84.44,106.67) v1(84.44,106.03) v1(84.44,105.4) v1(84.44,104.76) v1(84.4,81.1) v1(84.4,80.46) v1(84.88,99.5) v1(85.07,107.3) v1(85.07,106.67) v1(85.07,106.03) v1(85.07,105.4) v1(85.07,104.76) v1(85.15,104.13) v1(85.25,33.53) v1(85.71,107.05) v1(85.71,106.41) v1(85.71,105.78) v1(85.71,105.14) v1(85.71,104.51) v1(85.94,125.13) v1(86.04,85.33) v1(86.37,104.71) v1(86.47,84.82) v1(86.52,68.62) v1(86.49,66.73) v1(86.52,66.03) v1(86.52,65.14) v1(86.52,64.12) v1(86.52,63) v1(86.75,127.09) v1(86.85,55.99) v1(86.93,53.14) v1(87.18,52.49) v1(87.44,57.14) v1(87.47,57.8) v1(87.62,48.59) v1(88.45,52.56) v1(89.52,55.64) v1(89.72,52.46) v1(89.75,48.15) v1(90.8,80.04) v1(90.8,79.38) v1(90.99,52.46) v1(91.24,85.16) v1(91.4,12.97) v1(91.69,84.68) v1(91.96,14.31) v1(92.59,14.31) v1(93.46,127.06) v1(93.94,12.97) v1(96.38,127.09) v1(96.48,12.97) v1(97.01,119.11) v1(97.91,64.5) v1(98.08,121.15) v1(98.46,75.53) v1(98.54,74.86) v1(98.92,127.09) v1(98.89,52.27) v1(99.02,12.97) v1(99.2,116.22) v1(99.22,62.87) v1(99.22,60.07) v1(99.15,47.11) v1(99.78,74.51) v1(99.86,60.11) v1(99.92,49.44) v1(100.06,15.64) v1(100.27,62.94) v1(101.46,127.09) v1(101.48,78.73) v1(101.56,12.97) v1(101.74,50) v1(101.74,49.36) v1(102.02,116.8) v1(102.12,78.47) v1(102.17,114.74) v1(104,127.09) v1(104.07,50.23) v1(104.1,12.97) v1(104.79,121.02) v1(105.01,44.13) v1(105.09,26.53) v1(105.43,123.79) v1(105.41,123.15) v1(105.43,122.52) v1(105.47,119.37) v1(105.47,118.73) v1(105.47,118.1) v1(105.65,46.54) v1(105.62,45.22) v1(105.73,26.55) v1(105.68,22.9) v1(105.75,43.01) v1(106.28,47.76) v1(106.54,127.09) v1(106.54,74.76) v1(106.47,16.5) v1(106.56,74.13) v1(106.61,27.01) v1(106.64,12.97) v1(106.69,17.16) v1(107.1,16.56) v1(107.2,74.1) v1(107.33,17.16) v1(107.74,16.5) v1(108.37,16.5) v1(108.6,17.16) v1(108.66,124.19) v1(108.66,123.56) v1(108.66,122.92) v1(108.93,46.19) v1(109.01,16.5) v1(109.08,127.09) v1(109.21,45.6) v1(109.23,44.03) v1(109.23,43.39) v1(109.18,12.97) v1(109.38,69.51) v1(110.02,69.51) v1(110.63,55.36) v1(110.63,54.72) v1(110.65,69.51) v1(111.29,69.51) v1(111.26,55.36) v1(111.26,54.72) v1(111.31,45.43) v1(111.26,44.79) v1(111.44,119.37) v1(111.44,118.1) v1(111.62,127.09) v1(111.57,44.21) v1(111.72,12.97) v1(111.95,120.64) v1(111.92,69.51) v1(111.9,55.36) v1(111.9,54.72) v1(111.92,44.79) v1(112.08,119.37) v1(112.08,118.1) v1(112.52,86.47) v1(112.52,85.83) v1(113.89,72.88) v1(113.89,72.25) v1(113.89,71.61) v1(114.16,127.09) v1(114.26,12.97) v1(114.53,38.29) v1(114.53,37.65) v1(114.53,37.02) v1(114.53,36.38) v1(114.74,72.88) v1(114.74,72.25) v1(114.74,71.61) v1(114.84,35.83) v1(115.17,38.29) v1(115.17,37.65) v1(115.17,37.02) v1(115.16,36.38) v1(115.8,122.42) v1(115.84,121.78) v1(115.78,60.84) v1(115.76,59.55) v1(115.84,41.56) v1(115.86,123.32) v1(115.94,40.93) v1(116.42,60.84) v1(116.39,59.55) v1(116.39,49.03) v1(116.39,48.4) v1(116.39,47.76) v1(116.39,47.13) v1(116.7,127.09) v1(116.7,40.93) v1(116.8,12.97) v1(117.03,49.03) v1(117.03,48.4) v1(117.03,47.76) v1(117.03,47.13) v1(118.96,75.93) v1(119.24,127.09) v1(119.34,12.97) v1(119.42,76.39) v1(119.42,75.47) v1(119.76,66.93) v1(119.87,76.85) v1(119.87,75.93) v1(119.87,75.02) v1(120.08,69.28) v1(120.33,77.3) v1(120.33,76.39) v1(120.33,75.47) v1(120.33,74.56) v1(120.31,67.25) v1(120.31,66.61) v1(120.79,76.85) v1(120.79,75.93) v1(120.79,75.02) v1(120.95,67.25) v1(120.95,66.61) v1(120.95,67.88) v1(121.01,65.95) v1(121.02,48.22) v1(121.02,47.59) v1(121.02,46.95) v1(121.02,46.32) v1(121.14,68.49) v1(121.25,77.3) v1(121.25,76.39) v1(121.25,75.47) v1(121.59,67.88) v1(121.58,67.25) v1(121.58,66.61) v1(121.63,17.16) v1(121.7,76.85) v1(121.7,75.93) v1(121.65,48.22) v1(121.65,47.59) v1(121.65,46.95) v1(121.65,46.32) v1(121.8,68.52) v1(121.88,12.97) v1(122.16,77.3) v1(122.16,76.39) v1(122.22,67.88) v1(122.22,67.25) v1(122.22,66.61) v1(122.46,127.01) v1(122.49,94.6) v1(122.62,77.76) v1(122.62,76.85) v1(123.03,117.68) v1(122.95,80.25) v1(123.07,77.3) v1(123.89,94.6) v1(124.42,12.97) v1(124.65,20.79) v1(124.83,124.85) v1(125.28,49.9) v1(125.28,49.01) v1(125.28,48.12) v1(125.28,36.56) v1(125.28,20.79) v1(125.44,19.52) v1(125.74,121.68) v1(125.74,121.04) v1(125.92,36.56) v1(126.1,19.52) v1(126.17,49.9) v1(126.17,49.01) v1(126.17,48.12) v1(126.3,42.79) v1(126.3,42.15) v1(126.73,19.52) v1(126.91,77.48) v1(126.91,56.48) v1(126.93,42.79) v1(126.93,42.15) v1(126.91,12.89) v1(126.97,30.54) v1(127.19,49.9) v1(127.19,49.01) v1(127.19,48.12) v1(127.57,42.79) v1(127.57,42.15) v1(127.61,30.57) v1(127.65,29.93) v1(127.65,29.29) v1(127.92,48.81) v1(127.92,48.08) v1(128.13,23.23) v1(128.25,30.56) v1(128.31,69.05) v1(128.31,68.06) v1(128.31,67.14) v1(128.29,29.93) v1(128.29,29.29) v1(128.54,124.95) v1(128.76,23.23) v1(129.07,69.05) v1(129.07,68.06) v1(129.07,67.14) v1(129.45,23.1) v1(129.5,12.97) v1(129.82,67.25) v1(129.89,67.89) v1(130.01,51.13) v1(130.08,77.58) v1(130.11,23.1) v1(130.28,66.78) v1(130.26,66.12) v1(130.52,42.43) v1(130.89,66.99) v1(130.9,66.23) v1(131.15,42.43) v1(131.53,66.86) v1(131.53,66.23) v1(131.51,50.41) v1(131.63,74.61) v1(131.94,77.1) v1(132.04,12.97) v1(132.35,74.61) v1(132.6,77.18) v1(132.79,80.75) v1(132.78,47.99) v1(133.06,74.61) v1(133.45,80.73) v1(133.41,47.99) v1(133.77,74.61) v1(134.3,66.51) v1(134.3,65.87) v1(134.3,65.24) v1(134.3,64.6) v1(134.3,63.97) v1(134.58,12.97) v1(134.94,66.51) v1(134.94,65.87) v1(134.94,65.24) v1(134.94,64.6) v1(134.94,63.97) v1(135.57,98.67) v1(135.7,96.63) v1(135.72,80.76) v1(136.21,98.67) v1(136.39,80.76) v1(136.46,96.63) v1(136.84,56.37) v1(136.84,54.47) v1(136.84,52.56) v1(137.12,12.97) v1(137.17,28.08) v1(137.6,42.79) v1(138.21,42.58) v1(138.54,72.93) v1(138.47,41.98) v1(138.49,41.34) v1(138.48,40.68) v1(138.75,56.37) v1(138.75,54.47) v1(138.75,52.56) v1(139.06,42.26) v1(139.06,41.63) v1(139.25,72.93) v1(139.38,33.49) v1(139.66,12.97) v1(139.97,72.93) v1(140.07,16.7) v1(140.55,17.16) v1(140.68,72.93) v1(140.65,54.47) v1(140.65,52.56) v1(141.06,29.58) v1(141.82,38.96) v1(142.08,39.56) v1(142.2,12.97) v1(142.4,117.61) v1(142.76,38.49) v1(143.47,29.96) v1(143.98,92.8) v1(144,78.24) v1(143.98,30.34) v1(144.05,117.16) v1(144.05,114.62) v1(144.05,112.08) v1(144.05,109.54) v1(144.05,107) v1(144.05,104.46) v1(144.05,101.92) v1(144.05,99.38) v1(144.05,96.84) v1(144.05,88.61) v1(144.05,82.18) v1(144.05,73.09) v1(144.08,68.95) v1(144.21,64.71) v1(144.49,29.96) v1(144.74,12.97) v1(145.02,30.34) v1(145.27,16.6) v1(145.55,41.64) v1(145.83,57.52) v1(146.92,47.26) v1(147.28,12.97) v1(148.93,50.99) v1(149.82,12.97) v1(149.95,37.3) v1(152.36,18.02) v1(152.36,12.97) v1(154.19,18.02) v1(154.85,18.02) v1(154.9,12.97) v1(155.28,38.31) v1(156.4,37.43) v1(156.65,18.02) v1(156.93,37.83) v1(157.44,38.21) v1(157.44,12.97) v1(157.58,19.54) v1(157.92,18.02) v1(158.81,18.02) v1(159.48,19.54) v1(159.7,36.69) v1(159.7,18.02) v1(159.98,12.97) v1(160.46,34.96) v1(160.59,18.02) v1(161.15,37.53) v1(161.48,18.02) v1(162.52,12.97) v1(165.06,12.97) v1(167.45,34.63) v1(167.42,18.02) v1(167.6,12.97) v1(169.92,23.61) v1(170.14,12.97) v1(172.68,12.97) v1(175.22,12.97) v1(175.58,34.2) v1(177.76,12.97) v1(180.3,12.97) v1(182.59,34.3) v1(185.53,8.95) v1(188.07,8.95) v1(188.68,35.27) v1(190.61,8.95) v1(193.15,8.95) v1(195.11,37.25) v1(195.69,8.95) v1(198.23,8.95) v1(199.5,39.38) v1(200.77,8.95) v1(202.75,34.53) v1(202.75,33.13) v1(203.31,8.95) v1(204.02,42.45) v1(204.66,34.53) v1(204.66,32.63) v1(204.66,30.72) v1(205.85,8.95) v1(206.03,34.53) v1(206.18,30.72) v1(206.56,32.63) v1(207.91,45.91) v1(208.39,8.95) v1(210.4,22.34) v1(210.72,21.78) v1(210.93,8.95) v1(210.96,49.47) v1(211.51,37.2) v1(211.52,36.18) v1(211.52,35.17) v1(211.64,34.4) v1(213.8,8.93) v1(214.13,48.78) v1(214.44,49.34) v1(214.79,48.78) v1(215.1,49.34) v1(216.34,8.93) v1(217.79,47.18) v1(217.79,44.64) v1(217.79,42.79) v1(217.79,31.76) v1(217.79,29.91) v1(217.79,28.08) v1(217.79,26.22) v1(218.88,17.94) v1(218.88,15.4) v1(218.88,12.86) v1(218.88,10.32) v2(28.22,52.65) v2(28.21,51.49) v2(28.23,49.26) v2(28.23,48.43) v2(28.54,76.88) v2(28.83,73.11) v2(28.9,57.14) v2(29.55,42.63) v2(29.81,75.27) v2(30.54,55.69) v2(30.52,41.18) v2(30.81,72.63) v2(31.43,94.42) v2(31.41,34.23) v2(31.56,40.22) v2(31.84,51.73) v2(31.9,76.89) v2(32.21,54.12) v2(32.86,86.21) v2(33.17,88.72) v2(35.59,41.97) v2(36.49,35.49) v2(38.05,81.17) v2(38.21,63.69) v2(39.76,88.91) v2(40.39,80.69) v2(40.92,75.98) v2(41.59,84.08) v2(41.59,81.55) v2(41.87,55.06) v2(42.04,89.57) v2(42.29,84.09) v2(42.29,83.44) v2(43.45,74.88) v2(44.73,53.92) v2(45.5,88.97) v2(45.73,41.8) v2(45.84,67.12) v2(45.96,65.26) v2(46.21,76.08) v2(46.5,67.13) v2(46.67,78.13) v2(46.71,36) v2(46.95,65.79) v2(46.94,49.74) v2(46.98,64.38) v2(47.28,87.46) v2(47.76,67.45) v2(47.88,48.72) v2(48.12,65.77) v2(48.36,67.45) v2(48.38,48.28) v2(48.83,51.9) v2(48.96,53.5) v2(52.15,57.09) v2(52.16,56.04) v2(52.16,54.45) v2(52.28,49.51) v2(52.56,66.18) v2(52.7,61.23) v2(53.05,53.55) v2(53.5,78.58) v2(53.58,43.93) v2(53.58,33.51) v2(53.86,87.41) v2(54.05,63.23) v2(54.23,64.4) v2(54.31,89.53) v2(54.45,50.36) v2(54.68,84.33) v2(54.89,94.68) v2(54.91,69.21) v2(54.98,54.44) v2(55.05,55.71) v2(55.14,38.91) v2(55.48,95.62) v2(55.48,57.13) v2(55.65,64.42) v2(55.9,67.15) v2(55.87,60.95) v2(56.25,64.43) v2(56.4,65.78) v2(57.07,67.14) v2(59.98,25.67) v2(60.23,95.39) v2(60.26,94.8) v2(60.67,49.14) v2(60.82,95.34) v2(60.85,94.75) v2(61,24.32) v2(61.12,49.62) v2(61.41,95.31) v2(61.43,94.73) v2(61.63,50.07) v2(61.99,95.31) v2(62.02,94.73) v2(62.11,50.58) v2(62.55,43.47) v2(63.03,43.93) v2(63.59,62.19) v2(63.59,61.33) v2(64.22,62.19) v2(64.22,61.33) v2(64.86,61.33) v2(65.49,62.19) v2(65.49,61.33) v2(67.93,86.65) v2(68.35,86.23) v2(68.77,85.81) v2(68.84,77.68) v2(68.83,71.68) v2(69.19,85.38) v2(69.16,57.1) v2(69.68,51.69) v2(69.83,84.75) v2(69.84,55.37) v2(69.93,74.33) v2(69.96,71.64) v2(70.03,53.6) v2(70.34,75.96) v2(70.49,50.02) v2(70.87,67.5) v2(70.97,57.09) v2(71.09,65.01) v2(71.19,53.63) v2(71.41,71.76) v2(71.37,58.92) v2(71.5,51.68) v2(71.63,63.76) v2(71.64,60.68) v2(71.68,48.23) v2(76.08,82.31) v2(76.37,78.85) v2(79.28,82.21) v2(79.36,83.33) v2(79.62,83.88) v2(80,83.43) v2(80.62,78.85) v2(80.66,81.8) v2(82.31,81.04) v2(83.72,49.48) v2(84.95,49.31) v2(85.89,49.44) v2(87.16,49.34) v2(105.57,91.45) v2(106.51,91.22) v2(109.99,50.23) v2(110.48,41.34) v2(111.52,49.95) v2(111.72,41.54) v2(112.74,49.9) v2(113.07,40.98) v2(113.7,49.95) v2(114.41,41.06) v2(116.85,102.6) v2(117.16,110.22) v2(117.54,113.52) v2(117.66,111.62) v2(135.41,91.01) v2(138.61,92.61) v2(138.61,91.81) v2(138.61,91.01) v2(139.41,90.21) v2(152.54,26.94) v2(153.12,26.94) v2(154.42,22.72) v2(156.58,26.94) v2(157.16,26.99) v2(180.53,25.28) v2(180.94,28.51) v2(181.62,25.26) v2(184.49,10.37) v2(186.76,24.24) v2(190.31,10.53) v2(190.94,10.53) v2(191.58,10.53) v4(80.18,58.89) v4(84.06,33.6) v4(86.49,46.74) v4(86.5,45.43) v4(88.17,46.08) v4(88.17,45.47) v4(89.8,47.39) v4(89.8,46.74) v4(91.5,46.73) v4(91.52,44.75) v4(97.39,52.1) v4(99.11,42.74)
