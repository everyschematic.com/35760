# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC1#: length 122
  IN2 w0.089: v1(101.71,27.55) 101.71,27.85 102.02,28.15 102.98,28.15 103.29,28.46 103.29,29.23 103.06,29.45 103.05,29.45 101.75,30.76 100.7,30.76 100.37,31.09 96.13,31.09 95.8,30.76 93.63,30.76 92.86,29.98 91.77,29.98 91.33,30.42 88.97,30.42 88.39,29.84 82.19,29.84 80.99,31.04 80.99,31.74 80.57,32.16 78.89,32.16 77.33,33.72 75.7,33.72 75.35,33.36 67.7,33.36 65.11,30.77 64.45,30.77 64.32,30.9 64.32,30.91 64.01,31.23 64.01,31.76 63.61,32.16 54.54,32.16 53.64,31.25 49.77,31.25 49.62,31.41 48.88,31.41 48.86,31.43 47.74,31.43 46.77,30.47 44.08,30.47 43.98,30.36 41.06,30.36 40.45,30.97 35.6,30.97 31.39,35.19 31.39,36.11 29.24,38.26 20.31,38.26 v1(20.13,38.09)
  IN3 w0.089: v1(101.71,27.55) 101.6,27.65 101.6,30.32 103.6,32.32 103.91,32.32 104.74,33.15 104.74,33.74 104.6,33.88 104.6,34.94 103.8,35.75 103.8,36.89 103.93,37.03 v1(103.95,37.03)
  BOTTOM w0.102: U2030.C9 96.28,40.34 96.73,39.89 96.79,39.83 98.12,39.83 99.81,38.14 100.04,37.9 C2587.1 101.36,37.9 R2522.2 102.1,36.94 102.3,36.74 103.64,36.74 103.93,37.03 v1(103.95,37.03) ; v1(20.13,38.09) 19.72,38.49 19.72,40.71 19.62,40.81 U15.3
USB_OC2#: length 167.7
  IN1 w0.089: v2(196.9,21.87) 196.93,21.87 197.05,21.75 198.18,21.75 198.81,22.38 201.45,22.38 201.8,22.03 202.68,22.03 204.43,20.28 205.17,20.28 206.49,18.96 v1(207.89,18.96)
  IN3 w0.089: v1(96.56,19.37) 96.56,19.73 97.48,20.66 97.48,20.9 96.45,21.93 96.45,22.84 97.62,24 100.04,24 100.47,24.44 102.43,24.44 102.7,24.71 102.7,26.14 103.73,27.17 103.73,28.47 104.45,29.19 104.45,30.26 104.98,30.78 104.98,31.43 106.61,33.07 106.61,35.32 106.53,35.4 106.53,39.8 106.37,39.97 106.37,41.74 v1(106.3,41.81) ; v2(196.9,21.87) 196.32,21.87 195.78,21.33 189.81,21.33 189.23,20.74 188.08,20.74 187.64,20.31 183.17,20.31 182.57,19.71 182.57,19.15 181.77,18.34 179.58,18.34 179,18.92 177.42,18.92 176.57,18.07 175.52,18.07 174.83,18.76 173.38,18.76 173.14,18.52 165.44,18.52 165.11,18.19 165.11,17.21 164.88,16.97 151.05,16.97 150.44,17.58 139.44,17.58 138.83,16.97 128.31,16.97 127.7,16.36 126.38,16.36 126.1,16.64 121.98,16.64 121.7,16.36 112.5,16.36 110.22,14.08 100.46,14.08 99.82,14.71 99.17,14.71 v1(98.77,14.31)
  BOTTOM w0.102: v1(207.89,18.96) 207.89,19.28 208.6,19.99 208.6,20.22 208.5,20.32 U18.3 ; v1(96.56,19.37) 98.77,17.16 v1(98.77,14.31) ; v1(106.3,41.81) 106.29,41.82 104.88,41.82 103.69,40.62 R2508.2 101.41,40.62 101.2,40.83 C2582.1 100.85,40.58 100.75,40.49 98.55,40.49 98.52,40.52 97.63,40.52 97.5,40.65 95.74,40.65 U2030.D9
USB_OC3#: length 6.1
  BOTTOM w0.102: R25437.2 101.23,38.49 TP2091.1 100.97,38.43 99.99,38.43 98.39,40.03 97.03,40.03 96.95,40.11 U2030.B9
USBCOMP: length 7.3
  TOP w0.102: R2227.1 89.39,33.82 89.11,34.1 88.56,34.1 86.8,35.85 86.8,37.31 86.73,37.39 86.73,38.56 v4(86.79,38.62)
  BOTTOM w0.102: v4(86.79,38.62) 86.58,38.41 U2030.AB6
USBON#: length 231.4
  TOP w0.102: U37.99 196.45,29.08 196.91,28.61 196.91,27.51 195.42,26.02 195.1,26.02 194.24,25.16 v2(194.24,23.88)
  IN1 w0.089: v2(194.24,23.88) 194.24,23.99 194.68,24.43 195.2,24.43 196.23,23.41 197.2,23.41 197.4,23.61 197.83,23.61 198.66,22.78 201.61,22.78 201.97,22.43 202.85,22.43 204.6,20.67 205.33,20.67 v2(206.19,19.81)
  IN2 w0.089: v2(194.24,23.88) 193.86,23.51 193.1,23.51 192.97,23.63 192.97,24.19 191.7,25.46 189.28,25.46 188.76,25.98 188.36,25.98 187.99,26.34 187.99,26.59 187.63,26.95 187.22,26.95 187,26.73 176.98,26.73 175.65,28.06 171.97,28.06 171.36,28.67 168.56,28.67 168.38,28.49 166.41,28.49 165.92,28 165.06,28 164.34,27.28 161.99,27.28 160.44,28.83 159.8,28.83 159.69,28.72 159.69,27.8 159.37,27.48 158.45,27.48 158.17,27.2 158.17,26.89 157.21,25.93 157.21,24.72 156.67,24.18 155.16,24.18 155.05,24.07 153.86,24.07 153.65,23.87 151.33,23.87 151.12,23.67 149.86,23.67 149.26,24.27 145.2,24.27 144.34,23.41 132.65,23.41 131.24,24.83 127.6,24.83 127.04,24.27 122.14,24.27 121.53,24.88 120.72,24.88 120.5,25.1 120.11,25.1 119.84,24.82 119.84,24.62 119.48,24.27 115.3,24.27 113.59,22.56 108.86,22.56 106.02,25.4 104.79,25.4 103.15,27.03 101.54,27.03 101.1,27.47 101.1,28.08 101.37,28.35 102.3,28.35 102.45,28.5 102.45,29.79 101.67,30.57 100.62,30.57 100.29,30.9 96.21,30.9 95.83,30.52 93.66,30.52 92.93,29.79 91.69,29.79 91.25,30.23 89.05,30.23 88.47,29.65 82.11,29.65 80.78,30.97 80.78,31.61 80.43,31.96 78.8,31.96 77.28,33.49 76.18,33.49 75.85,33.16 69.89,33.16 69.81,33.08 67.7,33.08 65.19,30.57 64.37,30.57 64.12,30.82 64.12,30.84 63.82,31.15 63.82,31.68 63.76,31.74 62.19,31.74 61.71,31.25 61.35,31.25 60.64,31.96 54.62,31.96 53.7,31.05 49.7,31.05 49.54,31.2 48.8,31.2 48.78,31.23 47.81,31.23 46.85,30.26 44.16,30.26 44.05,30.16 40.98,30.16 40.37,30.77 35.52,30.77 34,32.29 33.67,32.29 33.41,32.04 33.06,32.04 32.8,32.29 32.8,32.65 33.06,32.9 33.06,33.23 31.18,35.11 31.18,35.13 31.08,35.23 31.08,36.16 29.91,37.32 v1(20.25,37.32)
  BOTTOM w0.102: v2(206.19,19.81) 206.11,19.81 205.6,20.32 U18.4 ; v1(20.25,37.32) 20.56,37.63 20.56,38.11 20.81,38.37 21.88,38.37 22.13,38.62 22.13,39.2 21.91,39.43 21.91,40.16 U15.4
USBP1+: length 91.3
  TOP w0.102: v1(22.46,45.07) 22.34,44.94 21.14,44.94 20.86,45.23 R25595.1
  IN3 w0.089: v4(86.78,41.25) 86.08,40.54 86.08,38 85.09,37.01 84.03,37.01 82.51,35.5 80.43,35.5 80.08,35.84 76.69,35.84 75.59,34.73 75.17,34.73 74.79,35.11 73.37,35.11 72.8,35.68 68.93,35.68 68.44,35.19 67.73,35.19 65.09,32.56 64.61,32.56 63.61,31.56 63.61,31.02 63.49,30.9 63.13,30.9 62.7,30.47 62.7,29.88 61,28.18 58.02,28.18 57.62,27.77 57.62,27.49 56.96,26.83 56.58,26.83 55.69,25.94 52.97,25.94 52.06,26.86 49.36,26.86 49.16,27.06 44.82,27.06 44.13,27.75 36.79,27.75 35.67,26.63 32.14,26.63 31,27.77 31,30.47 31.22,30.69 31.22,32.8 26.62,37.4 26,37.4 23.3,40.09 23.3,41.06 23.08,41.28 23.08,44.69 22.9,44.88 22.66,44.88 v1(22.46,45.07)
  BOTTOM w0.102: U2030.AB10 86.42,41.25 v4(86.78,41.25)
USBP1+_C: length 3.4
  TOP w0.102: U14.10 20.38,50.75 20.24,50.89 20.24,51 20.3,51.06 20.59,51.06 20.92,51.39 20.92,52.03 20.68,52.27 20.4,52.27 20.25,52.43 R420.1
USBP1+_C_R: length 11.3
  TOP w0.102: R25593.2 21.86,45.4 21.91,45.45 v1(21.93,45.45) ; R25597.1 18.71,52.64 v1(18.7,52.66)
  IN1 w0.089: v1(21.93,45.45) 21.93,45.1 21.8,44.97 21.57,44.97 21.35,45.19 21.35,49.82 20.55,50.62 20.55,51.49 19.83,52.22 19.14,52.22 v1(18.7,52.66)
USBP1+_C_R_N: length 16.8
  TOP w0.102: CN2.3 14.33,53.7 14.33,54.28 14.52,54.47 15.72,54.47 16.68,55.43 TP9053.1 17.62,55.43 17.85,55.67 17.85,56.19 17.95,56.29 18.23,56.29 U16.7 18.34,56.29 18.79,56.29 19.1,55.98 19.41,55.98 19.84,55.55 20.63,55.55 20.76,55.69 20.94,55.69 v1(21.12,55.51) ; v1(18.04,52.51) 18.04,52.5 18.17,52.5 18.43,52.25 19.62,52.25 19.8,52.43 R420.2
  IN1 w0.089: v1(18.04,52.51) 18.04,52.51 17.85,52.71 17.85,53.43 18.46,54.04 19.1,54.04 20.72,55.66 20.97,55.66 v1(21.12,55.51)
USBP1+_U14: length 3.3
  TOP w0.102: U14.3 20.38,46.46 20.12,46.2 20.12,45.85 19.9,45.63 19.9,45.02 20.1,44.82 20.28,44.82 20.41,44.95 R25595.2
USBP1-: length 91.5
  TOP w0.102: v1(22.46,44.31) 22.04,44.73 21.27,44.73 20.86,44.32 R25594.1
  IN3 w0.089: v4(86.78,40.57) 86.39,40.57 86.28,40.46 86.28,37.91 85.18,36.81 84.11,36.81 82.6,35.29 80.34,35.29 80,35.64 76.78,35.64 75.67,34.53 75.09,34.53 74.7,34.91 73.28,34.91 72.72,35.48 69.01,35.48 68.52,34.99 67.81,34.99 65.18,32.35 64.7,32.35 63.82,31.47 63.82,30.94 63.57,30.69 63.21,30.69 62.9,30.38 62.9,29.8 61.08,27.98 58.11,27.98 57.82,27.69 57.82,27.41 57.04,26.63 56.66,26.63 55.77,25.74 52.89,25.74 51.97,26.66 49.28,26.66 49.08,26.86 44.73,26.86 44.05,27.55 36.87,27.55 35.76,26.43 32.06,26.43 30.8,27.69 30.8,30.55 31.02,30.77 31.02,32.71 26.54,37.2 25.91,37.2 23.1,40.01 23.1,40.97 22.88,41.19 22.88,44.61 22.82,44.67 22.57,44.67 22.46,44.57 v1(22.46,44.31)
  BOTTOM w0.102: v4(86.78,40.57) 86.58,40.37 U2030.AB9
USBP1-_C: length 3
  TOP w0.102: R419.1 20.25,51.91 20.39,52.05 20.59,52.05 20.71,51.94 20.71,51.48 20.5,51.27 20.21,51.27 20.02,51.09 20.02,50.89 19.88,50.75 U14.11
USBP1-_C_R: length 11.3
  TOP w0.102: v1(18.77,51.53) 18.77,51.54 18.92,51.69 R25596.1 ; R25592.2 21.73,44.13 v1(21.8,44.06)
  IN1 w0.089: v1(21.8,44.06) 21.8,44.66 21.7,44.77 21.48,44.77 21.14,45.11 21.14,49.74 20.35,50.53 20.35,51.41 19.74,52.01 19.24,52.01 18.77,51.54 v1(18.77,51.53)
USBP1-_C_R_N: length 17
  TOP w0.102: R419.2 19.8,51.9 19.67,52.03 18.37,52.03 18.23,51.9 v1(18.22,51.9) ; v1(20.92,56.15) 20.92,55.95 20.86,55.9 20.67,55.9 20.54,55.77 20.25,55.77 U16.4 20.12,55.77 19.93,55.77 19.5,56.2 19.18,56.2 18.88,56.5 17.87,56.5 17.64,56.26 17.64,55.76 TP9051.1 17.53,55.65 16.59,55.65 15.63,54.68 14.77,54.68 14.6,54.86 CN2.2
  IN1 w0.089: v1(18.22,51.9) 18.22,51.89 18.03,51.89 17.64,52.28 17.64,53.51 18.38,54.25 19.02,54.25 20.64,55.87 20.78,55.87 20.92,56 v1(20.92,56.15)
USBP1-_U14: length 3.4
  TOP w0.102: U14.2 19.88,46.5 19.9,46.48 19.9,45.94 19.68,45.72 19.68,44.93 20.01,44.6 20.26,44.6 20.41,44.45 R25594.2
USBP2+: length 79.7
  TOP w0.102: v1(26.3,35.39) 26.45,35.24 26.45,35.01 26.2,34.76 22.95,34.76 R425.2
  IN3 w0.089: v1(82,32.73) 81.64,32.37 81.56,32.37 81.06,32.87 78.93,32.87 78.11,33.69 74.72,33.69 74.01,34.4 72.6,34.4 71.94,35.06 69.19,35.06 63.98,29.85 63.98,29.36 62.16,27.55 62.16,27.44 61.89,27.16 58.15,27.16 57.21,26.22 56.83,26.22 55.94,25.34 52.72,25.34 51.8,26.25 49.11,26.25 48.96,26.4 38.13,26.4 37.29,25.56 32.3,25.56 30.1,27.76 30.1,32.14 29.27,32.97 29.27,33.9 27.63,35.55 26.96,35.55 26.62,35.2 26.49,35.2 v1(26.3,35.39)
  BOTTOM w0.079: U2030.AJ3 82.08,36.99 82.15,36.91 82.15,36.55 82.2,36.43 82.2,36.23 82.16,36.08 82.16,35.88 82.23,35.72 82.23,35.32 82.37,35.17
  BOTTOM w0.102: 82.37,35.17 82.43,35.11 82.43,33.46 82.51,33.38 82.51,32.57 82.4,32.46 82.19,32.46 82,32.65 v1(82,32.73)
USBP2+_C: length 12.4
  TOP w0.102: v1(16.55,35.45) 16.77,35.23 17.05,35.23 TP9065.1 17.5,35.67 17.92,35.67 U17.7 18.15,35.67 20.56,35.67 21.3,34.94 21.54,34.94 R425.1
  IN1 w0.089: CN3.3 14.6,34.25 14.69,34.34 15.08,34.34 16.18,33.23 16.83,33.23 17.33,33.73 17.33,34.96 17.08,35.22 16.79,35.22 v1(16.55,35.45)
USBP2-: length 79.7
  TOP w0.102: v1(26.85,34.84) 26.59,34.84 26.29,34.55 22.95,34.55 R426.2
  IN3 w0.089: v1(82,32.09) 81.93,32.17 81.48,32.17 80.98,32.67 78.84,32.67 78.03,33.49 74.64,33.49 73.93,34.2 72.52,34.2 71.86,34.86 69.28,34.86 64.18,29.77 64.18,29.28 62.37,27.46 62.37,27.35 61.97,26.96 58.24,26.96 57.3,26.02 56.92,26.02 56.03,25.13 52.63,25.13 51.72,26.05 49.03,26.05 48.87,26.2 38.21,26.2 37.37,25.36 32.22,25.36 29.9,27.68 29.9,32.06 29.07,32.89 29.07,33.82 27.54,35.34 27.04,35.34 26.85,35.15 v1(26.85,34.84)
  BOTTOM w0.079: 82.52,35.31 82.38,35.45 82.38,35.75 82.32,35.91 82.32,36.06 82.35,36.21 82.35,36.46 82.31,36.57 82.31,37.03 U2030.AH3
  BOTTOM w0.102: 82.52,35.31 82.63,35.2 82.63,33.54 82.71,33.46 82.71,32.48 82.49,32.26 82.16,32.26 v1(82,32.09)
USBP2-_C: length 12.4
  TOP w0.102: v1(16.55,34.69) 16.55,34.89 16.67,35.01 TP9064.1 17.14,35.01 17.59,35.46 19.43,35.46 19.5,35.38 U17.4 20.01,35.46 20.47,35.46 21.21,34.72 21.64,34.72 21.77,34.59 R426.1
  IN1 w0.089: CN3.2 14.6,34.67 14.73,34.54 15.16,34.54 16.27,33.44 16.75,33.44 17.13,33.82 17.13,34.88 17,35.01 16.69,35.01 16.55,34.88 v1(16.55,34.69)
USBP3+_TPC: length 105.2
  TOP w0.102: R25292.2 12.38,11.4 12.74,11.4 12.97,11.18 12.97,10.76 12.71,10.5 12.71,9.38 13.37,8.72 13.37,7.89 14.13,7.12 17.26,7.12 18.2,8.06 20.41,8.06 22.27,9.93 23.1,9.93 23.88,10.7 24.27,10.7 26.72,13.16 28.12,13.16 29.36,14.4 29.36,17.22 30.83,18.69 30.83,21.39 28.68,23.54 28.68,25.71 30.03,27.06 31.91,27.06 32.29,27.43 32.29,27.58 v1(32.05,27.82)
  IN3 w0.089: v1(32.05,27.82) 32.33,28.1 32.33,28.29 32.62,28.59 33.36,28.59 34.45,27.49 35.58,27.49 36.52,28.43 44.44,28.43 44.69,28.18 46.91,28.18 47.24,27.85 49.35,27.85 49.65,27.55 52.34,27.55 53.26,26.63 55.41,26.63 56.3,27.52 56.68,27.52 56.93,27.77 56.93,28.05 57.75,28.87 60.38,28.87 60.56,29.05 60.56,29.4 61.42,30.26 61.42,30.97 62.04,31.58 62.04,31.71 64.63,34.3 65.46,34.3 67.97,36.82 72.76,36.82 73.44,36.13 75.76,36.13 76.36,36.73 80.26,36.73 80.81,36.18 82.23,36.18 83.77,37.72 84.72,37.72 84.97,37.98 84.97,38.28 85.24,38.54 85.45,38.54 v4(85.66,38.75)
  BOTTOM w0.102: U2030.AD7 85.36,38.83 85.58,38.83 v4(85.66,38.75)
USBP3-_TPC: length 105.3
  TOP w0.102: v1(32.81,27.82) 32.5,27.52 32.5,27.34 32,26.84 30.12,26.84 28.9,25.62 28.9,23.63 31.05,21.48 31.05,18.6 29.58,17.13 29.58,14.31 28.21,12.94 26.81,12.94 24.36,10.49 23.97,10.49 23.19,9.71 22.36,9.71 20.5,7.85 18.29,7.85 17.35,6.91 14.04,6.91 13.16,7.8 13.16,8.63 12.5,9.29 12.5,10.59 12.75,10.85 12.75,11.09 12.65,11.19 12.39,11.19 R25293.2
  IN3 w0.089: v4(85.66,38.13) 85.45,38.34 85.32,38.34 85.18,38.19 85.18,37.89 84.8,37.52 83.86,37.52 82.32,35.98 80.72,35.98 80.17,36.53 76.45,36.53 75.85,35.93 73.36,35.93 72.67,36.61 68.06,36.61 65.54,34.1 64.71,34.1 62.24,31.63 62.24,31.5 61.62,30.88 61.62,30.17 60.77,29.31 60.77,28.97 60.46,28.66 57.83,28.66 57.14,27.97 57.14,27.69 56.76,27.32 56.38,27.32 55.49,26.43 53.17,26.43 52.26,27.34 49.57,27.34 49.26,27.65 47.15,27.65 46.82,27.98 44.61,27.98 44.35,28.23 36.61,28.23 35.67,27.29 34.37,27.29 33.28,28.38 32.7,28.38 32.53,28.21 32.53,28.1 v1(32.81,27.82)
  BOTTOM w0.102: U2030.AD6 85.36,38.18 85.61,38.18 v4(85.66,38.13)
USBP4+_DB: length 169.9
  IN1 w0.089: v1(85.76,33.16) 85.98,32.95 86.98,32.95 88.33,34.3 94.47,34.3 95.8,32.97 99.99,32.97 102.28,30.68 103.81,30.68 105.19,29.3 105.19,28.92 106.13,27.98 106.54,27.98 107.31,27.21 108.23,27.21 108.4,27.38 109.8,27.38 110.14,27.04 116.12,27.04 116.66,26.49 121.4,26.49 124.21,23.68 127.54,23.68 127.72,23.86 130.96,23.86 131.67,23.15 146.15,23.15 146.64,23.64 153.28,23.64 153.43,23.79 160.71,23.79 161.48,24.56 164.24,24.56 164.43,24.37 165.11,24.37 166.15,23.33 169.11,23.33 169.25,23.18 173.44,23.18 173.59,23.33 174.64,23.33 175.15,22.82 176.48,22.82 177.14,23.48 184.31,23.48 184.69,23.1 187.51,23.1 189.62,25.2 195.04,25.2 195.33,25.5 196.85,25.5 196.89,25.46 197.43,25.46 199.44,23.45 201.89,23.45 202.25,23.1 203.77,23.1 204.1,23.43 206.28,23.43 206.64,23.07 206.64,21.77 208.42,19.99 212.6,19.99 213.31,20.69 213.31,23.55 213.68,23.92 213.68,24.84 215.02,26.18 215.02,29.23 216.74,30.94 216.74,32.53 216.34,32.93 216.34,37.23 213.01,40.56 212.45,40.56 v1(212.23,40.34)
  BOTTOM w0.079: U2030.AG2 83.49,36.1 83.49,35.86 83.52,35.8 83.52,35.58 83.46,35.44 83.46,35.08
  BOTTOM w0.102: v1(85.76,33.16) 85.55,32.95 85.2,32.95 84.8,33.35 84.8,33.75 83.98,34.57 83.71,34.57 83.46,34.83 83.46,35.08 ; CN35.16 212.76,40.4 212.61,40.55 212.44,40.55 v1(212.23,40.34)
USBP4-_DB: length 170.1
  IN1 w0.089: v1(85.76,32.53) 85.98,32.74 87.06,32.74 88.41,34.09 94.39,34.09 95.71,32.76 99.91,32.76 102.2,30.48 103.72,30.48 104.99,29.21 104.99,28.83 106.05,27.77 106.45,27.77 107.22,27.01 108.32,27.01 108.49,27.17 109.71,27.17 110.05,26.83 116.03,26.83 116.58,26.29 121.31,26.29 124.13,23.47 127.63,23.47 127.8,23.65 130.88,23.65 131.58,22.95 146.24,22.95 146.73,23.44 153.37,23.44 153.52,23.59 160.8,23.59 161.56,24.36 164.16,24.36 164.35,24.17 165.03,24.17 166.07,23.13 169.02,23.13 169.17,22.98 173.52,22.98 173.67,23.13 174.56,23.13 175.07,22.62 176.57,22.62 177.23,23.28 184.22,23.28 184.61,22.9 187.6,22.9 189.7,25 195.13,25 195.42,25.29 196.77,25.29 196.81,25.25 197.35,25.25 199.35,23.25 201.81,23.25 202.16,22.9 203.85,22.9 204.18,23.23 206.2,23.23 206.44,22.99 206.44,21.68 208.33,19.79 212.69,19.79 213.51,20.61 213.51,23.47 213.88,23.84 213.88,24.75 215.23,26.1 215.23,29.15 216.94,30.86 216.94,32.61 216.54,33.01 216.54,37.31 213.09,40.76 212.45,40.76 v1(212.23,40.98)
  BOTTOM w0.102: CN35.15 212.73,40.9 212.6,40.77 212.44,40.77 v1(212.23,40.98) ; v1(85.76,32.53) 85.55,32.74 85.12,32.74 84.59,33.27 84.59,33.67 83.89,34.37 83.63,34.37 83.26,34.74 U2030.AG1
USBP5+_CAM: length 104.2
  IN3 w0.089: v4(84.52,39.4) 84.52,39.2 84.57,39.15 84.84,39.15 84.95,39.27 84.95,42.1 85.7,42.85 88.17,42.85 88.58,43.27 88.58,48.72 85.09,52.21 85.09,69.46 86.9,71.27 86.9,75.7 87.61,76.41 88.17,76.41 88.33,76.57 88.33,81.13 84.41,85.05 84.22,85.05 81.17,88.1 80.01,88.1 73.87,94.25 63.99,94.25 61.45,96.79 60.49,96.79 60.21,97.06 60.21,97.67 60.13,97.75 v1(59.88,97.75)
  BOTTOM w0.102: v4(84.52,39.4) 83.95,39.4 83.88,39.33 83.88,39.24 U2030.AF7 ; v1(59.88,97.75) 60.13,97.75 60.21,97.67 60.21,97.37 60.02,97.18 59.02,97.18 58.75,97.46 58.75,98.22 57.77,99.2 55.93,99.2 54.86,100.27 47.61,100.27 46.39,101.48 46.39,102.17 46.76,102.54 46.76,102.95 46.94,103.13 R25289.2
USBP5+_CAM_C: length 3.6
  BOTTOM w0.102: R25289.1 46.79,104.3 46.79,105.41 47.2,105.83 47.2,106.51 47.35,106.66 CN29.8
USBP5-_CAM: length 104.2
  IN3 w0.089: v4(84.52,38.76) 84.71,38.95 84.92,38.95 85.16,39.18 85.16,42.02 85.79,42.65 88.25,42.65 88.78,43.18 88.78,48.8 85.29,52.3 85.29,69.37 87.11,71.19 87.11,75.62 87.69,76.2 88.25,76.2 88.54,76.49 88.54,81.21 84.49,85.25 84.31,85.25 81.26,88.3 80.1,88.3 73.95,94.45 64.07,94.45 61.53,96.99 60.57,96.99 60.41,97.15 60.41,97.52 v1(60.65,97.75)
  BOTTOM w0.102: R25288.2 46.54,102.75 46.54,102.63 46.18,102.26 46.18,101.39 47.52,100.05 54.77,100.05 55.84,98.98 57.68,98.98 58.53,98.13 58.53,97.37 58.93,96.97 60.11,96.97 60.43,97.28 60.43,97.53 v1(60.65,97.75) ; v4(84.52,38.76) 84.4,38.76 U2030.AF6
USBP5-_CAM_C: length 3.6
  BOTTOM w0.102: CN29.7 46.85,106.67 46.99,106.53 46.99,105.92 46.57,105.5 46.57,104.31 R25288.1
USBP6+_CR: length 168.5
  IN1 w0.089: v1(84.54,40.64) 84.54,40.52 84.66,40.4 84.96,40.4 85.16,40.19 85.16,36.35 85.78,35.73 87.02,35.73 87.74,35 95.83,35 96.39,34.44 97.98,34.44 98.31,34.11 99.85,34.11 102.14,31.81 104.35,31.81 105.68,30.49 107.64,30.49 110.42,27.71 116.4,27.71 116.94,27.16 121.68,27.16 124.49,24.35 126.63,24.35 126.81,24.53 131.28,24.53 131.99,23.82 145.87,23.82 146.36,24.31 149.62,24.31 150.23,24.92 152.21,24.92 152.67,24.47 159.18,24.47 160.35,25.64 165.09,25.64 166.41,24.32 170.83,24.32 171.14,24.01 175.31,24.01 175.45,24.15 184.59,24.15 184.97,23.77 187.04,23.77 187.39,24.12 187.39,25.41 187.97,26 188.85,26 188.97,25.88 194.76,25.88 195.05,26.17 195.5,26.17 195.75,26.42 197.42,26.42 199.36,24.49 200.3,24.49 200.61,24.17 205.81,24.17 205.84,24.14 206.53,24.14 207.53,23.14 207.53,21.83 208.7,20.66 212.32,20.66 212.63,20.97 212.63,23.9 212.94,24.2 212.94,25.05 214.34,26.45 214.34,29.59 216.06,31.31 216.06,32.19 215.66,32.59 215.66,36.38 212.94,39.1 212.76,39.1 v1(212.33,38.67)
  BOTTOM w0.102: U2030.AF9 84.06,40.57 84.24,40.76 84.42,40.76 v1(84.54,40.64) ; CN35.19 212.46,38.9 212.33,38.77 v1(212.33,38.67)
USBP6-_CR: length 168.6
  IN1 w0.089: v1(212.33,39.31) 213.02,39.31 215.87,36.46 215.87,32.68 216.27,32.28 216.27,31.23 214.54,29.5 214.54,26.36 213.14,24.97 213.14,24.12 212.84,23.81 212.84,20.89 212.41,20.46 208.61,20.46 207.33,21.75 207.33,23.05 206.44,23.94 205.75,23.94 205.73,23.96 200.53,23.96 200.21,24.28 199.27,24.28 197.34,26.22 195.84,26.22 195.58,25.97 195.14,25.97 194.85,25.67 188.89,25.67 188.77,25.79 188.06,25.79 187.59,25.33 187.59,24.04 187.12,23.57 184.88,23.57 184.5,23.95 175.54,23.95 175.4,23.81 171.05,23.81 170.75,24.12 166.32,24.12 165,25.44 160.44,25.44 159.26,24.26 152.59,24.26 152.13,24.72 150.31,24.72 149.71,24.11 146.44,24.11 145.95,23.62 131.9,23.62 131.2,24.33 126.89,24.33 126.71,24.15 124.41,24.15 121.59,26.96 116.86,26.96 116.31,27.51 110.33,27.51 107.55,30.29 105.59,30.29 104.27,31.61 102.06,31.61 102,31.67 99.76,33.9 98.22,33.9 97.89,34.24 96.31,34.24 95.74,34.8 87.66,34.8 86.93,35.53 85.7,35.53 84.96,36.26 84.96,40.11 84.87,40.19 84.71,40.19 v4(84.54,40.02)
  BOTTOM w0.102: U2030.AF8 84.36,40.02 v4(84.54,40.02) ; CN35.18 212.42,39.4 v1(212.33,39.31)
USBP7+_FP: length 76.6
  IN3 w0.089: v1(84.07,32.97) 83.89,32.8 83.38,32.8 83.17,32.58 83.17,31.26 82.49,30.58 81.63,30.58 80.4,31.82 78.27,31.82 78.18,31.91 77.11,31.91 76.91,31.71 76.91,31.42 76.82,31.33 76.5,31.33 76.41,31.42 76.41,31.71 76.2,31.91 75.81,31.91 75.7,32.02 75.7,32.32 75.5,32.53 75.14,32.53 74.92,32.3 74.92,32 74.83,31.91 74.7,31.91 74.28,32.33 73.62,32.33 73.53,32.42 73.53,32.75 73.32,32.96 72.84,32.96 72.63,32.75 72.63,32.42 72.54,32.33 72.22,32.33 72.13,32.42 72.13,32.75 71.92,32.96 71.44,32.96 71.23,32.75 71.23,32.42 71.14,32.33 70.75,32.33 70.58,32.5 70.58,32.85 70.37,33.06 69.93,33.06 69.72,32.85 69.72,32.24 69.52,32.04 69.37,32.04 69.18,32.23 68.89,32.23 68.56,31.9 68.56,31.75 68.55,31.74 68.55,31.61 68.72,31.45 68.72,31.23 67.5,30.02 67.38,30.02 67,30.4 66.71,30.4 66.38,30.08 66.38,29.74 66.74,29.38 66.74,29.26 66.52,29.03 66.39,29.03 66.21,29.21 65.92,29.21 65.58,28.87 65.58,28.57 65.75,28.4 65.75,28.27 65.53,28.05 65.4,28.05 65.27,28.17 64.98,28.17 64.64,27.83 64.64,27.53 64.76,27.41 64.76,27.28 64.32,26.83 63.74,26.83 62.49,25.59 61.46,25.59 61.2,25.33 60.95,25.33 v1(60.67,25.62)
  BOTTOM w0.102: v1(60.67,25.62) 60.42,25.37 60.27,25.37 59.85,24.95 59.09,24.95 58.27,25.78 56.69,25.78 55.79,24.88 52.03,24.88 51.1,25.81 45.77,25.81 45.46,25.5 45.46,25.07 45.77,24.76 49.15,24.76 49.43,24.48 50.77,24.48 51.6,23.66 56.12,23.66 57.11,24.65 57.85,24.65 58.05,24.45 58.05,22.75 EC7.2 58.07,22.26 58.07,22.15 57.45,21.53 CN14.7 ; U2030.AH2 82.59,36.45 82.97,36.07 82.97,35.52 83.04,35.46 83.04,33.97 83.32,33.68 83.32,32.97 83.43,32.86 83.96,32.86 v1(84.07,32.97)
USBP7-_FP: length 76.6
  IN3 w0.089: v1(84.07,32.34) 84.07,32.47 83.95,32.59 83.47,32.59 83.37,32.5 83.37,31.18 82.58,30.38 81.55,30.38 80.31,31.61 78.19,31.61 78.09,31.71 77.2,31.71 77.11,31.62 77.11,31.33 76.9,31.13 76.41,31.13 76.21,31.33 76.21,31.62 76.12,31.71 75.73,31.71 75.5,31.94 75.5,32.24 75.41,32.32 75.23,32.32 75.12,32.22 75.12,31.92 74.91,31.71 74.61,31.71 74.19,32.13 73.53,32.13 73.33,32.34 73.33,32.66 73.24,32.75 72.92,32.75 72.83,32.66 72.83,32.34 72.62,32.13 72.14,32.13 71.93,32.34 71.93,32.66 71.84,32.75 71.52,32.75 71.43,32.66 71.43,32.34 71.23,32.13 70.66,32.13 70.37,32.42 70.37,32.76 70.29,32.85 70.01,32.85 69.92,32.76 69.92,32.15 69.61,31.84 69.28,31.84 69.1,32.02 68.97,32.02 68.76,31.81 68.76,31.69 68.92,31.53 68.92,31.15 67.59,29.82 67.29,29.82 66.91,30.2 66.79,30.2 66.59,30 66.59,29.83 66.94,29.47 66.94,29.17 66.6,28.83 66.31,28.83 66.13,29.01 66,29.01 65.78,28.79 65.78,28.65 65.96,28.48 65.96,28.19 65.61,27.84 65.32,27.84 65.19,27.97 65.07,27.97 64.84,27.74 64.84,27.62 64.97,27.49 64.97,27.2 64.4,26.63 63.82,26.63 62.57,25.39 61.54,25.39 61.28,25.13 60.95,25.13 v1(60.67,24.84)
  BOTTOM w0.102: v1(60.67,24.84) 60.67,25.08 60.59,25.16 60.36,25.16 59.94,24.74 59,24.74 58.18,25.56 56.78,25.56 55.88,24.66 51.94,24.66 51.01,25.59 45.86,25.59 45.68,25.41 45.68,25.16 45.86,24.98 49.24,24.98 49.52,24.7 50.86,24.7 51.69,23.87 56.03,23.87 57.02,24.87 57.94,24.87 58.27,24.53 58.27,23.04 EC8.1 58.41,22.52 58.28,22.39 58.28,22.06 57.95,21.73 CN14.6 ; v1(84.07,32.34) 84.07,32.4 83.81,32.66 83.35,32.66 83.12,32.88 83.12,33.6 82.84,33.88 82.84,35.37 82.77,35.44 82.77,35.84 U2030.AH1
USBP8+_TS: length 114.1
  IN3 w0.089: v1(57.45,97.75) 57.21,97.52 57.21,97.28 57.38,97.12 58.22,97.12 58.53,97.43 58.53,98.06 59.04,98.56 62.03,98.56 62.67,97.92 62.67,96.8 64.35,95.12 74.23,95.12 79.75,89.6 80.91,89.6 84.58,85.93 84.78,85.93 89.21,81.5 89.21,76.16 88.78,75.74 88.78,69.69 87.56,68.47 87.56,59.77 89.09,58.24 89.09,51.88 89.51,51.45 89.51,48.48 89.34,48.3 89.34,43.92 89.5,43.76 89.5,39.75 89.16,39.4 88.86,39.4 88.53,39.07 88.53,37.78 87.93,37.19 87.27,37.19 86.64,36.56 85.74,36.56 85.35,36.17 84.47,36.17 82.54,34.24 82.19,34.24 v1(82,34.05)
  BOTTOM w0.079: 81.29,35.08 81.31,35.1 81.31,35.63 81.93,36.25 U2030.AJ2
  BOTTOM w0.102: v1(57.45,97.75) 57.25,97.95 57.25,98.17 56.92,98.5 55.45,98.5 54.38,99.57 47.27,99.57 45.35,101.48 45.35,101.76 44.75,102.36 44.75,102.86 R25291.2 ; 81.29,35.08 81.29,34.54 81.56,34.27 81.79,34.27 v1(82,34.05)
USBP8-_TS: length 114.1
  IN3 w0.089: v1(56.68,97.75) 56.86,97.75 57.01,97.6 57.01,97.2 57.29,96.91 58.3,96.91 58.74,97.35 58.74,97.97 59.13,98.36 61.94,98.36 62.46,97.84 62.46,96.72 64.27,94.92 74.14,94.92 79.67,89.39 80.83,89.39 84.5,85.72 84.7,85.72 89.01,81.42 89.01,76.25 88.58,75.82 88.58,69.78 87.36,68.56 87.36,59.68 88.89,58.16 88.89,51.79 89.31,51.37 89.31,48.56 89.14,48.39 89.14,43.83 89.3,43.67 89.3,39.83 89.07,39.6 88.78,39.6 88.33,39.15 88.33,37.87 87.85,37.39 87.18,37.39 86.55,36.76 85.66,36.76 85.27,36.37 84.38,36.37 82.45,34.44 82.11,34.44 82.02,34.53 v1(82.02,34.7)
  BOTTOM w0.079: 81.49,35.08 81.47,35.1 81.47,35.57 81.7,35.8 81.81,35.8 U2030.AJ1
  BOTTOM w0.102: v1(56.68,97.75) 56.91,97.75 57.03,97.88 57.03,98.08 56.83,98.28 55.36,98.28 54.29,99.35 47.18,99.35 45.13,101.39 45.13,101.67 44.54,102.27 44.54,103.16 44.43,103.27 44.15,103.27 R25290.2 ; v1(82.02,34.7) 82.02,34.57 81.92,34.47 81.65,34.47 81.49,34.62 81.49,35.08
USBP8_TS+_C: length 3.9
  BOTTOM w0.102: CN29.5 45.85,106.63 45.73,106.51 45.73,106 44.56,104.84 44.56,104.35 44.77,104.15 44.78,104.15 R25291.1
USBP8_TS-_C: length 3.9
  BOTTOM w0.102: R25290.1 44.35,104.25 44.35,104.93 45.52,106.09 45.52,106.51 45.35,106.68 CN29.4
USBP10+_BT: length 122.3
  IN1 w0.089: v4(85.69,40.66) 85.85,40.5 86.11,40.5 86.32,40.29 86.32,37.73 85.98,37.39 85.98,36.95 86.53,36.4 89.09,36.4 89.8,35.7 97.15,35.7 97.7,35.14 98.35,35.14 98.72,34.78 100.12,34.78 102.4,32.5 104.75,32.5 106.08,31.18 109.94,31.18 110.02,31.09 119.18,31.09 122.57,27.71 122.57,27.25 124.02,25.79 124.87,25.79 125.46,25.2 131.67,25.2 132.38,24.5 145.4,24.5 145.89,24.99 149.34,24.99 149.95,25.6 152.57,25.6 152.94,25.22 157.06,25.22 158.16,26.33 165.45,26.33 166.11,25.67 168.44,25.67 168.97,25.13 171.22,25.13 171.6,24.75 175.01,24.75 175.16,24.9 177.52,24.9 178.13,25.51 179.73,25.51 180.41,24.83 182.51,24.83 182.69,25.01 185.82,25.01 186.06,24.77 186.06,24.36 v2(186.18,24.24)
  BOTTOM w0.102: v4(85.69,40.66) 85.6,40.74 85.33,41.02 U2030.AD10 ; v2(186.18,24.24) 186.27,24.33 186.27,29.42 185.21,30.49 184.06,30.49 183.92,30.63 CN17.3
USBP10-_BT: length 122.3
  IN1 w0.089: v2(185.55,24.24) 185.63,24.24 185.86,24.47 185.86,24.68 185.74,24.8 182.77,24.8 182.59,24.62 180.33,24.62 179.65,25.3 178.21,25.3 177.61,24.7 175.25,24.7 175.09,24.55 171.51,24.55 171.13,24.93 168.89,24.93 168.35,25.46 166.03,25.46 165.36,26.13 158.25,26.13 157.14,25.02 152.85,25.02 152.48,25.39 150.03,25.39 149.42,24.78 145.97,24.78 145.49,24.29 132.29,24.29 131.59,25 125.37,25 124.78,25.59 123.94,25.59 122.36,27.16 122.36,27.62 119.09,30.89 109.94,30.89 109.86,30.97 106,30.97 104.67,32.3 102.32,32.3 100.04,34.58 98.63,34.58 98.27,34.94 97.62,34.94 97.06,35.49 89.72,35.49 89.01,36.2 86.44,36.2 85.78,36.87 85.78,37.47 86.12,37.81 86.12,40.21 86.03,40.3 85.84,40.3 85.69,40.14 v4(85.69,40)
  BOTTOM w0.102: CN17.5 183.96,30.13 184.03,30.07 184.17,30.07 184.37,30.27 185.12,30.27 186.05,29.33 186.05,24.71 185.58,24.24 v2(185.55,24.24) ; U2030.AD9 85.13,40.17 85.42,39.88 85.56,39.88 v4(85.69,40)
USBP_TYPC+_C: length 13.3
  TOP w0.102: R25292.1 11.2,11.56 11.04,11.4 10.72,11.4 10.55,11.57 v1(10.55,11.68)
  IN1 w0.089: v1(10.55,11.68) 10.26,11.39 9.92,11.39 9.79,11.52 9.79,15.34 9.54,15.58 9.23,15.58 9.13,15.68 v1(9.13,15.84) 9.13,16.01 8.57,16.57 7.71,16.57 7.44,16.3 CN10.B6
  BOTTOM w0.102: v1(10.55,11.68) 10.86,11.37 11.02,11.37 11.13,11.49 RV1.1 ; v1(9.13,15.84) 8.94,15.65 CN10.A6
USBP_TYPC-_C: length 13.4
  TOP w0.102: R25293.1 11.2,11.09 11.12,11.18 10.83,11.18 v1(10.55,10.9)
  IN1 w0.089: CN10.B7 6.43,15.5 6.55,15.62 6.55,15.93 6.72,16.1 7.52,16.1 7.79,16.37 8.42,16.37 8.49,16.29 v1(8.49,16.06) 8.49,15.89 9,15.38 9.46,15.38 9.59,15.25 9.59,11.43 9.83,11.19 10.26,11.19 v1(10.55,10.9)
  BOTTOM w0.102: v1(8.49,16.06) 8.49,15.94 8.41,15.85 7.94,15.85 7.89,15.91 7.89,16.07 7.81,16.15 CN10.A7 ; RV1.2 11.03,11.04 10.91,11.16 10.81,11.16 v1(10.55,10.9)
USBPWRD2:
  vias: v1(209.2,23.6)
VA: length 184.7
  TOP w0.381: v1(135.49,34.89) 135.48,34.9 PR235.1 134.7,35.67 134.43,35.94 PD9002.1
  TOP w1.524: PJ2.1 11.82,116.6
  IN1 w0.254: v1(41.65,122.48) 43.13,122.48 46.72,118.88 50.15,118.88 53.48,115.55 60.86,115.55 v1(61.96,114.45)
  IN1 w1.524: PJ2.1 11.95,116.6
  IN2 w0.381: v1(114.64,70.17) 113.41,68.93 107.7,68.93 105.84,70.79 105.84,79.58 104.58,80.84 104.58,85.73 104.22,86.09 104.22,87.15 v1(104.36,87.29)
  IN2 w1.524: PJ2.1 11.85,116.6
  IN3 w0.254: v1(104.36,87.29) 104.36,87.55 104.56,87.76 104.56,88.88 103.64,89.81 101.55,89.81 99.34,92.03 99.34,92.58 98.26,93.65 97.17,93.65 96.95,93.43 96.01,93.43 95.72,93.73 95.72,96.5 95.52,96.7 95.52,96.71 94.24,97.98 94.24,100.38 93.2,101.42 93.2,112.35 90.55,115.01 89.49,115.01 83.69,120.81 76.65,120.81 76.55,120.91 72.4,120.91 70.9,119.41 70.9,117.08 70.17,116.35 68.78,116.35 65.98,113.55 62.86,113.55 v1(61.96,114.45)
  IN3 w0.381: v1(135.49,34.89) 135.49,34.58 134.8,33.88 133.88,33.88 132.64,35.13 132.09,35.13 129.7,37.51 127.44,37.51 123.84,41.12 122.8,42.15 122.8,48.42 120.31,50.91 120.31,51.94 119.1,53.16 119.1,61.87 115.92,65.04 115.92,68.64 114.64,69.92 v1(114.64,70.17)
  IN3 w1.524: PJ2.1 11.98,116.6
  BOTTOM w0.203: v1(135.49,34.89) 135.8,34.58 PR31.1
  BOTTOM w1.524: PJ2.1 11.88,116.6
  vias: v1(20.05,116.6) v1(20.05,115.96) v1(20.69,116.6) v1(20.69,115.96) v1(21.32,116.6) v1(21.32,115.96) v1(21.96,116.6) v1(21.96,115.96) v1(37.51,122.4) v1(38.17,122.4) v1(38.89,122.43) v1(39.6,122.45) v1(40.28,122.45) v1(40.97,122.48)
VA2: length 161.8
  IN1 w0.254: v1(46.47,121.04) 46.47,120.14 47.02,119.59 50.8,119.59 52.2,118.2 57.44,118.2 59.37,116.26 61.61,116.26 v1(63.38,114.49)
  IN2 w0.381: v1(115.61,71.64) 115.61,72.94 113.11,75.44 108.14,75.44 106.81,76.77 106.81,80.03 105.6,81.24 105.6,85.86 105.85,86.12 105.85,86.8 v1(105.63,87.03)
  IN3 w0.254: v1(105.63,87.03) 105.41,87.24 105.41,89.19 104.08,90.52 101.85,90.52 100.62,91.75 100.62,93.37 97.99,96 97.99,96.92 97.43,97.48 97.06,97.48 96.62,97.03 96.19,97.03 94.95,98.27 94.95,100.67 93.91,101.71 93.91,112.65 90.84,115.72 89.78,115.72 83.98,121.52 76.95,121.52 76.84,121.62 70.42,121.62 68.46,119.67 68.46,118.97 67.95,118.45 67.95,116.52 65.69,114.26 63.61,114.26 v1(63.38,114.49)
  IN3 w0.381: v1(134.22,35.01) 133.15,36.09 132.49,36.09 130.1,38.48 127.84,38.48 124.8,41.52 123.77,42.55 123.77,48.82 121.28,51.31 121.28,52.34 120.06,53.56 120.06,62.27 116.89,65.44 116.89,70.15 116.01,71.03 116.01,71.24 v1(115.61,71.64)
  BOTTOM w0.203: v1(134.22,35.01) 133.87,34.66 PR28.1
VADJ1: length 6.9
  TOP w0.102: R441.2 54.75,104.34 54.75,105.88 55.49,106.62 C558.1 56.62,106.62 R442.1 57.3,107.67 v1(57.01,107.96)
  BOTTOM w0.102: v1(57.01,107.96) 56.85,107.8 CN29.27
VCORE_SENSE: length 30.3
  TOP w0.254: PR7043.1 PR7044.1 118.41,53.15 v1(117.85,52.59)
  IN1 w0.254: v1(117.85,52.59) 117.61,52.36 116.42,52.36 115.33,51.27 110.17,51.27 108.8,52.64 108.8,54.32 108.04,55.08 106.69,55.08 106.08,55.69 103.29,55.69 102.98,55.99 v1(101.97,55.99)
  BOTTOM w0.102: U2030.E32 94.65,53.99 95.63,54.96 95.86,54.96 95.96,54.86 96.16,54.86 96.27,54.97 96.5,54.97 96.6,54.88 97.73,54.88 97.8,54.95
  BOTTOM w0.254: 97.8,54.95 101.17,54.95 101.19,54.98 101.86,54.98 R2493.2 102.06,55.57 101.97,55.66 v1(101.97,55.99)
VCORESS_SENSE: length 30.4
  TOP w0.254: PR7045.1 PR7046.1 118.2,50.76 v1(118,50.96)
  IN1 w0.254: v1(118,50.96) 118,51.72 117.87,51.85 116.63,51.85 115.54,50.76 109.96,50.76 108.29,52.43 108.29,54.11 107.83,54.57 106.23,54.57 105.73,55.08 103.01,55.08 102.58,55.51 101.47,55.51 v1(101.37,55.61)
  BOTTOM w0.102: 97.95,55.39 97.78,55.39 97.65,55.52 95.29,55.52 94.65,54.89 U2030.E33
  BOTTOM w0.254: 97.95,55.39 99.48,55.39 99.68,55.6 99.68,55.82 99.86,55.99 100.29,55.99 100.68,55.61 R2492.1 v1(101.37,55.61)
VGA_MBCLK: length 16.2
  TOP w0.079: R2607.2 97.17,34.47 97.17,35.14 96.86,35.45 94.03,35.45 92.74,36.74 91.91,36.74 91.56,37.09 91.56,39.32 91.5,39.37 91.5,41.3 91.03,41.78 89.65,41.78 89.42,41.55 89.42,40.47 88.98,40.03 v4(88.9,40.03)
  BOTTOM w0.102: v4(88.9,40.03) 89.24,40.37 U2030.R9
VGA_MBDATA: length 7.7
  BOTTOM w0.079: 87.51,35.61 87.51,35.78 87.47,35.88 87.47,36.1 U2030.W2
  BOTTOM w0.102: R2591.2 88.41,30.13 88.1,30.44 88.1,31.13 87.84,31.38 87.84,32.71 88.37,33.24 88.37,34.75 87.51,35.61
VGA_OVT#: length 3.7
  TOP w0.102: R395.1 100.71,124.45 Q15.1 102,123.15 R25560.2
VGA_RST#: length 22.2
  TOP w0.102: v1(102.79,125.91) 102.63,125.74 R296.2 ; v2(98.82,112.47) 99.11,112.19 C364.1
  IN3 w0.089: v1(102.79,125.91) 102.22,125.34 98.87,125.34 96.81,123.28 96.81,122.19 97.41,121.59 97.41,119.49 98,118.91 98,113.3 v2(98.82,112.47)
  BOTTOM w0.127: v2(98.82,112.47) 98.82,111.64 U8.AC7
VGA_VCCSENSE: length 51.1
  IN2 w0.089: v2(91.16,104.82) 90.42,104.82 89.83,104.23 88.86,104.23 87.01,102.38 85.37,102.38 85.09,102.1 79.32,102.1 77.78,103.64 77.18,103.64 76.87,103.95 76.87,104.28 76.62,104.53 76.62,104.8 74.14,107.28 71.21,107.28 68.67,109.82 68.67,112.57 69.98,113.89 69.98,114.3 69.72,114.57 v1(69.1,114.57)
  BOTTOM w0.102: PR9028.2 69.18,108.04 68.9,108.32 68.78,108.32 68.63,108.47 v1(68.63,110.58) 68.63,113.09 69,113.46 69,114.46 v1(69.1,114.57) ; PR9026.2 91.04,104.95 v2(91.16,104.82) 91.45,104.82 92.11,104.16 92.11,99.31 93.88,97.54 94.46,97.54 94.87,97.13 U8.F2
VGA_VSSSENSE: length 43
  IN2 w0.089: v2(91.3,104.23) 91.24,104.16 90.01,104.16 89.9,104.05 88.93,104.05 87.08,102.2 85.44,102.2 85.16,101.92 79.24,101.92 77.7,103.46 77.11,103.46 76.69,103.87 76.69,104.2 76.44,104.46 76.44,104.72 74.06,107.1 71.14,107.1 68.49,109.75 68.49,112.64 69.58,113.74 v1(69.58,114.13)
  BOTTOM w0.102: v1(69.58,114.13) 69.62,114.09 69.62,113.41 69.43,113.22 PR9029.2 ; PR9031.2 91.29,104.22 v2(91.3,104.23) 91.58,104.23 91.91,103.9 91.91,99.22 93.86,97.27 94.19,97.27 U8.F1
VGPU_EN: length 17.3
  TOP w0.079: 77.47,38.05 77.52,38.1 77.8,38.1 78.04,38.34 78.35,38.34 79.79,39.78 v4(80.14,39.78)
  TOP w0.102: 77.47,38.05 74.05,38.05 72.28,36.28 70.09,36.28 69.48,35.67 69.02,35.67 68.51,35.17 67.52,35.17 TP2043.1
  BOTTOM w0.102: v4(80.14,39.78) 80.14,39.85 U2030.AN8
VL: length 54.6
  TOP w0.102: v1(76.01,23.64) 76.13,23.51 76.13,21.58 77.08,20.63 v1(77.08,20.14)
  IN2 w0.102: v1(77.08,20.14) 76.43,19.48 53.58,19.48 51.77,21.3 48.99,21.3 47.93,22.36 45.58,22.36 45.2,22.74 44.28,22.74 44.13,22.59 44.13,21.96 45.78,20.31 45.78,17.71 43.71,15.63 43.1,15.63 42.39,14.92 v1(41.46,14.92)
  BOTTOM w0.102: v1(76.01,23.64) 76.01,24.36 76.92,25.28 PR3020.1 ; PR6025.2 39.81,14 40.73,14.92 v1(41.46,14.92)
VMA_CLK0: length 42.6
  TOP w0.102: v2(133.01,92.61) 133.27,92.87 133.27,94.64 131.34,96.57 130.55,96.57 130.34,96.79 130.34,97.94 130.23,98.04 129.93,98.04 129.83,97.94 129.83,96.79 129.61,96.57 129.15,96.57 128.94,96.79 128.94,97.94 128.84,98.04 128.53,98.04 128.43,97.94 128.43,96.79 128.22,96.57 127.75,96.57 127.54,96.79 127.54,97.94 127.44,98.04 127.14,98.04 127.03,97.94 127.03,96.79 126.82,96.57 126.36,96.57 126.14,96.79 126.14,97.72 126.04,97.82 125.74,97.82 125.64,97.72 125.64,96.79 125.42,96.57 124.94,96.57 124.84,96.47 124.84,96.33 124.63,96.11 123.96,96.11 123.75,96.33 123.75,96.47 123.65,96.57 123.34,96.57 123.24,96.47 123.24,96.31 123.03,96.1 122.56,96.1 122.35,96.31 122.35,96.47 122.25,96.57 121.94,96.57 121.84,96.47 121.84,96.33 121.63,96.11 119.98,96.11 119.64,95.77 118.13,95.77 117.79,96.11 116.51,96.11 116.01,95.61 116.01,95.46 115.78,95.22 114.89,95.22 114.67,95.44 114.16,95.44 v2(113.73,95.87)
  BOTTOM w0.079: 134.16,94.73 134.14,94.71 134.14,94.69 133.73,94.28 133.73,92.01 133.6,91.88 133.49,91.88 133.41,91.96 VRAM1.J12
  BOTTOM w0.102: U8.D24 113.7,95.43 113.8,95.53 113.8,95.8 v2(113.73,95.87) ; 134.16,94.73 134.3,94.87 134.3,95.76 134.75,96.2 134.75,96.94 R25488.1 ; VRAM1.J12 133.41,92.21 v2(133.01,92.61)
VMA_CLK0#: length 42.9
  TOP w0.102: v2(133.01,91.81) 133.46,92.26 133.46,94.72 131.42,96.77 130.63,96.77 130.53,96.87 130.53,98.02 130.31,98.23 129.85,98.23 129.64,98.02 129.64,96.87 129.54,96.77 129.23,96.77 129.13,96.87 129.13,98.02 128.92,98.23 128.45,98.23 128.24,98.02 128.24,96.87 128.14,96.77 127.83,96.77 127.73,96.87 127.73,98.02 127.52,98.23 127.06,98.23 126.84,98.02 126.84,96.87 126.74,96.77 126.44,96.77 126.34,96.87 126.34,97.8 126.12,98.01 125.66,98.01 125.45,97.8 125.45,96.87 125.34,96.77 124.86,96.77 124.65,96.55 124.65,96.4 124.55,96.3 124.04,96.3 123.94,96.4 123.94,96.55 123.72,96.76 123.26,96.76 123.05,96.55 123.05,96.39 122.95,96.29 122.64,96.29 122.54,96.39 122.54,96.55 122.33,96.76 121.86,96.76 121.65,96.55 121.65,96.4 121.55,96.3 119.9,96.3 119.56,95.96 118.21,95.96 117.87,96.3 116.44,96.3 115.82,95.69 115.82,95.53 115.7,95.41 114.97,95.41 114.75,95.63 114.73,95.63 v2(114.51,95.85)
  BOTTOM w0.079: 134.29,94.59 134.28,94.58 134.26,94.58 133.89,94.21 133.89,91.94 133.67,91.72 133.49,91.72 133.41,91.64 VRAM1.J11
  BOTTOM w0.102: 134.29,94.59 134.49,94.79 134.49,95.68 134.94,96.13 134.94,97.01 R25488.2 ; VRAM1.J11 133.01,91.8 v2(133.01,91.81) ; U8.D25 114.13,95.46 v2(114.51,95.85)
VMA_CLK1: length 45.6
  TOP w0.102: v2(133.01,107.81) 133.25,107.57 133.25,107.26 133.03,107.05 131.89,107.05 131.63,107.3 126.16,107.3 125.86,107 125.86,106.14 125.72,106 125.47,106 125.37,106.1 125.37,106.94 125.14,107.18 124.7,107.18 124.48,106.96 124.48,106.1 124.38,106 123.52,106 123.08,105.56 123.08,104.92 123.29,104.71 124.75,104.71 124.85,104.6 124.85,104.3 124.75,104.2 123.29,104.2 123.08,103.99 123.08,103.52 123.29,103.31 124.95,103.31 125.05,103.21 125.05,102.9 124.95,102.8 123.29,102.8 123.08,102.59 123.08,102.05 121.98,100.95 117.04,100.95 116.41,101.59 113.44,101.59 113.16,101.86 112.49,101.86 112.11,102.25 v2(112.11,102.49)
  BOTTOM w0.079: 134.75,104.6 134.75,104.62 134.76,104.64 134.76,105.22 134.53,105.45 134.53,106.81 134.43,106.92 133.93,106.92 133.73,107.12 133.73,107.65 133.65,107.73 133.57,107.73 133.41,107.57 VRAM2.J12
  BOTTOM w0.102: v2(133.01,107.81) 133.01,107.21 133.11,107.11 133.31,107.11 133.41,107.21 VRAM2.J12 ; R25489.1 133.78,102.78 134.08,103.07 134.08,103.54 134.75,104.21 134.75,104.6
  BOTTOM w0.127: v2(112.11,102.49) 111.93,102.49 111.69,102.73 U8.N22
VMA_CLK1#: length 45.9
  TOP w0.102: v2(112.11,101.67) 113.08,101.67 113.36,101.4 116.33,101.4 116.97,100.76 122.06,100.76 123.27,101.97 123.27,102.51 123.37,102.61 125.03,102.61 125.25,102.82 125.25,103.29 125.03,103.5 123.37,103.5 123.27,103.6 123.27,103.91 123.37,104.01 124.83,104.01 125.04,104.22 125.04,104.68 124.83,104.9 123.37,104.9 123.27,105 123.27,105.48 123.6,105.81 124.46,105.81 124.67,106.02 124.67,106.88 124.78,106.99 125.06,106.99 125.18,106.86 125.18,106.02 125.4,105.81 125.79,105.81 126.05,106.06 126.05,106.92 126.24,107.11 131.55,107.11 131.81,106.86 133.11,106.86 133.44,107.18 133.44,107.96 133.01,108.39 v2(133.01,108.62)
  BOTTOM w0.079: 134.94,104.6 134.94,104.62 134.92,104.64 134.92,105.29 134.69,105.51 134.69,106.88 134.49,107.08 134,107.08 133.89,107.19 133.89,107.72 133.71,107.89 133.54,107.89 133.41,108.02 VRAM2.J11
  BOTTOM w0.102: 134.94,104.6 134.94,104.13 134.27,103.46 134.27,103.07 134.56,102.78 R25489.2 ; U8.M22 v2(112.11,101.67) ; v2(133.01,108.62) 133.01,108.61 133.41,108.21 VRAM2.J11
VMA_DQ0: length 39.3
  TOP w0.102: v2(136.21,83.81) 135.82,83.42 135.82,82.66 135.49,82.32
  TOP w0.165: v2(107.92,96.66) 108.51,96.07 108.51,95.38 108.36,95.24 108.36,94.81 109.28,93.89 109.28,93.33 109.44,93.17 109.44,91.91 111.94,89.42 122.02,89.42 v1(122.71,88.73) 125.23,86.2 125.23,85 126.66,83.57 129.61,83.57 131.03,82.15 135.31,82.15 135.49,82.32
  BOTTOM w0.165: VRAM1.E2 136.61,84.2 v2(136.21,83.81) ; v2(107.92,96.66) U8.E18
VMA_DQ1: length 37.3
  TOP w0.102: v2(135.41,83.81) 135.41,83.65 134.99,83.23 134.99,82.73 134.84,82.58
  TOP w0.165: v2(108.72,96.63) 108.77,96.58 108.77,95.62 109.41,94.98 109.41,94.14 109.74,93.81 109.74,93.4 110.59,92.54 110.59,91.36 112.11,89.84 122.25,89.84 125.65,86.44 125.65,85.17 126.83,83.99 v1(129.81,83.99) 131.23,82.57 134.83,82.57 134.84,82.58
  BOTTOM w0.165: v2(135.41,83.81) 135.8,84.2 VRAM1.F2 ; v2(108.72,96.63) 108.35,97.01 U8.F18
VMA_DQ2: length 46
  TOP w0.102: v2(140.21,83.81) 140.21,83.27 139.48,82.54 139.38,82.54 139.14,82.3
  TOP w0.165: 139.14,82.3 138.16,81.31 127.07,81.31 124.39,83.99 124.39,85.73 121.54,88.58 111.54,88.58 108.86,91.27 107.84,91.27 107.5,91.6 107.5,92.74 106.66,93.58 106.66,95.67 106.7,95.7 106.7,96.23 v2(107.09,96.62)
  BOTTOM w0.102: v2(107.09,96.62) 106.68,96.23 U8.E16
  BOTTOM w0.165: v2(140.21,83.81) 139.82,84.2 VRAM1.A2
VMA_DQ3: length 44.6
  TOP w0.102: v2(139.41,83.81) 139.41,83.71 139,83.3 139,82.75 138.83,82.58
  TOP w0.165: v2(107.88,97.52) 107.88,97.27 107.5,96.89 107.5,96.49 107.52,96.47 107.52,95.17 108.36,94.33 108.36,92.98 108.62,92.73 108.62,92.15 111.76,89 121.78,89 124.81,85.97 124.81,84.16 127.25,81.73 137.98,81.73 138.83,82.58
  BOTTOM w0.165: v2(107.88,97.52) 107.88,97.45 U8.F17 ; v2(139.41,83.81) 139.02,84.2 VRAM1.B2
VMA_DQ4: length 31.1
  TOP w0.102: v2(135.41,86.21) 134.99,86.63 134.99,87.24 134.74,87.49
  TOP w0.165: 134.74,87.49 134.34,87.89 127.12,87.89 v1(126.78,88.22) 123.73,91.27 112.74,91.27 112.51,91.5 112.28,91.5 111.39,92.38 111.39,92.88 110.54,93.73 110.54,94.82 v2(110.38,94.98)
  BOTTOM w0.165: VRAM1.F4 135.81,85.81 v2(135.41,86.21) ; v2(110.38,94.98) 110.38,95.04 U8.D20
VMA_DQ5: length 34.9
  TOP w0.102: v2(139.41,85.41) 138.99,84.99 137.97,84.99 137.17,85.79
  TOP w0.165: v2(111.23,95.03) 111.23,94.27 113.37,92.14 124.18,92.14 v1(125.4,90.91) 127.28,89.04 135.29,89.04 136.89,87.44 136.89,86.07 137.17,85.79
  BOTTOM w0.165: VRAM1.B4 139.02,85.8 v2(139.41,85.41) ; v2(111.23,95.03) U8.D21
VMA_DQ6: length 33.4
  TOP w0.102: 135.82,87.24 135.82,86.6 136.21,86.21 v2(136.21,86.21)
  TOP w0.165: 135.82,87.24 134.76,88.3 127.36,88.3 123.96,91.71 112.94,91.71 112.77,91.88 112.28,91.88 111.66,92.49 111.66,92.99 110.81,93.84 110.81,96.09 110.42,96.48 v2(110.42,96.6)
  BOTTOM w0.165: v2(110.42,96.6) 109.99,97.04 U8.F20 ; VRAM1.E4 136.61,85.81 v2(136.21,86.21)
VMA_DQ7: length 36
  TOP w0.102: v2(140.21,85.41) 140.19,85.41 139.81,85.79 137.65,85.79 137.3,86.14 137.3,86.3 ; 111.62,94.83 111.62,95.31 111.23,95.71 v2(111.23,95.83)
  TOP w0.165: 111.62,94.83 111.62,94.3 113.35,92.57 124.4,92.57 v1(124.78,92.19) 127.51,89.46 135.46,89.46 137.3,87.62 137.3,86.3
  BOTTOM w0.165: v2(111.23,95.83) 110.83,96.23 U8.E21 ; VRAM1.A4 139.82,85.8 v2(140.21,85.41)
VMA_DQ8: length 43
  IN1 w0.102: v2(139.41,91.01) 139.01,91.4 139.01,92.94
  IN1 w0.152: v2(106.27,96.63) 106.27,97.82 107.12,98.67 109.68,98.67 110.38,97.96 115.13,97.96 115.5,98.33 117.04,98.33 117.85,99.15 136.37,99.15 138.54,96.97 138.54,93.41 139.01,92.94
  BOTTOM w0.165: v2(106.27,96.63) 106.27,96.61 105.89,96.23 U8.E15 ; v2(139.41,91.01) 139.02,91.4 VRAM1.B11
VMA_DQ9: length 35.2
  IN1 w0.102: 136.61,94.38 136.61,93.81 v2(136.21,93.41)
  IN1 w0.152: 136.61,94.38 135.26,95.73 134.4,95.73 132,98.13 121.41,98.13 120.25,96.96 115.57,96.96 114.88,96.28 112.8,96.28 112.77,96.25 111.06,96.25 111.01,96.2 109.95,96.2 109.92,96.23 107.75,96.23 107.75,96.22 106.84,96.22 106.48,95.86 v2(106.28,95.86)
  BOTTOM w0.165: U8.D15 106.28,95.84 v2(106.28,95.86) ; VRAM1.E13 136.61,93.01 v2(136.21,93.41)
VMA_DQ10: length 45.6
  IN1 w0.152: v2(140.21,92.61) 140.64,93.04 140.64,96.17 136.66,100.15 127.57,100.15 127.27,100.44 120.91,100.44 120.84,100.52 119.79,100.52 119.33,100.06 117.47,100.06 117.07,99.66 114.4,99.66 114.34,99.6 110.3,99.6 109.29,100.61 107.38,100.61 106.93,100.16 106.93,99.66 106.78,99.5 105.59,99.5 105.19,99.1 105.19,97.7 v2(105.43,97.46)
  BOTTOM w0.165: VRAM1.A13 139.82,93 v2(140.21,92.61) ; U8.F15 105.82,97.07 v2(105.43,97.46)
VMA_DQ11: length 49.4
  IN1 w0.152: v2(140.21,91.01) 141.1,91.89 141.1,96.36 136.38,101.08 135.06,101.08 134.89,100.9 121.1,100.9 121.03,100.98 119.6,100.98 119.14,100.52 117.11,100.52 117,100.42 111.13,100.42 110.68,100.86 106.4,100.86 105.98,100.44 105.98,100.25 104.23,98.5 104.23,97.05 v2(103.81,96.64)
  BOTTOM w0.165: VRAM1.A11 139.82,91.4 v2(140.21,91.01) ; v2(103.81,96.64) 104.19,97.01 U8.F13
VMA_DQ12: length 37.7
  IN1 w0.102: v2(137.01,91.81) 136.63,92.19 136.08,92.19 135.82,92.44 135.82,92.81 135.64,93 134.38,93
  IN1 w0.152: 134.38,93 134.05,93.33 134.05,94 131.39,96.66 122.02,96.66 120.86,95.49 118.55,95.49 117.41,94.35 114.18,94.35 113.9,94.63 113.24,94.63 112.85,94.23 108.59,94.23 108.22,94.6 107.61,94.6 107.36,94.35 104.71,94.35 v2(104.63,94.26)
  BOTTOM w0.165: v2(104.63,94.26) 104.26,94.63 U8.C13 ; VRAM1.E11 136.61,91.4 v2(137.01,91.81)
VMA_DQ13: length 36.6
  IN1 w0.102: 134.14,92.54 134.49,92.19 135.03,92.19 v2(135.41,91.81)
  IN1 w0.152: v2(103.81,93.43) 104.22,93.03 105.04,93.03 105.8,93.79 108.34,93.79 108.42,93.86 112.18,93.86 112.33,93.71 113.78,93.71 113.94,93.87 117.58,93.87 118.74,95.03 121.05,95.03 122.21,96.2 131.2,96.2 133.41,93.99 133.41,93.27 134.14,92.54
  BOTTOM w0.165: U8.B13 104.19,93.81 v2(103.81,93.43) ; v2(135.41,91.81) 135.81,91.41 VRAM1.F11
VMA_DQ14: length 44.8
  IN1 w0.102: v2(104.65,95.83) 105.07,96.25 105.07,96.91 105.19,97.04 105.7,97.04 105.85,97.19 105.85,97.27
  IN1 w0.152: v2(139.41,92.61) 139.51,92.7 139.51,93.33 139,93.84 139,97.16 136.56,99.6 117.66,99.6 116.85,98.79 113.92,98.79 113.91,98.78 111.18,98.78 110.81,98.41 110.29,98.41 108.99,99.71 108.29,99.71 108.27,99.69 107.66,99.69 107.37,99.39 107.37,99.27 105.85,97.76 105.85,97.27
  BOTTOM w0.165: v2(104.65,95.83) 104.26,96.23 U8.E13 ; v2(139.41,92.61) 139.02,93 VRAM1.B13
VMA_DQ15: length 35.6
  IN1 w0.102: v2(135.41,93.41) 135.01,93.8 135.01,94.46 134.74,94.73
  IN1 w0.152: 134.74,94.73 133.96,94.73 131.58,97.12 121.84,97.12 120.67,95.95 116.18,95.95 114.84,94.6 114.28,94.6 113.9,94.98 112.96,94.98 112.56,94.58 108.61,94.58 108.33,94.86 107.5,94.86 107.25,94.6 105.08,94.6 v2(104.65,95.03)
  BOTTOM w0.165: v2(135.41,93.41) 135.81,93.01 VRAM1.F13 ; U8.D13 104.26,95.43 v2(104.65,95.03)
VMA_DQ16: length 31.6
  IN1 w0.152: v2(129.83,91) 129.6,90.77 129.6,90.18 129.18,89.76 125.08,89.76 123.6,88.28 109.27,88.28 108.46,89.09 106.71,89.09 104.71,91.09 104.71,91.96 105.37,92.62 v2(105.44,92.62)
  BOTTOM w0.165: U8.B15 105.84,93.83 105.44,93.42 v2(105.44,92.62) ; VRAM1.N11 130.21,91.37 v2(129.83,91)
VMA_DQ17: length 26.6
  IN1 w0.152: v2(106.36,92.44) 105.98,92.06 105.98,91.18 107.16,90 108.84,90 109.65,89.19 123.22,89.19 124.95,90.92 126.48,90.92 v2(126.58,91.02)
  BOTTOM w0.165: v2(126.58,91.02) 126.96,91.4 VRAM1.U11 ; v2(106.36,92.44) 106.27,92.53 106.27,94.23 U8.C16
VMA_DQ18: length 31.9
  IN1 w0.152: v2(130.61,91) 130.11,90.5 130.11,90.04 129.37,89.31 125.27,89.31 123.79,87.82 109.08,87.82 108.27,88.63 106.52,88.63 104.19,90.97 v2(104.19,92.32)
  BOTTOM w0.165: v2(104.19,92.32) U8.A13 ; VRAM1.M11 v2(130.61,91)
VMA_DQ19: length 26.9
  IN1 w0.152: v2(127.42,90.99) 126.88,90.46 125.14,90.46 123.41,88.73 109.46,88.73 108.65,89.55 106.9,89.55 105.17,91.28 105.17,91.73 v2(105.47,92.04)
  BOTTOM w0.165: U8.A15 105.9,93 105.9,92.46 v2(105.47,92.04) ; v2(127.42,90.99) 127.42,91.01 VRAM1.T11
VMA_DQ20: length 23.1
  IN1 w0.152: v2(108.01,91.68) 108.16,91.53 109.47,91.53 110.28,90.71 122.59,90.71 124.92,93.05 126.33,93.05 v2(126.43,92.95)
  BOTTOM w0.102: U8.B18 108.35,93.67 108.01,93.33 108.01,93.05 107.51,92.55 107.51,92.18 v2(108.01,91.68)
  BOTTOM w0.165: v2(126.43,92.95) 126.96,92.95 VRAM1.U13
VMA_DQ21: length 23.3
  IN1 w0.152: v2(108.01,92.44) 108.47,91.98 109.66,91.98 110.47,91.17 122.4,91.17 125.44,94.21 v2(127.4,94.21)
  BOTTOM w0.165: VRAM1.T13 127.4,93.41 v2(127.4,94.21) ; v2(108.01,92.44) 108.35,92.78 U8.A18
VMA_DQ22: length 28.6
  IN1 w0.152: v2(129.83,93.4) 130.25,93.83 130.25,94.37 129.95,94.67 125.25,94.67 124.22,93.64 119.62,93.64 117.61,91.63 112.13,91.63 111.97,91.79 111.97,92.71 111.68,93 111.22,93 111.07,92.85 111.07,91.83 110.91,91.68 110.61,91.68 110.46,91.83 110.46,92.85 110.3,93 109.59,93 v2(109.03,92.44)
  BOTTOM w0.165: v2(109.03,92.44) 109.03,92.91 U8.A19 ; v2(129.83,93.4) 130.21,93.03 VRAM1.N13
VMA_DQ23: length 27.1
  IN1 w0.152: v2(108.77,93.43) 108.8,93.46 111.87,93.46 112.42,92.9 112.89,92.9 113.7,92.09 117.42,92.09 119.43,94.09 124.03,94.09 125.06,95.13 130.14,95.13 130.71,94.56 130.71,93.5 v2(130.61,93.4)
  BOTTOM w0.165: v2(130.61,93.4) VRAM1.M13 ; U8.C19 108.77,94.25 v2(108.77,93.43)
VMA_DQ24: length 21.2
  BOTTOM w0.165: VRAM1.N4 129.81,86.2 129.81,86.78 129.54,87.04 129.54,87.17 128.84,87.87 127.54,87.87 123.23,92.19 113.98,92.19 113.73,92.44 113.73,93.2 113.33,93.6 U8.B24
VMA_DQ25: length 20.2
  BOTTOM w0.165: VRAM1.U4 126.6,86.21 126.6,87.36 122.64,91.32 113.45,91.32 112.96,91.82 112.96,94.16 U8.C23
VMA_DQ26: length 20.9
  BOTTOM w0.165: U8.A25 114.13,92.78 114.3,92.62 123.46,92.62 127.58,88.51 129.73,88.51 130.62,87.62 130.62,86.19 VRAM1.M4
VMA_DQ27: length 18.6
  BOTTOM w0.165: U8.A24 113.33,92.2 113.78,91.76 122.92,91.76 127.42,87.26 127.42,86.19 VRAM1.T4
VMA_DQ28: length 23.2
  BOTTOM w0.165: VRAM1.T2 127.42,83.81 125.66,83.81 124.81,84.66 124.81,86.43 121.8,89.44 112.41,89.44 111.19,90.66 111.19,92.32 110.83,92.67 U8.A21
VMA_DQ29: length 22.4
  BOTTOM w0.165: VRAM1.U2 126.03,84.2 125.41,84.82 125.41,86.45 121.98,89.88 112.69,89.88 111.45,91.11 111.45,92.61 111.24,92.82 111.24,93.42 U8.B21
VMA_DQ30: length 32.1
  BOTTOM w0.165: VRAM1.M2 130.62,83.81 130.62,82.71 129.62,81.72 126.57,81.72 123.89,84.4 123.89,86.04 121.35,88.58 111.49,88.58 110.17,89.9 110.17,91.55 109.48,92.25 109.48,92.77 109.54,92.82 109.54,93.97 109.99,94.42 U8.C20
VMA_DQ31: length 29.5
  BOTTOM w0.165: U8.C21 110.42,94.23 110.42,92.32 110.68,92.06 110.68,90.28 111.95,89.01 121.52,89.01 124.35,86.19 124.35,84.53 126.5,82.38 129.06,82.38 129.81,83.12 129.81,83.8 VRAM1.N2
VMA_DQ32: length 38.7
  IN1 w0.102: v2(112.11,104.15) 112.11,104.06 112.54,103.63 112.54,102.27 112.84,101.97
  IN1 w0.152: v2(140.21,108.61) 141.1,107.72 141.1,103.56 139.79,102.25 134.36,102.25 133.9,101.79 119.65,101.79 118.98,101.12 117.41,101.12 117.2,101.33 113.47,101.33 112.84,101.97
  BOTTOM w0.165: v2(112.11,104.15) U8.R22 ; VRAM2.U11 140.21,108.6 v2(140.21,108.61)
VMA_DQ33: length 28
  IN1 w0.152: v2(136.21,108.61) 136.71,109.11 136.71,109.84 136.26,110.3 125.19,110.3 123.98,109.09 121.87,109.09 119.24,106.46 117.18,106.46 115.68,104.96 v2(113.74,104.96)
  BOTTOM w0.165: U8.R24 113.36,104.57 v2(113.74,104.96) ; v2(136.21,108.61) 136.61,108.21 VRAM2.N11
VMA_DQ34: length 33.7
  IN1 w0.102: 114.54,101.89 114.11,102.32 114.11,102.65 113.88,102.87 113.58,102.87 113.35,103.11 113.35,103.62 113.23,103.73 112.73,103.73 112.54,103.92 112.54,104.54 v2(112.11,104.97)
  IN1 w0.152: v2(140.21,106.21) 139.63,105.63 139.63,104.76 138.03,103.16 133.98,103.16 133.53,102.7 118.78,102.7 117.96,101.89 114.54,101.89
  BOTTOM w0.165: VRAM2.U13 139.82,106.6 v2(140.21,106.21)
  BOTTOM w0.305: v2(112.11,104.97) 111.71,105.37 U8.T22
