# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ27: length 58
  TOP w0.102: U2010.D7 v2(43.49,74.11)
  IN3 w0.089: v2(43.49,74.11) 43.49,73.84 43.76,73.57 44.28,73.57 44.38,73.47 44.38,73.37 44.28,73.27 43.95,73.27 43.85,73.16 43.85,73.04 43.93,72.95 44.38,72.95 44.98,72.35 45.19,72.35 45.67,72.83 46.19,72.83 46.25,72.77 46.25,72.39 46.34,72.3 46.49,72.3 46.57,72.38 46.57,72.76 46.64,72.83 46.78,72.83 46.85,72.76 46.85,72.38 46.93,72.3 47.03,72.3 47.12,72.38 47.12,72.74 47.2,72.83 47.32,72.83 47.41,72.74 47.41,72.38 47.5,72.3 47.62,72.3 47.7,72.38 47.7,72.74 47.79,72.83 47.91,72.83 47.99,72.74 47.99,72.38 48.08,72.3 48.2,72.3 48.29,72.38 48.29,72.74 48.37,72.83 48.49,72.83 48.58,72.74 48.58,72.38 48.66,72.3 48.79,72.3 48.87,72.38 48.87,72.74 48.96,72.83 49.08,72.83 49.16,72.74 49.16,72.38 49.25,72.3 49.36,72.3 49.46,72.4 49.46,72.73 49.57,72.83 50.02,72.83 50.66,73.47 53.29,73.47 53.37,73.38 53.37,73.13 53.46,73.04 53.58,73.04 53.67,73.13 53.67,73.38 53.75,73.47 53.87,73.47 53.96,73.38 53.96,72.9 54.04,72.82 54.16,72.82 54.25,72.9 54.25,73.38 54.34,73.47 57.09,73.47 57.74,72.82 58.45,72.82 59.09,72.17 66.8,72.17 67.8,71.17 70.8,71.17 71.44,70.53 72.59,70.53 73.95,69.17 74.87,69.17 75.13,68.91 75.55,68.91 75.62,68.84 75.62,68.54 75.71,68.46 75.83,68.46 75.92,68.54 75.92,68.88 76,68.96 76.12,68.96 76.21,68.88 76.21,67.8 76.29,67.72 76.41,67.72 76.5,67.8 76.5,68.88 76.59,68.96 76.71,68.96 76.79,68.88 76.79,67.09 76.88,67.01 77,67.01 77.08,67.09 77.08,68.84 77.18,68.94 77.33,68.94 77.4,68.86 77.4,68.53 77.48,68.46 77.66,68.46 77.74,68.53 77.74,68.84 77.81,68.91 78.01,68.91 78.09,68.84 78.09,68.56 78.17,68.48 78.32,68.48 78.42,68.58 78.42,69.26 78.5,69.34 79.59,69.34 v2(80.14,69.88)
  BOTTOM w0.114: U2030.AN60 v2(80.14,69.88)
M_B_DQ28: length 57.8
  TOP w0.102: v2(48.1,76.77) 47.86,76.77 47.76,76.67 47.76,75.7 47.68,75.62 47.51,75.62 47.38,75.75 47.38,77.33 47.2,77.51 46.75,77.51 46.56,77.7 U2010.A3
  IN3 w0.089: v2(48.1,76.77) 48.44,77.11 48.44,77.22 48.3,77.35 48.3,77.46 48.38,77.54 48.49,77.54 48.62,77.41 48.73,77.41 48.81,77.48 48.81,77.59 48.68,77.73 48.68,77.84 48.75,77.92 48.87,77.92 49,77.78 49.11,77.78 49.19,77.86 49.19,77.97 49.05,78.11 49.05,78.22 49.13,78.3 49.24,78.3 49.38,78.16 49.65,78.16 49.73,78.24 49.73,78.43 49.81,78.51 49.92,78.51 49.99,78.43 49.99,78.24 50.07,78.16 50.18,78.16 50.26,78.24 50.26,78.43 50.34,78.51 50.45,78.51 50.53,78.43 50.53,78.24 50.61,78.16 50.72,78.16 50.79,78.24 50.79,78.43 50.87,78.51 50.98,78.51 51.06,78.43 51.06,78.24 51.14,78.16 53.4,78.16 53.42,78.17 54.04,78.17 54.12,78.25 54.12,78.43 54.2,78.51 54.31,78.51 54.39,78.43 54.39,78.25 54.47,78.17 54.58,78.17 54.66,78.25 54.66,78.43 54.73,78.51 54.84,78.51 54.92,78.43 54.92,78.25 55,78.17 55.11,78.17 55.19,78.25 55.19,78.43 55.27,78.51 55.38,78.51 55.46,78.43 55.46,78.25 55.53,78.17 55.64,78.17 55.72,78.25 55.72,78.43 55.8,78.51 55.91,78.51 55.99,78.43 55.99,78.25 56.07,78.17 56.18,78.17 56.26,78.25 56.26,78.43 56.33,78.51 56.44,78.51 56.52,78.43 56.52,78.25 56.6,78.17 56.71,78.17 56.79,78.25 56.79,78.43 56.87,78.51 56.98,78.51 57.06,78.43 57.06,78.25 57.13,78.17 57.24,78.17 57.32,78.25 57.32,78.43 57.4,78.51 57.51,78.51 57.59,78.43 57.59,78.25 57.67,78.17 57.78,78.17 57.86,78.25 57.86,78.43 57.93,78.51 58.04,78.51 58.12,78.43 58.12,78.25 58.2,78.17 58.31,78.17 58.39,78.25 58.39,78.43 58.47,78.51 58.58,78.51 58.66,78.43 58.66,78.25 58.73,78.17 58.84,78.17 58.92,78.25 58.92,78.43 59,78.51 59.11,78.51 59.19,78.43 59.19,78.25 59.27,78.17 59.38,78.17 59.46,78.25 59.46,78.43 59.53,78.51 59.64,78.51 59.72,78.43 59.72,78.25 59.8,78.17 59.91,78.17 59.99,78.25 59.99,78.43 60.07,78.51 60.18,78.51 60.26,78.43 60.26,78.25 60.33,78.17 60.44,78.17 60.52,78.25 60.52,78.43 60.6,78.51 60.71,78.51 60.79,78.43 60.79,78.25 60.87,78.17 60.98,78.17 61.06,78.25 61.06,78.43 61.13,78.51 61.24,78.51 61.32,78.43 61.32,78.25 61.4,78.17 61.51,78.17 61.59,78.25 61.59,78.43 61.67,78.51 61.78,78.51 61.86,78.43 61.86,78.25 61.93,78.17 62.04,78.17 62.12,78.25 62.12,78.43 62.2,78.51 62.31,78.51 62.39,78.43 62.39,78.25 62.47,78.17 62.58,78.17 62.66,78.25 62.66,78.43 62.73,78.51 62.84,78.51 62.92,78.43 62.92,78.25 63,78.17 63.11,78.17 63.19,78.25 63.19,78.43 63.27,78.51 63.38,78.51 63.46,78.43 63.46,78.25 63.53,78.17 63.64,78.17 63.72,78.25 63.72,78.43 63.8,78.51 63.91,78.51 63.99,78.43 63.99,78.25 64.07,78.17 64.18,78.17 64.26,78.25 64.26,78.43 64.33,78.51 64.44,78.51 64.52,78.43 64.52,78.25 64.6,78.17 64.71,78.17 64.79,78.25 64.79,78.43 64.87,78.51 64.98,78.51 65.06,78.43 65.06,78.25 65.13,78.17 65.24,78.17 65.32,78.25 65.32,78.43 65.4,78.51 65.51,78.51 65.59,78.43 65.59,78.25 65.67,78.17 66.14,78.17 68.46,75.85 68.46,75.54 68.57,75.44 68.67,75.44 68.77,75.54 68.77,76.33 68.89,76.45 71.65,76.45 71.94,76.17 71.94,75.4 72.97,74.36 72.97,73.54 73.73,72.78 74.81,72.78 75.93,71.66 78.21,71.66 78.53,71.34 80.31,71.34 80.4,71.25 80.4,71.05 v2(80.16,70.82)
  BOTTOM w0.114: U2030.AN61 v2(80.16,70.82)
M_B_DQ29: length 57.3
  TOP w0.102: U2010.C2 45.14,78.03 45.14,76.93 45.35,76.72 45.5,76.72 45.6,76.82 45.6,77.35 45.71,77.46 45.88,77.46 46.01,77.33 46.01,76.57 46.11,76.47 46.26,76.47 46.39,76.59 46.39,77.05 46.5,77.16 46.69,77.16 46.8,77.05 v2(46.8,76.12)
  IN3 w0.089: v2(79.52,70.8) 79.52,71.1 79.45,71.17 78.46,71.17 78.14,71.48 75.75,71.48 74.67,72.56 73.64,72.56 72.58,73.62 72.58,73.85 72.76,74.03 72.76,74.18 72.65,74.28 72.53,74.28 72.31,74.06 72.19,74.06 72.1,74.15 72.1,74.28 72.3,74.48 72.3,74.61 71.72,75.19 71.54,75.19 71.46,75.26 71.46,75.56 71.4,75.63 71.29,75.63 71.19,75.53 71.19,75.26 71.11,75.19 71,75.19 70.93,75.26 70.93,75.51 70.85,75.59 70.74,75.59 70.66,75.51 70.66,75.26 70.58,75.19 70.47,75.19 70.39,75.26 70.39,75.51 70.32,75.59 70.21,75.59 70.13,75.5 70.13,75.26 70.05,75.19 69.94,75.19 69.86,75.26 69.86,75.5 69.78,75.58 69.67,75.58 69.59,75.5 69.59,75.26 69.51,75.19 69.4,75.19 69.33,75.26 69.33,75.5 69.25,75.58 69.14,75.58 69.06,75.5 69.06,75.26 68.98,75.19 68.21,75.19 68.02,75.37 68.02,75.95 66.74,77.23 66.64,77.23 66.58,77.18 66.58,76.95 66.52,76.88 66.39,76.88 66.31,76.97 66.31,77.61 66.23,77.68 66.13,77.68 66.05,77.61 66.05,76.95 65.99,76.88 65.83,76.88 65.77,76.95 65.77,77.86 65.69,77.93 65.57,77.93 65.49,77.85 65.49,76.98 65.41,76.9 65.3,76.9 65.23,76.98 65.23,77.85 65.15,77.93 65.04,77.93 64.96,77.85 64.96,76.98 64.88,76.9 64.77,76.9 64.69,76.98 64.69,77.85 64.61,77.93 59.39,77.93 59.38,77.92 49.59,77.92 48.83,77.16 48.83,77.04 48.94,76.92 48.94,76.76 48.88,76.69 48.78,76.69 48.73,76.74 48.6,76.74 48.32,76.46 48.32,76.08 48.26,76.02 47.94,76.02 47.89,76.07 47.89,76.45 47.82,76.52 47.66,76.52 47.59,76.44 47.59,76.1 47.51,76.02 47.32,76.02 47.23,76.11 47.23,76.67 47.15,76.74 46.92,76.74 46.8,76.62 v2(46.8,76.12)
  BOTTOM w0.114: U2030.AP61 v2(79.52,70.8)
M_B_DQ30: length 57.1
  TOP w0.102: U2010.C8 45.06,73.31 v2(45.08,73.31)
  IN3 w0.089: v2(45.08,73.31) 45.5,73.31 45.58,73.4 45.58,73.74 45.67,73.83 45.79,73.83 45.87,73.74 45.87,73.4 45.96,73.31 46.08,73.31 46.17,73.4 46.17,73.61 46.25,73.7 46.37,73.7 46.46,73.61 46.46,73.4 46.54,73.31 46.66,73.31 46.75,73.4 46.75,73.61 46.84,73.7 46.96,73.7 47.04,73.61 47.04,73.4 47.13,73.31 49.82,73.31 50.46,73.95 57.34,73.95 57.49,73.8 57.62,73.8 57.77,73.95 57.87,73.95 57.97,73.84 57.97,73.74 57.85,73.62 57.85,73.49 58.04,73.3 58.16,73.3 58.24,73.39 58.24,73.86 58.33,73.95 58.45,73.95 58.54,73.86 58.54,73.39 58.62,73.3 58.74,73.3 58.83,73.39 58.83,73.86 58.91,73.95 59.03,73.95 59.12,73.86 59.12,72.83 59.18,72.77 59.33,72.77 59.41,72.85 59.41,73.86 59.5,73.95 59.68,73.95 59.75,73.88 59.75,72.74 59.83,72.66 59.95,72.66 60.04,72.74 60.04,73.86 60.12,73.95 60.24,73.95 60.33,73.86 60.33,72.74 60.42,72.66 60.54,72.66 60.62,72.74 60.62,73.82 60.71,73.9 60.83,73.9 60.91,73.82 60.91,72.74 61,72.66 61.12,72.66 61.21,72.74 61.21,73.82 61.29,73.9 61.41,73.9 61.5,73.82 61.5,72.74 61.58,72.66 61.7,72.66 61.79,72.74 61.79,73.82 61.88,73.9 62,73.9 62.08,73.82 62.08,72.74 62.17,72.66 62.29,72.66 62.37,72.74 62.37,73.82 62.46,73.9 62.58,73.9 62.67,73.82 62.67,72.74 62.75,72.66 62.87,72.66 62.96,72.74 62.96,73.82 63.04,73.9 66.63,73.9 67.63,72.9 71.23,72.9 73.61,70.52 74.5,70.52 75.52,69.5 78.1,69.5 78.18,69.59 v2(78.18,69.88)
  BOTTOM w0.114: U2030.AT60 78.37,69.63 v2(78.18,69.88)
M_B_DQ31: length 56.2
  TOP w0.102: v2(45.06,74.12) 45.47,73.71 U2010.B8
  IN3 w0.089: v2(45.06,74.12) 45.28,73.9 45.4,73.9 45.63,74.13 45.63,74.23 45.43,74.43 45.43,74.56 45.71,74.84 45.71,74.99 45.78,75.07 45.9,75.07 45.99,74.98 45.99,74.02 46.08,73.93 46.2,73.93 46.28,74.02 46.28,74.98 46.37,75.07 46.49,75.07 46.57,74.98 46.57,74.02 46.66,73.93 46.78,73.93 46.87,74.02 46.87,74.98 46.95,75.07 47.13,75.07 47.2,74.99 47.2,73.79 47.44,73.55 49.13,73.55 49.3,73.72 49.44,73.72 49.61,73.55 49.72,73.55 49.82,73.65 49.82,73.77 49.62,73.97 49.62,74.09 49.7,74.18 49.82,74.18 50.03,73.98 50.14,73.98 50.26,74.09 50.26,74.27 50.09,74.44 50.09,74.57 50.31,74.79 50.43,74.79 50.56,74.66 50.56,74.29 50.66,74.19 50.79,74.19 50.87,74.28 50.87,74.78 50.63,75.02 50.63,75.11 50.96,75.44 51.08,75.44 51.16,75.35 51.16,74.28 51.25,74.19 51.37,74.19 51.46,74.28 51.46,75.35 51.54,75.44 51.66,75.44 51.75,75.35 51.75,74.28 51.83,74.19 51.96,74.19 52.04,74.28 52.04,75.35 52.13,75.44 52.25,75.44 52.33,75.35 52.33,74.28 52.42,74.19 52.54,74.19 52.63,74.28 52.63,75.35 52.71,75.44 52.83,75.44 52.92,75.35 52.92,74.28 53,74.19 53.14,74.19 53.23,74.28 53.23,75.38 53.31,75.47 53.43,75.47 53.52,75.38 53.52,74.28 53.61,74.19 66.69,74.19 67.69,73.19 71.35,73.19 73.77,70.77 74.61,70.77 75.57,69.81 77.46,69.81 v2(77.53,69.88)
  BOTTOM w0.114: U2030.AU60 v2(77.53,69.88)
M_B_DQ32: length 61.6
  TOP w0.102: v2(41.86,56.71) 41.09,56.71 U2011.H3
  IN3 w0.089: v2(77.58,58.91) 75.98,58.91 75.78,58.71 75.78,58.6 76.1,58.28 76.1,58.17 76.02,58.09 75.91,58.09 75.56,58.44 75.44,58.44 75.36,58.36 75.36,58.26 75.72,57.9 75.72,57.79 75.65,57.71 75.54,57.71 75.17,58.07 75.05,58.07 74.97,57.99 74.97,57.9 75.35,57.52 75.35,57.38 74.23,56.27 73.16,56.27 72.67,55.78 61.3,55.78 60.73,55.22 60.73,53.9 60.67,53.83 60.46,53.83 60.36,53.94 60.36,54.14 60.29,54.22 59.88,54.22 59.58,53.92 57.07,53.92 56.44,53.29 54.64,53.29 54.32,52.98 53.58,52.98 53.46,53.1 53.46,53.75 53.25,53.96 51.46,53.96 51.38,53.88 51.38,53.68 51.3,53.6 51.19,53.6 51.12,53.68 51.12,54.72 51.05,54.78 50.94,54.78 50.85,54.69 50.85,53.68 50.77,53.6 50.66,53.6 50.58,53.68 50.58,55.08 50.5,55.16 50.38,55.16 50.3,55.08 50.3,54.17 50.22,54.09 50.11,54.09 50.01,54.18 50.01,55.14 49.92,55.24 49.76,55.24 49.68,55.15 49.68,54.85 49.58,54.75 49.43,54.75 49.36,54.82 49.36,55.5 49.27,55.59 49.14,55.59 49.05,55.49 49.05,55.25 48.96,55.17 48.79,55.17 48.72,55.24 48.72,55.42 48.26,55.89 48.14,55.89 47.97,55.72 47.86,55.72 47.79,55.8 47.79,55.91 47.96,56.08 47.96,56.19 47.88,56.27 47.77,56.27 47.6,56.1 47.49,56.1 47.41,56.18 47.41,56.29 47.58,56.46 47.58,56.57 47.5,56.65 47.39,56.65 47.24,56.49 47.13,56.49 47.05,56.57 47.05,56.69 47.2,56.83 47.2,56.94 47.06,57.09 45.52,57.09 45.44,57.01 45.44,56.7 45.37,56.62 45.26,56.62 45.18,56.7 45.18,57.01 45.1,57.09 44.99,57.09 44.91,57.01 44.91,56.77 44.83,56.69 44.72,56.69 44.64,56.77 44.64,57.01 44.57,57.09 43.93,57.09 43.87,57.15 43.87,57.62 43.79,57.7 43.68,57.7 43.61,57.62 43.61,57.15 43.53,57.07 43.42,57.07 43.34,57.15 43.34,57.6 43.27,57.68 43.16,57.68 43.07,57.59 43.07,56.88 42.95,56.76 42.38,56.76 42.08,57.06 42.08,58.01 42,58.09 41.87,58.09 41.76,57.97 41.76,56.81 v2(41.86,56.71)
  BOTTOM w0.102: v2(77.58,58.91) 77.58,58.75 U2030.AU40
M_B_DQ33: length 62.2
  TOP w0.102: v2(42.68,57.48) 41.86,57.48 U2011.G2
  IN3 w0.079: v2(78.2,58.94) 77.84,59.3 77.43,59.3 77.38,59.25 77.19,59.25
  IN3 w0.089: 77.19,59.25 75.9,59.25 74.7,58.05 74.7,57.85 75.02,57.54 75.02,57.4 74.94,57.32 74.85,57.32 74.71,57.46 74.58,57.46 74.51,57.39 74.51,57.27 74.64,57.15 74.64,57.02 74.25,56.63 74.12,56.63 73.8,56.95 73.71,56.95 73.29,56.53 72.92,56.53 72.42,56.03 61.2,56.03 60.44,55.26 60.44,54.55 60.35,54.46 60.18,54.46 60.11,54.53 60.11,55.07 60.01,55.17 59.88,55.17 59.78,55.07 59.78,54.46 59.62,54.3 59.52,54.3 59.45,54.37 59.45,54.95 59.37,55.03 59.24,55.03 59.17,54.95 59.17,54.24 59.09,54.16 58.98,54.16 58.9,54.24 58.9,54.95 58.82,55.03 58.71,55.03 58.63,54.95 58.63,54.24 58.56,54.16 58.45,54.16 58.37,54.24 58.37,54.95 58.29,55.03 58.18,55.03 58.1,54.95 58.1,54.24 58.02,54.16 57.91,54.16 57.83,54.24 57.83,54.95 57.76,55.03 57.65,55.03 57.57,54.95 57.57,54.24 57.49,54.16 57.38,54.16 57.3,54.24 57.3,54.95 57.22,55.03 57.11,55.03 57.03,54.95 57.03,54.21 56.96,54.13 56.84,54.13 56.76,54.21 56.76,54.79 56.69,54.86 56.58,54.86 56.5,54.78 56.5,53.69 56.34,53.53 56.06,53.53 55.98,53.61 55.98,54.01 55.9,54.09 55.79,54.09 55.71,54.01 55.71,53.61 55.64,53.53 55.52,53.53 55.45,53.61 55.45,54 55.37,54.08 55.26,54.08 55.18,54 55.18,53.6 55.12,53.53 55.01,53.53 54.91,53.63 54.91,53.99 54.84,54.07 54.72,54.07 54.65,53.99 54.65,53.6 54.57,53.52 54.46,53.52 54.38,53.6 54.38,54 54.3,54.08 54.12,54.08 54.02,53.98 54.02,53.31 53.93,53.22 53.8,53.22 53.7,53.31 53.7,54.02 53.96,54.28 53.96,54.66 53.75,54.87 53.58,54.87 53.5,54.79 53.5,54.29 53.45,54.23 53.29,54.23 53.19,54.33 53.19,54.78 53.1,54.87 51.33,54.87 50.35,55.85 50.1,55.85 50.01,55.76 50.01,55.57 49.93,55.5 49.82,55.5 49.74,55.57 49.74,55.76 49.65,55.85 48.64,55.85 47.16,57.33 46.57,57.33 45.96,57.94 42.77,57.94 42.59,58.13 42.46,58.13 42.33,57.99 42.33,57.84 v2(42.68,57.48)
  BOTTOM w0.114: v2(78.2,58.94) 78.51,58.47 U2030.AT40
M_B_DQ34: length 63.2
  TOP w0.102: U2011.F7 v2(42.68,53.5)
  IN3 w0.089: v2(78.19,57.01) 78.19,56.78 78,56.59 76.48,56.59 75.37,55.48 75.37,55.4 73.76,53.78 73.54,53.78 73.47,53.71 73.47,53.58 73.39,53.5 73.21,53.5 73.15,53.57 73.15,53.72 73.09,53.78 72.52,53.78 72.4,53.66 72.4,53.2 72.53,53.07 72.53,52.95 72.45,52.87 67.35,52.87 67.17,53.05 66.7,53.05 64.67,51.01 63.93,51.01 63.85,50.93 63.85,50.28 63.78,50.2 63.67,50.2 63.59,50.28 63.59,50.93 63.51,51.01 63.4,51.01 63.32,50.93 63.32,50.28 63.24,50.2 63.13,50.2 63.05,50.28 63.05,50.93 62.98,51.01 62.87,51.01 62.79,50.93 62.79,50.28 62.71,50.2 62.6,50.2 62.52,50.28 62.52,50.93 62.44,51.01 61.95,51.01 60.25,49.31 60.25,48.82 60.16,48.73 60.03,48.73 59.95,48.81 59.95,49.07 59.88,49.14 59.76,49.14 59.68,49.07 59.68,48.29 59.59,48.2 59.46,48.2 59.38,48.29 59.38,49.06 59.3,49.14 59.17,49.14 59.08,49.05 59.08,48.29 58.99,48.2 58.88,48.2 58.81,48.28 58.81,49.08 58.73,49.16 58.62,49.16 58.54,49.08 58.54,48.26 58.46,48.19 58.35,48.19 58.27,48.27 58.27,49.08 58.19,49.16 58.08,49.16 58.01,49.08 58.01,48.26 57.93,48.19 57.82,48.19 57.74,48.27 57.74,48.86 57.65,48.94 57.54,48.94 57.47,48.87 57.47,48.41 57.29,48.22 54.93,48.22 54.8,48.35 54.8,49.61 54.72,49.7 54.55,49.7 54.46,49.61 54.46,48.26 54.37,48.17 54.24,48.17 54.15,48.27 54.15,49.74 54.08,49.81 53.89,49.81 53.8,49.72 53.8,48.27 53.72,48.19 53.6,48.19 53.51,48.29 53.51,49.84 53.43,49.91 51.42,49.91 49.03,52.31 48.46,52.31 46.37,54.4 44.6,54.4 44.29,54.08 43.26,54.08 v2(42.68,53.5)
  BOTTOM w0.114: U2030.AT37 78.51,56.63 78.19,57.01 v2(78.19,57.01)
M_B_DQ35: length 63.1
  TOP w0.102: U2011.H8 41.08,52.7 41.08,53.2 41.35,53.46 v2(41.87,53.46)
  IN3 w0.089: v2(77.49,57) 77.27,56.78 76.38,56.78 75.17,55.57 75.17,55.48 73.67,53.98 72.4,53.98 72.19,53.78 72.19,53.27 72.07,53.14 67.45,53.14 67.26,53.33 66.64,53.33 64.57,51.25 61.85,51.25 61.72,51.12 61.42,51.12 61.34,51.04 61.34,50.74 61.28,50.68 61.15,50.68 61.07,50.76 61.07,51.03 60.99,51.11 60.88,51.11 60.8,51.03 60.8,50.2 60.72,50.12 60.42,50.12 60.27,49.97 60.27,49.67 60.19,49.59 60.08,49.59 60,49.67 60,49.97 59.92,50.04 59.81,50.04 59.73,49.97 59.73,49.44 59.66,49.36 59.55,49.36 59.47,49.44 59.47,49.94 59.39,50.02 59.28,50.02 59.2,49.94 59.2,49.46 59.12,49.38 59.01,49.38 58.93,49.46 58.93,49.94 58.86,50.02 58.75,50.02 58.67,49.94 58.67,49.48 58.59,49.4 58.48,49.4 58.4,49.48 58.4,49.94 58.32,50.02 58.21,50.02 58.13,49.94 58.13,49.48 58.06,49.4 57.95,49.4 57.86,49.49 57.86,49.89 57.76,49.99 57.61,49.99 57.54,49.92 57.54,49.25 57.46,49.17 57.35,49.17 57.27,49.25 57.27,49.58 57.21,49.64 57.1,49.64 57.01,49.55 57.01,49.2 56.93,49.12 56.82,49.12 56.74,49.2 56.74,49.86 56.66,49.94 56.55,49.94 56.47,49.86 56.47,49.23 56.4,49.15 56.29,49.15 56.21,49.23 56.21,49.93 56.13,50.01 56.02,50.01 55.94,49.93 55.94,49.2 55.86,49.12 55.75,49.12 55.67,49.2 55.67,49.93 55.6,50.01 55.49,50.01 55.41,49.93 55.41,49.21 55.33,49.14 55.22,49.14 55.14,49.21 55.14,49.86 55.06,49.94 54.3,49.94 54.04,50.19 54.04,51.06 53.96,51.14 53.85,51.14 53.78,51.06 53.78,50.19 53.7,50.12 53.59,50.12 53.51,50.19 53.51,51.06 53.43,51.14 53.32,51.14 53.24,51.06 53.24,50.25 53.17,50.18 53.06,50.18 52.98,50.26 52.98,50.53 52.9,50.6 52.79,50.6 52.71,50.52 52.71,50.24 52.63,50.16 52.52,50.16 52.44,50.24 52.44,50.53 52.37,50.6 52.26,50.6 52.18,50.52 52.18,50.28 52.06,50.16 51.94,50.16 51.84,50.27 51.84,50.48 51.76,50.56 51.63,50.56 51.45,50.38 51.3,50.38 51.07,50.61 51.07,50.79 51.17,50.89 51.17,51.04 51.09,51.12 50.56,51.12 49.13,52.55 48.56,52.55 46.47,54.64 44.24,54.64 44.16,54.56 44.16,54.41 44.08,54.33 43.97,54.33 43.89,54.41 43.89,54.56 43.82,54.64 43.63,54.64 43.41,54.41 43.15,54.41 42.71,53.97 42.38,53.97 v2(41.87,53.46)
  BOTTOM w0.114: U2030.AU37 77.51,57 v2(77.49,57)
M_B_DQ36: length 63.3
  TOP w0.102: v2(42.25,58.47) 41.87,58.09 41.87,57.82 41.49,57.44 41.18,57.44 41.03,57.28 41.03,56.96 40.73,56.67 40.25,56.67 U2011.J3
  IN3 w0.079: 77.26,59.52 77.33,59.45 78.3,59.45 v2(78.86,58.89)
  IN3 w0.089: 77.26,59.52 77.19,59.59 75.9,59.59 73.04,56.73 72.73,56.73 72.27,56.27 61.1,56.27 60.6,55.76 60.46,55.76 60.39,55.84 60.39,56.12 60.29,56.22 60.16,56.22 60.08,56.15 60.08,55.49 60.01,55.41 59.87,55.41 59.8,55.49 59.8,56.09 59.72,56.17 59.61,56.17 59.53,56.09 59.53,55.35 59.45,55.27 59.34,55.27 59.26,55.35 59.26,56.09 59.18,56.17 59.07,56.17 59,56.09 59,55.35 58.92,55.27 58.81,55.27 58.73,55.35 58.73,56.09 58.65,56.17 58.54,56.17 58.46,56.09 58.46,55.35 58.38,55.27 58.27,55.27 58.2,55.35 58.2,56.09 58.12,56.17 58.01,56.17 57.93,56.09 57.93,55.35 57.85,55.27 57.74,55.27 57.66,55.35 57.66,56.09 57.58,56.17 57.47,56.17 57.4,56.09 57.4,55.35 57.32,55.27 57.19,55.27 57.11,55.35 57.11,56.09 57.03,56.17 56.88,56.17 56.81,56.09 56.81,55.21 56.7,55.1 56.61,55.1 56.53,55.18 56.53,55.3 56.46,55.36 56.33,55.36 56.26,55.29 56.26,54.33 56.19,54.26 56.06,54.26 55.98,54.35 55.98,55.26 55.87,55.37 55.75,55.37 55.65,55.27 55.65,54.87 55.56,54.78 55.44,54.78 55.35,54.87 55.35,55.25 55.29,55.31 55.12,55.31 55.05,55.24 55.05,54.92 54.98,54.86 54.74,54.86 54.64,54.95 54.64,55.78 54.53,55.9 54.4,55.9 54.3,55.79 54.3,55.03 54.21,54.94 54.08,54.94 53.99,55.02 53.99,55.81 53.92,55.89 53.74,55.89 53.66,55.8 53.66,55.21 53.56,55.12 53.44,55.12 53.37,55.18 53.37,55.42 53.31,55.48 53.19,55.48 53.1,55.4 53.1,55.2 53.02,55.12 52.93,55.12 52.85,55.19 52.85,55.32 52.77,55.4 52.66,55.4 52.58,55.32 52.58,55.19 52.5,55.12 52.39,55.12 52.31,55.19 52.31,55.32 52.24,55.4 52.13,55.4 52.05,55.32 52.05,55.19 51.97,55.12 51.83,55.12 51.74,55.2 51.74,55.33 51.66,55.4 51.14,55.4 50.45,56.09 48.74,56.09 47.26,57.57 46.67,57.57 46.06,58.18 44.15,58.18 43.55,58.79 43.19,58.79 42.87,58.47 v2(42.25,58.47)
  BOTTOM w0.114: U2030.AR40 v2(78.86,58.89)
M_B_DQ37: length 64.1
  TOP w0.102: v2(42.37,59.13) 41.61,59.13 41.05,58.56 41.05,57.69 40.67,57.32 U2011.H2
  IN3 w0.079: v2(79.53,58.89) 79.66,58.76
  IN3 w0.089: 79.66,58.76 79.92,58.5 80.98,58.5 81.21,58.74 81.21,59.22 81.52,59.52 81.52,60.44 81.88,60.79 81.88,61.05 81.98,61.15 82.79,61.15 82.89,61.05 82.89,60.59 82.99,60.49 83.15,60.49 83.25,60.59 83.25,61.56 83.15,61.66 82.94,61.66 82.76,61.48 81.95,61.48 81.88,61.56 81.88,61.71 81.98,61.81 82.51,61.81 82.59,61.89 82.59,62.04 82.48,62.14 82.18,62.14 82.08,62.24 82.08,62.5 82,62.57 81.9,62.57 81.55,62.22 81.55,60.92 81.21,60.59 81.21,59.7 80.79,59.28 80.62,59.28 80.5,59.4 80.5,59.65 80.43,59.73 80.3,59.73 80.2,59.63 80.2,59.37 80.11,59.28 79.92,59.28 79.82,59.38 79.82,59.96 79.74,60.03 79.61,60.03 79.54,59.96 79.54,59.35 79.46,59.27 79.13,59.27 79.06,59.35 79.06,59.48 79.25,59.68 79.25,60.07 79.13,60.18 78.62,60.18 78.58,60.22 77.25,60.22 76.84,59.81 75.75,59.81 72.9,56.96 72.6,56.96 72.16,56.51 60.66,56.51 60.16,57 59.85,57 59.26,56.41 56.72,56.41 56.45,56.14 53.42,56.14 52.93,55.64 51.24,55.64 50.55,56.33 48.84,56.33 47.36,57.81 46.77,57.81 46.16,58.42 44.25,58.42 43.55,59.13 43.06,59.13 42.8,58.86 42.63,58.86 v2(42.37,59.13)
  BOTTOM w0.114: U2030.AP40 79.68,58.66 v2(79.53,58.89)
M_B_DQ38: length 64.8
  TOP w0.102: U2011.J7 40.49,53.71 40.94,53.71 41.36,54.13 41.61,54.13 v2(41.88,54.4)
  IN3 w0.089: v2(41.88,54.4) 42.3,54.82 42.3,54.9 42.51,55.1 43.17,55.1 43.47,55.41 46.38,55.41 48.76,53.03 49.33,53.03 50.02,52.34 50.62,52.34 50.68,52.28 50.68,51.73 50.77,51.64 50.88,51.64 50.96,51.72 50.96,52.27 51.05,52.37 51.16,52.37 51.22,52.3 51.22,51.72 51.3,51.64 51.41,51.64 51.49,51.72 51.49,51.95 51.58,52.04 51.69,52.04 51.76,51.98 51.76,51.72 51.83,51.64 51.94,51.64 52.02,51.72 52.02,51.99 52.12,52.08 52.23,52.08 52.29,52.02 52.29,51.72 52.37,51.64 52.48,51.64 52.56,51.72 52.56,52.01 52.65,52.11 52.76,52.11 52.82,52.04 52.82,51.72 52.9,51.64 57.2,51.64 57.53,51.31 60.26,51.31 60.59,51.64 61.47,51.64 61.53,51.7 61.53,51.9 61.63,52.01 61.73,52.01 62.01,51.73 64.36,51.73 65.04,52.4 65.04,52.48 64.81,52.71 64.81,52.92 64.86,52.97 65.06,52.97 65.26,52.77 65.4,52.77 66.32,53.69 66.32,53.8 66.21,53.92 66.21,54.12 66.27,54.18 66.59,54.18 66.66,54.11 66.66,53.91 66.74,53.83 67.02,53.83 67.14,53.96 67.14,54.24 67.21,54.31 71.96,54.31 72.04,54.39 73.5,54.39 73.67,54.56 73.67,55.18 73.89,55.4 74.33,55.4 76.17,57.24 76.34,57.24 76.41,57.31 76.41,57.54 76.48,57.61 76.66,57.61 76.72,57.54 76.72,57.36 76.8,57.29 76.9,57.29 77,57.39 77,57.62 77.1,57.72 77.21,57.72 77.35,57.57 78.8,57.57 79.01,57.36 79.14,57.36 79.23,57.46 79.23,58.18 79.03,58.38 79.03,58.51 79.13,58.61 79.26,58.61 79.54,58.33 79.54,57.47 79.61,57.39 79.74,57.39 79.82,57.47 79.82,58.22 79.89,58.29 80.03,58.29 80.12,58.2 80.12,57.52 80.22,57.42 80.36,57.42 80.43,57.49 80.43,58.2 80.5,58.28 80.63,58.28 80.71,58.2 80.71,57.47 80.78,57.4 80.92,57.4 81.01,57.49 81.01,58.22 81.1,58.31 81.23,58.31 81.32,58.22 81.32,56.73 81.16,56.58 79.28,56.58 79.21,56.65 79.21,56.74 v2(79.48,57.01)
  BOTTOM w0.114: v2(79.48,57.01) 79.5,57 U2030.AP37
M_B_DQ39: length 64.5
  TOP w0.102: U2011.H7 41.47,53.89 43.28,53.89 43.36,53.98 43.36,54.12 43.27,54.22 42.63,54.22 42.55,54.3 v2(42.55,54.48)
  IN3 w0.089: v2(78.84,57.01) 78.46,57.4 77.31,57.4 76.92,57.01 76.23,57.01 74.59,55.37 74.59,55.19 74.38,54.98 74.28,54.98 74.13,55.13 74,55.13 73.9,55.03 73.9,54.93 74.05,54.77 74.05,54.65 73.59,54.19 72.17,54.19 72.05,54.07 67.58,54.07 67.12,53.61 66.58,53.61 64.46,51.49 61.73,51.49 61.64,51.4 60.69,51.4 60.54,51.24 60.54,50.44 60.46,50.37 60.34,50.37 60.26,50.44 60.26,50.96 60.18,51.04 60.04,51.04 59.96,50.96 59.96,50.36 59.88,50.29 59.77,50.29 59.7,50.36 59.7,50.91 59.62,50.99 59.51,50.99 59.43,50.91 59.43,50.36 59.35,50.29 59.24,50.29 59.16,50.36 59.16,50.91 59.08,50.99 58.97,50.99 58.9,50.91 58.9,50.36 58.82,50.29 58.71,50.29 58.63,50.36 58.63,50.91 58.55,50.99 58.44,50.99 58.36,50.91 58.36,50.36 58.28,50.29 58.17,50.29 58.1,50.36 58.1,50.91 58.02,50.99 57.91,50.99 57.83,50.91 57.83,50.36 57.75,50.29 57.64,50.29 57.56,50.36 57.56,50.99 57.48,51.07 57.34,51.07 57.27,50.99 57.27,49.97 57.18,49.88 57.07,49.88 57,49.95 57,51.32 56.92,51.4 56.81,51.4 56.73,51.32 56.73,50.78 56.66,50.71 56.55,50.71 56.47,50.79 56.47,51.32 56.39,51.4 56.28,51.4 56.2,51.32 56.2,50.71 56.12,50.64 56.01,50.64 55.93,50.71 55.93,51.32 55.85,51.4 55.74,51.4 55.67,51.32 55.67,50.7 55.59,50.63 55.48,50.63 55.4,50.71 55.4,51.32 55.32,51.4 55.21,51.4 55.13,51.32 55.13,50.77 55.05,50.7 54.94,50.7 54.87,50.77 54.87,51.32 54.79,51.4 54.68,51.4 54.6,51.32 54.6,50.83 54.52,50.76 54.41,50.76 54.33,50.83 54.33,51.32 54.25,51.4 50.62,51.4 50.33,51.69 50.33,51.78 50.43,51.88 50.43,52.01 50.34,52.1 50.22,52.1 50.12,52 50.02,52 49.23,52.79 48.66,52.79 46.57,54.88 46.31,54.88 46.24,54.96 46.24,55.06 46.16,55.14 46.05,55.14 45.97,55.06 45.97,54.96 45.89,54.88 45.78,54.88 45.7,54.96 45.7,55.06 45.62,55.14 45.51,55.14 45.44,55.06 45.44,54.96 45.36,54.88 45.25,54.88 45.17,54.96 45.17,55.06 45.09,55.14 44.98,55.14 44.9,55.06 44.9,54.96 44.82,54.88 44.71,54.88 44.63,54.96 44.63,55.06 44.56,55.14 44.45,55.14 44.37,55.06 44.37,54.96 44.29,54.88 44.18,54.88 44.1,54.96 44.1,55.06 44.02,55.14 43.91,55.14 43.83,55.06 43.83,54.96 43.76,54.88 43.41,54.88 43.27,54.74 42.81,54.74 v2(42.55,54.48)
  BOTTOM w0.114: v2(78.84,57.01) 79.15,56.64 U2030.AR37
M_B_DQ40: length 64.1
  TOP w0.102: v2(43.49,53.52) 43.78,53.81 43.78,54.55 44.29,55.07 44.29,55.87 U2011.D3
  IN3 w0.089: v2(43.49,53.52) 43.49,53.21 43.61,53.09 44.45,53.09 44.81,52.73 44.81,52.55 44.58,52.32 44.58,52.21 44.66,52.13 44.77,52.13 44.99,52.36 45.93,52.36 46.29,51.99 46.29,51.07 49.34,48.03 49.85,48.03 51.47,46.41 53.06,46.41 53.37,46.09 53.89,46.09 53.95,46.04 53.95,45.91 53.95,45.91 54.01,45.86 54.13,45.86 54.19,45.92 54.19,46.34 54.25,46.41 54.38,46.41 54.45,46.34 54.45,45.63 54.52,45.56 54.63,45.56 54.71,45.64 54.71,46.32 54.79,46.39 54.9,46.39 54.97,46.32 54.97,45.69 55.05,45.61 55.16,45.61 55.24,45.69 55.24,46.32 55.32,46.39 55.43,46.39 55.51,46.32 55.51,45.69 55.59,45.61 55.7,45.61 55.77,45.69 55.77,46.32 55.85,46.39 55.96,46.39 56.04,46.32 56.04,45.69 56.12,45.61 56.23,45.61 56.31,45.69 56.31,46.32 56.39,46.39 56.5,46.39 56.57,46.32 56.57,45.69 56.65,45.61 56.76,45.61 56.84,45.69 56.84,46.32 56.92,46.39 57.03,46.39 57.11,46.32 57.11,45.69 57.19,45.61 57.3,45.61 57.37,45.69 57.37,46.32 57.45,46.39 57.56,46.39 57.64,46.32 57.64,45.57 57.71,45.49 57.82,45.49 57.91,45.58 57.91,46.32 57.99,46.39 58.1,46.39 58.17,46.32 58.17,45.65 58.25,45.57 58.36,45.57 58.44,45.65 58.44,46.32 58.52,46.39 58.63,46.39 58.71,46.32 58.71,45.83 59.21,45.33 59.32,45.33 59.4,45.41 59.4,45.52 58.98,45.93 58.98,46.02 59.06,46.1 59.19,46.1 59.58,45.71 59.7,45.71 59.78,45.79 59.78,45.89 59.54,46.13 59.54,46.24 59.62,46.32 59.73,46.32 59.97,46.07 60.06,46.07 60.14,46.15 60.14,46.28 59.87,46.55 59.87,46.69 59.95,46.77 60.03,46.77 60.27,46.54 60.39,46.54 60.46,46.61 60.46,46.72 60.3,46.88 60.3,47.09 62.19,48.98 65.02,48.98 67.19,51.15 67.42,51.15 67.54,51.03 72.76,51.03 73.27,51.53 73.27,52.23 73.57,52.52 73.88,52.52 75.85,54.49 77,54.49 77.32,54.81 77.76,54.81 v2(78.2,55.25)
  BOTTOM w0.114: v2(78.2,55.25) U2030.AT33
M_B_DQ41: length 63.7
  TOP w0.102: U2011.C3 45.46,55.5 45.46,54.77 45.11,54.42 44.64,54.42 44.15,53.93 v2(44.15,53.58)
  IN3 w0.089: v2(77.55,55.25) 77.4,55.1 77.02,55.1 76.95,55.03 76.95,54.85 76.83,54.74 76.71,54.74 76.62,54.82 76.62,55.03 76.54,55.1 76.36,55.1 76.29,55.03 76.29,54.82 76.21,54.74 75.81,54.74 73.84,52.77 73.53,52.77 73.07,52.31 73.07,51.64 72.7,51.27 67.68,51.27 67.55,51.4 67.55,51.8 67.47,51.88 67.35,51.88 67.26,51.79 67.26,51.51 67.19,51.45 67.09,51.45 66.9,51.64 66.75,51.64 66.68,51.57 66.68,51.45 66.85,51.28 66.85,51.15 66.77,51.07 66.66,51.07 66.48,51.24 66.35,51.24 66.27,51.16 66.27,51.05 66.46,50.87 66.46,50.76 64.92,49.22 62.09,49.22 59.87,47 59.74,47 59.55,47.19 59.43,47.19 59.35,47.11 59.35,46.42 59.29,46.36 59.14,46.36 59.07,46.44 59.07,47.09 58.99,47.17 58.88,47.17 58.8,47.09 58.8,46.73 58.72,46.65 58.61,46.65 58.53,46.73 58.53,47.09 58.45,47.17 58.34,47.17 58.27,47.09 58.27,46.73 58.19,46.65 58.08,46.65 58,46.73 58,47.09 57.92,47.17 57.81,47.17 57.73,47.09 57.73,46.73 57.65,46.65 57.54,46.65 57.47,46.73 57.47,47.09 57.39,47.17 57.28,47.17 57.2,47.09 57.2,46.73 57.12,46.65 57.01,46.65 56.93,46.73 56.93,47.09 56.85,47.17 56.74,47.17 56.67,47.09 56.67,46.73 56.59,46.65 56.48,46.65 56.4,46.73 56.4,47.09 56.32,47.17 56.21,47.17 56.13,47.09 56.13,46.73 56.05,46.65 55.94,46.65 55.87,46.73 55.87,47.09 55.79,47.17 55.68,47.17 55.6,47.09 55.6,46.73 55.52,46.65 55.41,46.65 55.33,46.73 55.33,47.09 55.25,47.17 55.14,47.17 55.07,47.09 55.07,46.73 54.99,46.65 54.88,46.65 54.8,46.73 54.8,47.09 54.72,47.17 54.61,47.17 54.53,47.09 54.53,46.73 54.45,46.65 54.34,46.65 54.27,46.73 54.27,47.09 54.19,47.17 54.08,47.17 54,47.09 54,46.5 53.92,46.42 53.81,46.42 53.73,46.5 53.73,47.09 53.65,47.17 53.54,47.17 53.47,47.09 53.47,46.65 53.39,46.57 53.28,46.57 53.2,46.65 53.2,47.09 53.12,47.17 53.01,47.17 52.93,47.09 52.93,46.73 52.85,46.65 52.74,46.65 52.67,46.73 52.67,47.09 52.59,47.17 52.48,47.17 52.4,47.09 52.4,46.73 52.32,46.65 52.21,46.65 52.13,46.73 52.13,47.09 52.05,47.17 51.94,47.17 51.87,47.09 51.87,46.73 51.79,46.65 51.68,46.65 51.6,46.73 51.6,47.1 51.5,47.19 51.03,47.19 49.95,48.27 49.44,48.27 46.96,50.74 46.96,50.87 47.39,51.3 47.39,51.41 47.31,51.49 47.2,51.49 46.77,51.06 46.64,51.06 46.54,51.16 46.54,51.27 46.9,51.62 46.9,51.73 45.78,52.84 45.63,52.84 45.38,52.6 45.19,52.6 45.1,52.69 45.1,52.91 44.54,53.47 44.27,53.47 v2(44.15,53.58)
  BOTTOM w0.114: U2030.AU33 v2(77.55,55.25)
M_B_DQ42: length 62.7
  TOP w0.102: v2(45.05,50.44) 44.33,51.16 44.33,51.95 U2011.C8
  IN3 w0.089: v2(45.05,50.44) 45.26,50.23 45.26,48.98 47.89,46.35 48.17,46.07 48.17,45.35 50.82,42.7 50.94,42.7 51.02,42.78 51.02,42.93 50.89,43.06 50.89,43.22 51.07,43.4 51.22,43.4 51.29,43.33 51.29,42.97 51.36,42.89 51.48,42.89 51.55,42.97 51.55,43.47 51.63,43.54 51.74,43.54 51.84,43.44 51.84,42.99 51.93,42.9 52.08,42.9 52.15,42.97 52.15,43.51 52.23,43.59 52.34,43.59 52.42,43.51 52.42,42.93 52.48,42.87 52.59,42.87 52.68,42.96 52.68,43.52 52.76,43.6 52.87,43.6 52.95,43.52 52.95,43.07 53.01,43.01 53.12,43.01 53.22,43.1 53.22,43.47 53.29,43.55 53.4,43.55 53.48,43.47 53.48,43.33 53.56,43.25 53.67,43.25 53.75,43.33 53.75,43.48 53.81,43.54 53.92,43.54 54.02,43.45 54.02,43.33 54.09,43.25 54.58,43.25 54.99,42.84 58.53,42.84 62.56,46.87 62.56,47.62 62.65,47.7 62.79,47.7 62.85,47.64 62.85,46.92 62.95,46.81 63.05,46.81 63.13,46.89 63.13,47.63 63.22,47.71 63.33,47.71 63.4,47.64 63.4,46.89 63.48,46.81 63.59,46.81 63.67,46.89 63.67,47.42 63.76,47.51 63.87,47.51 63.93,47.45 63.93,46.89 64.01,46.81 64.12,46.81 64.2,46.89 64.2,47.42 64.3,47.52 64.41,47.52 64.47,47.47 64.47,46.99 64.53,46.92 64.65,46.92 64.8,47.06 64.8,47.69 64.89,47.79 65.03,47.79 65.1,47.72 65.1,47.57 65.16,47.51 65.25,47.51 66.22,48.49 67.45,48.49 68.08,49.12 68.21,49.12 68.28,49.2 68.28,49.57 68.36,49.65 68.47,49.65 68.55,49.57 68.55,49.2 68.63,49.12 68.74,49.12 68.82,49.2 68.82,49.57 68.9,49.65 69.01,49.65 69.08,49.57 69.08,49.2 69.16,49.12 69.27,49.12 69.35,49.2 69.35,49.57 69.43,49.65 69.54,49.65 69.62,49.57 69.62,49.2 69.7,49.12 69.81,49.12 69.88,49.2 69.88,49.57 69.96,49.65 70.07,49.65 70.15,49.57 70.15,49.2 70.23,49.12 70.34,49.12 70.42,49.2 70.42,49.57 70.5,49.65 70.61,49.65 70.68,49.57 70.68,49.2 70.76,49.12 70.87,49.12 70.95,49.2 70.95,49.57 71.03,49.65 71.14,49.65 71.22,49.57 71.22,49.2 71.3,49.12 71.41,49.12 71.48,49.2 71.48,49.57 71.56,49.65 71.67,49.65 71.75,49.57 71.75,49.2 71.83,49.12 71.92,49.12 72.02,49.22 72.02,49.55 72.12,49.64 72.45,49.64 72.91,50.1 72.91,50.21 73.55,50.85 74,50.85 74.62,51.48 74.62,51.78 75.94,53.1 76.65,53.1 77,53.45 v2(77.54,53.45)
  BOTTOM w0.114: v2(77.54,53.45) U2030.AU30
M_B_DQ43: length 63.4
  TOP w0.102: U2011.B8 v2(45.07,51.89)
  IN3 w0.079: 77.32,53.06 77.71,53.06 78.09,53.45 v2(78.19,53.45)
  IN3 w0.089: v2(45.07,51.89) 44.7,51.89 44.6,51.79 44.6,49.84 44.68,49.77 44.94,49.77 45.02,49.69 45.02,49.58 44.94,49.5 44.68,49.5 44.6,49.42 44.6,49.3 47.93,45.97 47.93,45.25 51.25,41.93 51.43,41.93 51.6,42.1 51.87,42.1 52.03,41.93 52.25,41.93 52.39,42.07 52.65,42.07 52.79,41.93 53.07,41.93 53.16,42.02 53.16,42.71 53.24,42.79 53.35,42.79 53.42,42.72 53.42,42.02 53.5,41.94 53.61,41.94 53.69,42.02 53.69,42.93 53.77,43.01 53.88,43.01 53.96,42.93 53.96,42.02 54.03,41.94 54.15,41.94 54.22,42.02 54.22,42.93 54.3,43.01 54.41,43.01 54.49,42.93 54.49,41.83 54.58,41.74 54.69,41.74 54.76,41.81 54.76,42.52 54.84,42.59 54.95,42.59 55.02,42.52 55.02,41.83 55.11,41.74 55.22,41.74 55.29,41.81 55.29,42.52 55.37,42.59 55.48,42.59 55.56,42.52 55.56,41.83 55.64,41.74 55.75,41.74 55.82,41.81 55.82,42.52 55.9,42.59 56.01,42.59 56.07,42.53 56.09,42.52 56.09,41.83 56.18,41.74 56.29,41.74 56.36,41.81 56.36,42.52 56.44,42.59 56.55,42.59 56.62,42.52 56.62,41.83 56.71,41.74 56.82,41.74 56.89,41.81 56.89,42.52 56.97,42.59 57.08,42.59 57.16,42.52 57.16,41.83 57.24,41.74 57.35,41.74 57.42,41.81 57.42,42.52 57.5,42.59 57.61,42.59 57.69,42.52 57.69,41.9 57.76,41.84 57.87,41.84 57.95,41.91 57.95,42.49 58.05,42.59 58.17,42.59 58.34,42.42 58.45,42.42 62.6,46.57 64.65,46.57 64.88,46.8 65.04,46.8 65.34,46.49 65.44,46.49 65.55,46.6 65.55,46.72 65.24,47.03 65.24,47.15 66.33,48.25 67.55,48.25 68.18,48.88 72.04,48.88 73.11,49.94 73.11,50.12 73.64,50.65 74.08,50.65 74.83,51.39 74.83,51.7 76.02,52.9 76.74,52.9 76.9,53.06 77.32,53.06
  BOTTOM w0.114: v2(78.19,53.45) 78.38,53.17 U2030.AT30
M_B_DQ44: length 64.8
  TOP w0.102: U2011.C2 45.05,56.71 45.05,56.25 45.85,55.44 45.85,54.53 45.31,53.98 v2(45.31,53.64)
  IN3 w0.079: 77.15,55.5 77.28,55.63 78.47,55.63 v2(78.85,55.25)
  IN3 w0.089: 77.15,55.5 77.03,55.38 76.05,55.38 73.7,53.03 73.48,53.03 72.66,52.21 66.91,52.21 65.89,51.19 65.89,51.08 66.01,50.96 66.1,50.87 66.1,50.76 66.02,50.69 65.91,50.69 65.7,50.89 65.59,50.89 65.51,50.81 65.51,50.7 65.72,50.5 65.72,50.39 65.64,50.31 65.53,50.31 65.32,50.51 65.21,50.51 65.14,50.44 65.14,50.33 65.24,50.22 65.34,50.12 65.34,50.01 65.25,49.92 65.14,49.92 64.8,50.26 64.68,50.26 64.6,50.18 64.6,50.08 64.95,49.73 64.95,49.62 64.85,49.52 64.73,49.52 64.63,49.62 64.45,49.62 64.3,49.46 61.99,49.46 59.96,47.43 51.13,47.43 50.45,48.11 50.45,48.24 50.92,48.7 50.92,48.81 50.83,48.9 50.72,48.9 50.25,48.43 50.14,48.43 50.05,48.51 50.05,48.67 50.5,49.11 50.5,49.22 50.41,49.31 50.3,49.31 49.6,48.62 49.43,48.62 49.35,48.7 49.35,48.81 50.07,49.54 50.07,49.65 50,49.73 49.89,49.73 49.16,49 49.05,49 48.97,49.07 48.97,49.19 49.7,49.92 49.7,50.02 49.63,50.1 49.5,50.1 48.78,49.37 48.67,49.37 48.59,49.45 48.59,49.56 48.94,49.91 48.94,50.01 48.86,50.08 48.74,50.08 48.4,49.75 48.29,49.75 48.19,49.85 48.19,49.96 48.5,50.27 48.5,50.38 48.42,50.46 48.31,50.46 48,50.15 47.89,50.15 47.82,50.23 47.82,50.34 48.53,51.05 48.53,51.14 48.45,51.22 48.32,51.22 47.63,50.53 47.52,50.53 47.43,50.62 47.43,50.78 48.13,51.48 48.13,51.6 47.86,51.87 47.73,51.87 47.53,51.67 47.46,51.67 47.35,51.79 47.35,51.93 47.49,52.07 47.49,52.18 47.41,52.26 47.3,52.26 47.06,52.02 46.95,52.02 46.87,52.1 46.87,52.21 47.11,52.45 47.11,52.56 47.04,52.64 46.93,52.64 46.68,52.4 46.57,52.4 46.49,52.47 46.49,52.59 46.74,52.83 46.74,52.94 46.66,53.02 46.55,53.02 46.31,52.77 46.2,52.77 46.12,52.85 46.12,52.96 46.36,53.21 46.36,53.32 46.28,53.39 46.17,53.39 45.87,53.1 45.3,53.1 44.94,53.45 44.94,53.55 45.03,53.64 v2(45.31,53.64)
  BOTTOM w0.114: v2(78.85,55.25) U2030.AR33
M_B_DQ45: length 65.6
  TOP w0.102: U2011.A3 46.27,54.15 45.95,53.83 v2(45.95,53.81)
  IN3 w0.079: 80.38,55.79 77.25,55.79 77.21,55.83
  IN3 w0.089: v2(79.5,55.25) 79.5,54.91 79.59,54.82 81.13,54.82 81.21,54.74 81.21,52.46 81.3,52.37 81.46,52.37 81.55,52.46 81.55,56.3 81.47,56.37 81.29,56.37 81.19,56.27 81.19,55.82 81.09,55.71 80.45,55.71 80.38,55.79 ; v2(45.95,53.81) 46.26,53.81 48.72,51.35 48.83,51.35 49,51.52 49.11,51.52 49.19,51.45 49.19,51.33 48.91,51.06 48.91,50.9 48.99,50.82 49.05,50.82 49.38,51.15 49.49,51.15 49.57,51.07 49.57,50.96 49.27,50.66 49.27,50.54 49.35,50.46 49.45,50.46 49.76,50.77 49.87,50.77 49.94,50.69 49.94,50.58 49.77,50.41 49.77,50.3 49.85,50.22 49.96,50.22 50.13,50.39 50.24,50.39 50.32,50.31 50.32,50.2 50.15,50.03 50.15,49.92 50.23,49.84 50.34,49.84 50.51,50.01 50.62,50.01 50.7,49.94 50.7,49.83 50.53,49.65 50.53,49.54 50.6,49.46 50.71,49.46 50.89,49.64 51,49.64 51.08,49.56 51.08,49.45 50.9,49.27 50.9,49.16 51.29,48.78 51.45,48.78 51.52,48.86 51.52,48.98 51.6,49.06 51.75,49.06 51.85,48.96 51.85,48.83 51.93,48.75 52.06,48.75 52.13,48.83 52.13,49.01 52.21,49.08 52.36,49.08 52.41,49.03 52.41,48.83 52.49,48.75 52.64,48.75 52.72,48.83 52.72,49.06 52.77,49.11 52.92,49.11 53,49.03 53,48.58 52.92,48.5 51.37,48.5 51.19,48.32 50.91,48.32 50.84,48.25 50.84,48.12 50.93,48.03 51.15,48.03 51.22,47.97 51.22,47.74 51.28,47.67 52.86,47.67 53.07,47.89 53.2,47.89 53.42,47.67 59.86,47.67 61.89,49.7 64.17,49.7 64.35,49.89 64.35,50.37 64.49,50.51 64.87,50.51 66.81,52.46 72.57,52.46 73.37,53.26 73.64,53.26 75.97,55.59 76.69,55.59 76.83,55.73 76.83,56.13 76.9,56.2 77.05,56.2 77.13,56.12 77.13,55.92 77.21,55.83
  BOTTOM w0.114: v2(79.5,55.25) U2030.AP33
M_B_DQ46: length 63.6
  TOP w0.102: U2011.C7 44.27,52.69 v2(44.27,52.64)
  IN3 w0.079: 77.48,52.85 77.72,52.85 77.93,53.06 78.78,53.06 78.84,53.12 v2(78.84,53.45)
  IN3 w0.089: 77.48,52.85 76.98,52.85 76.82,52.69 76.11,52.69 75.03,51.62 75.03,51.31 74.17,50.45 73.72,50.45 73.31,50.04 73.31,49.78 72.17,48.64 68.28,48.64 67.93,48.29 67.93,48.14 67.72,47.92 67.72,47.81 68.01,47.52 68.01,47.42 67.93,47.34 67.81,47.34 67.45,47.7 67.34,47.7 67.26,47.62 67.26,47.51 67.79,46.98 67.79,46.88 67.71,46.8 67.6,46.8 66.61,47.79 66.49,47.79 66.42,47.71 66.42,47.6 67.53,46.49 67.53,46.38 67.46,46.3 67.34,46.3 66.09,47.55 66,47.55 65.92,47.48 65.92,47.35 66.83,46.44 66.83,46.33 66.75,46.25 66.64,46.25 66.4,46.49 66.29,46.49 66.05,46.25 62.63,46.25 60.45,44.07 60.45,43.96 60.58,43.83 60.58,43.75 60.5,43.67 60.36,43.67 60.26,43.77 60.15,43.77 60.07,43.7 60.07,43.58 60.25,43.41 60.25,43.3 60.17,43.22 60.06,43.22 59.88,43.4 59.77,43.4 59.69,43.32 59.69,43.21 59.87,43.03 59.87,42.92 59.79,42.84 59.68,42.84 59.5,43.02 59.39,43.02 59.31,42.94 59.31,42.83 59.49,42.65 59.49,42.54 59.41,42.46 59.3,42.46 59.13,42.64 59.02,42.64 58.94,42.56 58.94,42.45 59.12,42.27 59.12,42.16 59.04,42.09 58.93,42.09 58.75,42.26 58.64,42.26 58.56,42.19 58.56,42.08 58.74,41.9 58.74,41.79 58.66,41.71 58.55,41.71 58.37,41.89 58.26,41.89 57.88,41.5 54.18,41.5 53.99,41.69 51.15,41.69 47.69,45.15 47.69,45.87 44.27,49.29 44.27,50.35 44.19,50.43 43.7,50.43 43.64,50.49 43.64,50.6 43.74,50.7 44.19,50.7 44.27,50.77 44.27,50.88 44.19,50.96 43.96,50.96 43.88,51.04 43.88,51.15 43.96,51.23 44.19,51.23 44.27,51.31 44.27,51.42 44.19,51.5 43.92,51.5 43.84,51.57 43.84,51.68 43.92,51.76 44.19,51.76 44.27,51.84 44.27,51.95 44.19,52.03 43.88,52.03 43.81,52.11 43.81,52.22 43.88,52.3 44.19,52.3 44.27,52.37 44.27,52.64 v2(44.27,52.64)
  BOTTOM w0.114: v2(78.84,53.45) 79.03,53.17 U2030.AR30
M_B_DQ47: length 64.6
  TOP w0.102: v2(43.47,52.64) 43.47,52.69 U2011.D7
  IN3 w0.079: v2(79.49,53.45) 79.49,53.25 79.56,53.18 79.83,53.18 79.92,53.09 79.92,52.97 79.85,52.91 78,52.91 77.74,52.65 77.48,52.65
  IN3 w0.089: v2(43.47,52.64) 43.21,52.64 43.11,52.74 43.11,53 43.04,53.07 42.4,53.07 42.28,52.95 42.28,51.93 42.41,51.8 42.68,51.8 42.78,51.9 42.78,52.24 42.85,52.32 42.98,52.32 43.06,52.24 43.06,50.73 43.62,50.18 43.95,50.18 44.03,50.1 44.03,49.19 45.37,47.85 45.37,47.74 45.11,47.49 45.11,47.37 45.19,47.3 45.3,47.3 45.55,47.55 45.67,47.55 45.74,47.47 45.74,47.36 45.49,47.11 45.49,47 45.57,46.92 45.68,46.92 45.93,47.17 46.04,47.17 46.12,47.09 46.12,46.98 45.87,46.73 45.87,46.62 45.95,46.54 46.06,46.54 46.31,46.8 46.42,46.8 47.45,45.77 47.45,45.04 50.76,41.72 51.03,41.45 53.89,41.45 54.08,41.26 58.62,41.26 60.86,43.5 60.86,44.14 62.73,46.01 67.84,46.01 67.91,46.07 67.91,46.19 67.8,46.29 67.8,46.44 67.88,46.52 67.98,46.52 68.39,46.11 68.51,46.11 68.62,46.21 68.62,46.39 68.03,46.98 68.03,47.1 68.11,47.18 68.26,47.18 68.88,46.56 68.96,46.56 69.05,46.65 69.05,46.76 68.42,47.39 68.42,47.49 68.5,47.57 68.63,47.57 69.24,46.95 69.35,46.95 69.43,47.03 69.43,47.14 68.85,47.72 68.85,47.84 68.93,47.92 69.02,47.92 69.62,47.33 69.73,47.33 69.81,47.41 69.81,47.52 69.61,47.72 69.61,47.8 69.67,47.86 69.84,47.86 70,47.71 70.11,47.71 70.23,47.83 72.43,47.83 72.64,48.04 72.64,48.79 73.51,49.66 73.51,49.95 73.81,50.25 74.27,50.25 75.23,51.2 75.23,51.53 76.19,52.49 76.91,52.49 77.06,52.65 77.48,52.65
  BOTTOM w0.114: U2030.AP30 79.67,53.18 v2(79.49,53.45)
M_B_DQ48: length 62.6
  TOP w0.102: U2012.H3 41.05,43.46 41.74,43.46 41.92,43.64 41.92,44.08 42.17,44.33 42.56,44.33 42.71,44.47 42.71,44.8 43.06,45.15 43.53,45.15 v2(43.7,45.32)
  IN3 w0.089: v2(77.55,51.59) 77.23,51.59 76.92,51.28 76.82,51.28 76.54,51.56 76.42,51.56 76.05,51.19 76.05,50.43 74.82,49.2 74.82,48.41 73.82,47.4 73.6,47.4 71.75,45.55 71.02,45.55 70.25,44.79 63.23,44.79 62.08,43.64 62.08,42.99 58.3,39.22 58.3,39.03 58.23,38.95 58.1,38.95 58.02,39.03 58.02,39.33 57.97,39.38 57.84,39.38 57.76,39.3 57.76,38.98 57.68,38.9 57.57,38.9 57.49,38.98 57.49,39.3 57.42,39.38 55,39.38 54.65,39.03 54.65,38.72 54.53,38.61 54.41,38.61 54.32,38.7 54.32,38.9 54.24,38.98 54.06,38.98 53.98,38.9 53.98,38.67 53.9,38.59 53.79,38.59 53.71,38.67 53.71,38.9 53.63,38.98 51.27,38.98 51.14,38.85 51.14,38.66 51.07,38.58 50.57,38.58 47.71,41.44 47.71,41.55 47.84,41.68 47.84,41.79 47.77,41.87 47.65,41.87 47.52,41.74 47.41,41.74 47.34,41.82 47.34,41.93 48.02,42.62 48.02,42.73 47.95,42.8 47.84,42.8 47.15,42.12 47.04,42.12 46.96,42.19 46.96,42.3 47.65,42.99 47.65,43.1 47.57,43.18 47.46,43.18 46.77,42.49 46.66,42.49 46.44,42.71 46.44,42.89 46.59,43.04 46.88,43.04 47.25,43.4 47.25,43.51 46.7,44.06 46.59,44.06 46.28,43.74 46.17,43.74 46.09,43.82 46.09,43.93 46.4,44.25 46.4,44.36 45.91,44.85 45.8,44.85 45.5,44.55 45.39,44.55 45.31,44.63 45.31,44.74 45.61,45.04 45.61,45.15 45.53,45.23 45.42,45.23 44.54,44.34 44.43,44.34 44.35,44.42 44.35,44.53 45.23,45.42 45.23,45.53 45.11,45.66 44.91,45.66 44.73,45.48 43.85,45.48 v2(43.7,45.32)
  BOTTOM w0.114: U2030.AU27 v2(77.55,51.59)
M_B_DQ49: length 63.7
  TOP w0.102: U2012.J3 40.25,43.47 40.25,45.57 40.67,45.98 40.67,46.4 41.1,46.83 43.6,46.83 44.03,46.4 v2(44.03,45.97)
  IN3 w0.079: v2(78.2,51.59) 78.11,51.59 77.68,52.02 77.38,52.02
  IN3 w0.089: v2(44.03,45.97) 44.27,45.97 44.35,46.06 44.35,46.32 44.42,46.39 44.63,46.39 44.72,46.31 44.72,46.01 44.82,45.91 45.19,45.91 46.3,44.8 48.41,42.69 48.41,42.58 47.96,42.14 47.96,42.03 48.04,41.95 48.15,41.95 48.6,42.4 48.71,42.4 48.79,42.32 48.79,42.21 48.09,41.51 48.09,41.42 48.16,41.34 48.3,41.34 48.97,42.02 49.08,42.02 49.16,41.94 49.16,41.83 48.7,41.36 48.46,41.13 48.46,41.04 48.54,40.97 48.68,40.97 49.35,41.64 49.46,41.64 49.54,41.56 49.54,41.45 49.45,41.36 48.87,40.78 48.87,40.67 48.94,40.59 49.05,40.59 49.73,41.26 49.84,41.26 49.92,41.19 49.92,41.07 49.22,40.37 49.22,40.29 49.3,40.21 49.43,40.21 49.67,40.45 49.78,40.45 49.86,40.38 49.86,40.27 49.62,40.02 49.62,39.91 50.33,39.2 50.51,39.2 50.61,39.1 50.61,38.92 50.67,38.86 50.82,38.86 50.89,38.92 50.89,39.1 51,39.22 54.46,39.22 54.86,39.62 58.37,39.62 61.83,43.09 61.83,43.74 63.13,45.03 70.15,45.03 70.97,45.85 71.69,45.85 73.54,47.7 73.83,47.7 74.31,48.19 74.31,48.39 74.13,48.58 74.13,48.7 74.22,48.79 74.32,48.79 74.42,48.69 74.55,48.69 74.62,48.76 74.62,49.29 75.84,50.51 75.84,51.28 76.37,51.8 77.08,51.8 77.3,52.02 77.38,52.02
  BOTTOM w0.114: U2030.AT27 v2(78.2,51.59)
M_B_DQ50: length 61.8
  TOP w0.102: U2012.H7 40.67,40.12 41.57,41.02 43.77,41.02 43.78,41.02 44.5,41.02 44.83,40.69 45.72,40.69 v2(45.91,40.88)
  IN3 w0.089: v2(45.91,40.88) 46.19,40.88 46.26,40.8 46.26,40.7 46.14,40.57 46.14,40.45 46.24,40.35 46.41,40.35 46.54,40.47 46.65,40.47 46.72,40.39 46.72,40.28 46.57,40.13 46.57,40.02 46.65,39.94 46.76,39.94 46.91,40.1 47.02,40.1 47.1,40.02 47.1,39.91 46.95,39.75 46.95,39.66 47.02,39.59 47.16,39.59 47.29,39.72 47.4,39.72 47.48,39.64 47.48,39.53 47.37,39.42 47.37,39.34 47.45,39.26 47.59,39.26 47.67,39.34 47.78,39.34 47.86,39.26 47.86,39.15 47.73,39.02 47.73,38.91 47.8,38.83 47.91,38.83 48.05,38.96 48.16,38.96 48.4,38.72 48.4,38.53 47.55,37.68 47.55,37.53 47.62,37.45 47.74,37.45 48.63,38.34 48.78,38.34 48.88,38.24 48.88,38.14 48.07,37.32 48.07,37.18 48.14,37.11 48.31,37.11 49.08,37.88 49.24,37.88 49.35,37.77 49.35,37.62 49.01,37.27 49.01,37.19 49.09,37.11 49.31,37.11 49.53,37.32 49.67,37.32 49.88,37.11 55.2,37.11 55.47,36.84 59.12,36.84 59.88,36.08 60.12,36.08 60.22,36.17 60.22,36.31 59.76,36.77 59.76,36.9 59.85,36.99 59.96,36.99 60.44,36.5 60.55,36.5 60.64,36.6 60.64,36.74 60.18,37.2 60.18,37.32 60.27,37.41 60.4,37.41 60.56,37.25 60.65,37.25 60.78,37.37 60.78,37.49 60.62,37.65 60.62,37.76 61.78,38.92 61.78,39.75 62.79,40.75 62.79,41.67 63.37,42.25 71.22,42.25 72.15,43.18 72.15,44.58 75.64,48.08 75.64,48.87 76.28,49.51 77.67,49.51 77.79,49.62 77.79,50.05 77.89,50.15 78.4,50.15 78.48,50.24 78.48,50.38 v2(78.2,50.66)
  BOTTOM w0.114: U2030.AT25 v2(78.2,50.66)
M_B_DQ51: length 61.3
  TOP w0.102: U2012.J7 39.97,39.88 41.31,41.22 43.6,41.22 43.6,41.23 44.79,41.23 44.88,41.13 v2(45.29,41.13)
  IN3 w0.089: v2(77.55,50.66) 77.55,49.84 77.45,49.74 77.29,49.74 77.2,49.82 77.2,50.07 77.14,50.14 76.99,50.14 76.92,50.07 76.92,49.82 76.82,49.72 76.69,49.72 76.52,49.9 76.38,49.9 75.44,48.95 75.44,48.16 71.59,44.31 71.59,44.18 71.91,43.86 71.91,43.78 71.82,43.69 71.72,43.69 71.35,44.06 71.21,44.06 71.11,43.95 71.11,43.87 71.72,43.25 71.72,43.1 71.65,43.02 71.54,43.02 70.92,43.64 70.8,43.64 70.72,43.57 70.72,43.47 71.35,42.84 71.35,42.73 71.27,42.65 71.16,42.65 70.55,43.26 70.41,43.26 70.32,43.17 70.32,43.04 70.65,42.71 70.65,42.59 70.55,42.49 63.27,42.49 62.55,41.77 62.55,40.85 61.54,39.85 61.54,39.17 61.45,39.08 61.36,39.08 61.21,39.23 61.07,39.23 60.99,39.14 60.99,39.01 61.18,38.82 61.18,38.66 60.31,37.79 59.94,37.79 59.83,37.68 59.83,37.31 59.71,37.19 59.59,37.19 59.51,37.26 59.51,37.83 59.43,37.91 59.32,37.91 59.24,37.83 59.24,37.16 59.16,37.08 59.05,37.08 58.97,37.16 58.97,37.61 58.9,37.69 58.79,37.69 58.71,37.61 58.71,37.16 58.63,37.08 58.52,37.08 58.44,37.16 58.44,37.61 58.36,37.69 58.25,37.69 58.17,37.61 58.17,37.16 58.1,37.08 57.99,37.08 57.91,37.16 57.91,37.61 57.83,37.69 57.72,37.69 57.64,37.61 57.64,37.16 57.56,37.08 57.45,37.08 57.37,37.16 57.37,37.61 57.3,37.69 57.19,37.69 57.09,37.6 57.09,37.17 57,37.08 56.66,37.08 56.58,37.16 56.58,37.29 56.5,37.37 56.39,37.37 56.31,37.29 56.31,37.16 56.24,37.08 55.57,37.08 55.3,37.35 50.11,37.35 46.16,41.3 45.46,41.3 v2(45.29,41.13)
  BOTTOM w0.114: U2030.AU25 v2(77.55,50.66)
M_B_DQ52: length 63.4
  TOP w0.102: v2(43.4,46.2) 43.1,46.2 41.85,44.95 41.85,44.59 41.47,44.21 U2012.G2
  IN3 w0.079: v2(79.5,51.59) 79.5,51.91 79.43,51.98 77.95,51.98 77.69,52.24 77.43,52.24
  IN3 w0.089: 77.43,52.24 77.23,52.24 77.05,52.06 76.33,52.06 75.64,51.36 75.64,51 75.53,50.89 75.53,50.77 75.6,50.7 75.6,50.56 75.51,50.47 75.4,50.47 75.31,50.56 75.2,50.56 75.12,50.48 75.12,50.37 75.21,50.28 75.21,50.17 75.13,50.09 75.02,50.09 74.93,50.19 74.82,50.19 74.74,50.11 74.74,50 74.84,49.91 74.84,49.79 74,48.96 73.78,48.96 73.39,48.57 73.39,47.94 71.58,46.13 70.9,46.13 70.05,45.27 63.03,45.27 61.59,43.84 61.59,43.19 58.27,39.86 57.52,39.86 57.36,40.02 57.36,40.42 57.26,40.52 54.57,40.52 54.47,40.42 54.47,39.66 54.39,39.58 54.27,39.58 54.19,39.66 54.19,40.35 54.1,40.44 53.97,40.44 53.88,40.35 53.88,39.53 53.81,39.46 53.67,39.46 53.59,39.54 53.59,39.99 53.51,40.07 53.4,40.07 53.33,39.99 53.33,39.54 53.25,39.46 53.14,39.46 53.06,39.54 53.06,39.96 52.98,40.04 52.87,40.04 52.79,39.96 52.79,39.54 52.71,39.46 52.6,39.46 52.53,39.54 52.53,40.01 52.45,40.09 52.34,40.09 52.26,40.01 52.26,39.54 52.18,39.46 52.07,39.46 51.99,39.54 51.99,40.01 51.91,40.09 51.8,40.09 51.73,40.01 51.73,39.54 51.65,39.46 51.27,39.46 51.16,39.56 51.16,39.7 51.4,39.94 51.4,40.05 51.32,40.12 51.21,40.12 50.57,39.48 50.48,39.48 50.4,39.56 50.4,39.7 51.02,40.31 51.02,40.42 50.94,40.5 50.83,40.5 50.16,39.83 50.05,39.83 49.98,39.91 49.98,40.02 50.64,40.69 50.64,40.8 50.56,40.88 50.45,40.88 50.14,40.57 50.03,40.57 49.95,40.65 49.95,40.76 50.27,41.07 50.27,41.18 46.89,44.56 44.81,46.64 44.05,46.64 43.61,46.2 v2(43.4,46.2)
  BOTTOM w0.114: U2030.AP27 v2(79.5,51.59)
M_B_DQ53: length 64
  TOP w0.102: U2012.H2 41.06,44.27 41.06,45.26 41.96,46.16 v2(41.96,46.23)
  IN3 w0.079: v2(80.15,51.59) 79.61,52.13 78.02,52.13 77.71,52.44 77.46,52.44
  IN3 w0.089: v2(41.96,46.23) 41.59,46.6 41.59,46.87 41.69,46.98 42.2,46.98 42.28,46.9 42.28,46.72 42.34,46.66 42.47,46.66 42.53,46.72 42.53,46.9 42.61,46.98 42.81,46.98 42.89,46.9 42.89,46.75 42.97,46.67 43.08,46.67 43.16,46.75 43.16,46.9 43.24,46.98 43.35,46.98 43.43,46.9 43.43,46.72 43.5,46.65 43.61,46.65 43.69,46.72 43.69,46.9 43.77,46.98 44.81,46.98 47.47,44.32 47.47,44.32 50.83,40.96 53.68,40.96 53.87,40.77 57.54,40.77 57.61,40.69 57.61,40.2 57.69,40.12 57.8,40.12 57.88,40.2 57.88,40.69 57.96,40.77 58.1,40.77 58.18,40.69 58.18,40.45 58.28,40.35 58.41,40.35 58.48,40.42 58.48,40.68 58.57,40.77 58.83,40.77 61.35,43.29 61.35,43.94 62.93,45.52 68.71,45.52 68.97,45.78 69.11,45.78 69.38,45.52 69.48,45.52 69.56,45.59 69.56,45.71 69.28,45.99 69.28,46.13 69.37,46.21 69.51,46.21 70,45.72 70.16,45.72 70.22,45.79 70.22,45.9 69.69,46.44 69.69,46.56 69.76,46.64 69.86,46.64 70.41,46.09 70.52,46.09 70.6,46.16 70.6,46.27 70.06,46.82 70.06,46.95 70.14,47.02 70.23,47.02 70.87,46.39 71,46.39 71.08,46.47 71.08,46.55 70.48,47.15 70.48,47.24 70.56,47.32 70.69,47.32 71.5,46.51 71.61,46.51 71.69,46.59 71.69,46.69 71.11,47.27 71.11,47.37 71.17,47.43 71.33,47.43 71.84,46.93 71.99,46.93 72.1,47.03 72.1,47.13 71.94,47.28 71.94,47.38 72.02,47.46 72.17,47.46 72.32,47.31 72.45,47.31 73.09,47.94 73.09,48.73 73.67,49.31 74.07,49.31 74.38,49.62 74.38,50.07 75.44,51.13 75.44,51.45 76.28,52.29 76.99,52.29 77.15,52.44 77.46,52.44
  BOTTOM w0.114: U2030.AN27 v2(80.15,51.59)
M_B_DQ54: length 63.9
  TOP w0.102: U2012.F7 42.6,40.21 45.03,40.21 v2(45.08,40.26)
  IN3 w0.089: v2(45.08,40.26) 45.58,39.76 45.58,39.17 45.35,38.94 45.35,38.26 45.43,38.19 45.58,38.19 45.65,38.26 45.65,38.54 45.73,38.62 45.88,38.62 45.96,38.54 45.96,38.31 46.04,38.24 46.82,38.24 47.05,38.02 47.05,37.53 46.94,37.43 46.47,37.43 46.39,37.35 46.39,37.18 46.48,37.1 47.1,37.1 47.57,36.63 55,36.63 55.27,36.36 58.66,36.36 59.42,35.6 60.32,35.6 61.26,36.53 61.26,37.72 62.27,38.73 62.27,39.55 63.61,40.89 65.99,40.89 66.15,41.06 66.15,41.63 66.25,41.73 66.37,41.73 66.46,41.64 66.46,40.98 66.53,40.91 66.67,40.91 66.76,40.99 66.76,41.54 66.88,41.65 71.31,41.65 72.63,42.98 72.63,44.38 73.93,45.68 74.08,45.68 74.38,45.38 74.54,45.38 74.88,45.72 74.88,46.09 74.71,46.25 74.71,46.43 76.05,47.76 76.05,48.7 76.37,49.02 79.79,49.02 79.89,48.92 79.89,48.55 80,48.45 80.12,48.45 80.2,48.53 80.2,49.29 80.28,49.36 80.4,49.36 80.49,49.27 80.49,47.83 80.57,47.75 80.72,47.75 80.78,47.81 80.78,48.32 80.91,48.45 81.18,48.45 81.27,48.53 81.27,50 80.99,50.28 80.2,50.28 79.74,49.82 79.61,49.82 79.51,49.92 79.51,50.02 v2(80.16,50.66)
  BOTTOM w0.114: U2030.AN25 v2(80.16,50.66)
