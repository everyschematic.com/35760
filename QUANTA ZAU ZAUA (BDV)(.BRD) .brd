# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ35: length 25.5
  IN1 w0.152: v2(135.41,108.61) 135.02,108.21 125.56,108.21 123.35,106.01 117.37,106.01 115.97,104.61 114.39,104.61 114.29,104.51 113.32,104.51 v2(112.92,104.11)
  BOTTOM w0.165: v2(112.92,104.11) 112.53,104.5 U8.R23 ; v2(135.41,108.61) 135.81,108.21 VRAM2.M11
VMA_DQ36: length 25.1
  IN1 w0.152: v2(136.21,106.16) 135.32,107.04 126.72,107.04 125.23,105.55 117.56,105.55 116.56,104.55 v2(116.56,104.38)
  BOTTOM w0.127: v2(116.56,104.38) 116.56,104.04 116.12,103.6 115.61,103.6 115.38,103.36 114.9,103.36 114.43,102.89 U8.N25
  BOTTOM w0.165: v2(136.21,106.16) 136.61,106.55 VRAM2.N13
VMA_DQ37: length 22.9
  IN1 w0.152: v2(135.41,106.16) 134.98,106.59 126.98,106.59 125.49,105.09 117.76,105.09 v2(117.32,104.65)
  BOTTOM w0.127: U8.N26 115.15,103.11 115.45,103.11 115.71,103.37 116.22,103.37 117.32,104.47 v2(117.32,104.65)
  BOTTOM w0.165: VRAM2.M13 135.81,106.55 v2(135.41,106.16)
VMA_DQ38: length 35.3
  IN1 w0.102: 113.35,102.25 113.35,102.6 112.92,103.03 v2(112.92,103.28)
  IN1 w0.152: v2(139.41,107.81) 140.64,106.57 140.64,103.75 139.6,102.7 134.17,102.7 133.71,102.25 119.21,102.25 118.6,101.63 113.96,101.63 113.35,102.25
  BOTTOM w0.165: VRAM2.T11 139.02,108.2 v2(139.41,107.81) ; v2(112.92,103.28) U8.N23
VMA_DQ39: length 29.9
  IN1 w0.102: 115.11,102.14 114.95,102.29 114.95,102.83 114.46,103.33 v2(113.74,103.33)
  IN1 w0.152: v2(139.41,106.21) 139.13,105.92 139.13,104.9 137.85,103.62 133.79,103.62 133.34,103.16 118.58,103.16 117.56,102.14 115.11,102.14
  BOTTOM w0.165: v2(139.41,106.21) 139.02,106.6 VRAM2.T13 ; v2(113.74,103.33) 113.33,102.92 U8.N24
VMA_DQ40: length 27.7
  IN1 w0.102: v2(135.41,113.4) 134.99,112.98 134.99,112.25
  IN1 w0.152: 134.99,112.25 134.92,112.18 124.41,112.18 123.2,110.97 121.09,110.97 118.64,108.52 116.5,108.52 115.36,107.38 114.49,107.38 114.02,107.86 112.52,107.86 v2(112.11,107.45)
  BOTTOM w0.165: v2(135.41,113.4) 135.41,113.41 135.81,113.8 VRAM2.M4 ; U8.V23 112.51,107.05 v2(112.11,107.45)
VMA_DQ41: length 32.2
  IN1 w0.102: 137.41,113.08 137.41,113.8 v2(137.01,114.21)
  IN1 w0.152: v2(111.29,106.63) 111.6,106.63 112.02,106.22 112.26,106.22 113.09,107.04 114.11,107.04 114.23,106.93 115.55,106.93 116.69,108.07 118.83,108.07 121.28,110.51 123.39,110.51 124.6,111.72 136.87,111.72 137.48,112.33 137.48,113.02 137.41,113.08
  BOTTOM w0.165: VRAM2.N4 136.61,113.8 v2(137.01,114.21) ; v2(111.29,106.63) 111.69,107.03 U8.V22
VMA_DQ42: length 31.9
  IN1 w0.152: v2(112.93,104.97) 113.36,105.4 115.4,105.4 117.15,107.15 119.21,107.15 121.66,109.6 123.77,109.6 124.98,110.81 137.61,110.81 v2(140.21,113.41)
  BOTTOM w0.165: v2(140.21,113.41) 139.82,113.8 VRAM2.U4 ; v2(112.93,104.97) U8.T23
VMA_DQ43: length 31.6
  IN1 w0.152: v2(112.11,105.79) 112.34,105.79 112.76,106.22 115.57,106.22 116.96,107.61 119.02,107.61 121.47,110.06 123.58,110.06 124.79,111.26 137.27,111.26 v2(139.41,113.41)
  BOTTOM w0.165: U8.U22 v2(112.11,105.79) ; v2(139.41,113.41) 139.02,113.8 VRAM2.T4
VMA_DQ44: length 29.6
  IN1 w0.102: 136.61,116.8 136.61,116.2 v2(137.01,115.81)
  IN1 w0.152: v2(113.75,109.11) 114.15,109.51 114.69,109.51 114.96,109.78 114.96,110.75 116.38,112.18 119.49,112.18 120.27,112.95 121.63,112.95 126.26,117.59 132.65,117.59 133.24,117 136.42,117 136.61,116.8
  BOTTOM w0.165: VRAM2.N2 136.61,115.4 v2(137.01,115.81) ; U8.Y24 v2(113.75,109.11)
VMA_DQ45: length 32.3
  IN1 w0.152: v2(112.93,109.93) 113,109.93 113.42,110.34 113.9,110.34 116.19,112.63 118.68,112.63 119.46,113.41 121.44,113.41 126.07,118.05 133.08,118.05 133.67,117.45 138.37,117.45 139.08,116.74 139.08,116.4 138.61,115.93 v2(138.61,115.81)
  BOTTOM w0.165: v2(112.93,109.93) U8.AA24 ; VRAM2.T2 138.61,115.8 v2(138.61,115.81)
VMA_DQ46: length 30
  IN1 w0.152: v2(136.21,115.81) 135.7,116.32 133.41,116.32 133.27,116.17 132.03,116.17 131.13,117.08 126.4,117.08 121.82,112.5 120.46,112.5 119.13,111.16 116.02,111.16 115.42,110.56 115.42,109.75 114.74,109.08 114.37,109.08 113.99,108.7 112.58,108.7 112.16,108.27 v2(112.11,108.27)
  BOTTOM w0.165: v2(112.11,108.27) U8.Y22 ; v2(136.21,115.81) 135.81,115.41 VRAM2.M2
VMA_DQ47: length 34.8
  IN1 w0.152: v2(112.9,109.16) 112.47,109.59 112.47,110.14 113.76,111.43 114.34,111.43 116,113.09 118.49,113.09 119.27,113.87 121.25,113.87 125.88,118.5 133.39,118.5 133.98,117.91 138.68,117.91 139.63,116.95 139.63,116.03 v2(139.41,115.81)
  BOTTOM w0.165: VRAM2.U2 139.41,115.8 v2(139.41,115.81) ; U8.AA23 v2(112.9,109.16)
VMA_DQ48: length 19.8
  TOP w0.165: v2(130.61,115.8) 130.68,115.87 130.68,117.02 129.94,117.75 127.83,117.75 127.67,117.91 125.4,117.91 v1(124.54,117.06) 120.85,113.37 118.25,113.37 v2(118.12,113.5)
  BOTTOM w0.165: v2(118.12,113.5) 118.12,113.3 116.95,112.13 116.27,112.13 116.17,112.03 U8.AD27 ; VRAM2.F2 130.61,115.8 v2(130.61,115.8)
VMA_DQ49: length 18.8
  TOP w0.165: v2(113.73,109.93) 113.73,110.1 114.23,110.6 114.62,110.6 116.39,112.38 117.2,112.38 117.35,112.53 121.33,112.53 v1(124.31,115.52) 125.87,117.08 126.75,117.08 127.41,116.42 v2(127.41,115.88)
  BOTTOM w0.165: VRAM2.B2 127.81,115.48 v2(127.41,115.88) ; v2(113.73,109.93) U8.AB25
VMA_DQ50: length 20.6
  TOP w0.165: v2(116.95,113.52) 116.95,113.35 117.35,112.95 121.09,112.95 v1(122.9,114.76) 125.63,117.5 127.29,117.5 127.6,117.19 129.92,117.19 130.26,116.84 130.26,116.24 v2(129.83,115.8)
  BOTTOM w0.165: U8.AD26 115.34,112.44 116.13,112.44 116.27,112.59 116.6,112.59 116.95,112.94 v2(116.95,113.52) ; VRAM2.E2 130.21,115.43 v2(129.83,115.8)
VMA_DQ51: length 15.5
  TOP w0.165: v2(117.03,111.62) 117.52,112.11 121.56,112.11 v1(122.73,113.28) 125.35,115.9 126.39,115.9 v2(126.45,115.96)
  BOTTOM w0.165: U8.AC25 114.58,110.73 115.03,110.73 115.36,111.06 116.6,111.06 117.03,111.49 v2(117.03,111.62) ; v2(126.45,115.96) VRAM2.A2
VMA_DQ52: length 14.2
  TOP w0.165: v2(116.52,110.22) 116.99,110.69 122.13,110.69 v1(123.6,112.16) 125.28,113.83 126.98,113.83 v2(127.42,113.4)
  BOTTOM w0.165: v2(116.52,110.22) 116.42,110.22 U8.AA27 ; VRAM2.B4 127.42,113.41 v2(127.42,113.4)
VMA_DQ53: length 14.6
  TOP w0.165: v2(117.77,110.22) 118.27,109.71 121.81,109.71 v1(124.88,112.78) 125.5,113.4 126.57,113.4 v2(126.58,113.4)
  BOTTOM w0.127: 116.15,109.45 115.88,109.17 115.56,109.17 115.2,109.53 U8.AA26
  BOTTOM w0.165: 116.15,109.45 116.99,109.45 v2(117.77,110.22) ; v2(126.58,113.4) 126.58,113.42 126.96,113.8 VRAM2.A4
VMA_DQ54: length 17.8
  TOP w0.165: v2(129.83,113.4) 129.61,113.4 128.92,112.7 125.46,112.7 v1(123.62,110.87) 121.96,109.21 117.74,109.21 v2(117.49,108.96)
  BOTTOM w0.102: v2(117.49,108.96) 116.75,108.22 115.3,108.22 U8.W26
  BOTTOM w0.165: v2(129.83,113.4) 130.21,113.77 VRAM2.E4
VMA_DQ55: length 19.6
  TOP w0.165: v2(130.61,113.4) 130.6,113.4 129.49,112.28 125.69,112.28 v1(124.83,111.42) 121.85,108.44 116.73,108.44 v2(116.22,108.96)
  BOTTOM w0.127: v2(116.22,108.96) 116.11,108.84 115.46,108.84 115.25,109.05 114.49,109.05 U8.Y25
  BOTTOM w0.165: VRAM2.F4 130.61,113.4 v2(130.61,113.4)
VMA_DQ56: length 13.9
  BOTTOM w0.165: VRAM2.B13 127.42,106.21 126.65,106.21 125.93,105.48 v1(122.26,105.48) 119.18,105.48 119.1,105.4 118.39,105.4 118.2,105.6 116.49,105.6 115.84,104.94 115.57,104.94 115.2,104.57 U8.R26
VMA_DQ57: length 14.1
  BOTTOM w0.165: U8.T25 114.53,104.97 115.06,104.97 115.3,105.21 115.3,105.68 115.49,105.87 116.23,105.87 116.35,105.98 118.21,105.98 118.37,105.82 118.85,105.82 119.06,106.03 v1(121.09,106.03) 125.87,106.03 126.44,106.6 VRAM2.A13
VMA_DQ58: length 17.6
  BOTTOM w0.127: U8.N27 115.88,103.04 117.21,103.04
  BOTTOM w0.165: VRAM2.F13 130.62,106.21 130.62,105.52 130.74,105.4 130.74,105.14 130.15,104.55 127.36,104.55 127.19,104.38 v1(120.97,104.38) 119.27,104.38 118.97,104.08 118.25,104.08 117.21,103.04
VMA_DQ59: length 16
  BOTTOM w0.165: VRAM2.E13 129.81,106.2 129.81,105.47 129.3,104.97 v1(123.51,104.97) 118.41,104.97 118.05,105.33 116.6,105.33 115.84,104.57 U8.R27
VMA_DQ60: length 13.2
  BOTTOM w0.165: VRAM2.A11 126.64,108.57 v1(120.33,108.57) 119.5,108.57 117.71,106.78 116,106.78 115.9,106.68 115.5,106.68 115.12,107.05 U8.V26
VMA_DQ61: length 14
  BOTTOM w0.165: VRAM2.B11 127.42,108.59 127.42,109.29 127.25,109.46 v1(123.12,109.46) 119.8,109.46 117.39,107.05 U8.V27
VMA_DQ62: length 18.1
  BOTTOM w0.165: VRAM2.F11 130.64,108.57 130.64,109.82 129.86,110.6 v1(120.58,110.6) 119.75,110.6 117,107.85 U8.W27
VMA_DQ63: length 18.6
  BOTTOM w0.102: 129.47,109.42 129.77,109.12 129.77,108.64 VRAM2.E11
  BOTTOM w0.165: 129.47,109.42 129.47,109.64 129.01,110.1 v1(121.85,110.1) 119.84,110.1 117.17,107.43 114.55,107.43 U8.W25
VMA_WCK01: length 37.3
  IN3 w0.089: v2(107.91,94.19) 108.13,94.19 108.41,93.92 109.12,93.92 113.7,89.34 122.42,89.34 127.55,84.21 135.6,84.21 136.59,85.2 136.59,85.58 137.45,86.44 137.57,86.44 v2(137.81,86.21)
  BOTTOM w0.102: U8.D18 108.01,95.09 108.01,94.29 v2(107.91,94.19) ; VRAM1.D4 137.41,85.81 v2(137.81,86.21)
VMA_WCK01#: length 37.3
  IN3 w0.089: v2(137.81,87.01) 137.43,86.62 137.37,86.62 136.41,85.66 136.41,85.28 135.52,84.39 127.62,84.39 122.5,89.51 113.77,89.51 109.19,94.09 108.48,94.09 108.4,94.18 108.4,94.57 108.77,94.94 v2(108.77,95.01)
  BOTTOM w0.102: VRAM1.D5 137.41,86.61 v2(137.81,87.01) ; U8.C18 108.22,94.76 108.22,94.91 108.32,95.01 v2(108.77,95.01)
VMA_WCK23: length 27.9
  IN3 w0.089: v2(107.08,95.02) 107.29,95.24 108.26,95.24 108.51,95.49 109.03,95.49 109.41,95.11 109.41,94.65 111.23,92.82 112.58,92.82 112.91,92.49 112.91,91.61 114.45,90.07 123.59,90.07 127.06,86.61 128.61,86.61 v2(129.01,86.21)
  BOTTOM w0.102: v2(129.01,86.21) 129.01,86.2 VRAM1.P4 ; U8.D17 107.48,95.43 v2(107.08,95.02)
VMA_WCK23#: length 28
  IN3 w0.089: v2(107.11,95.8) 107.5,95.41 108.18,95.41 108.44,95.67 109.1,95.67 109.59,95.18 109.59,94.72 111.31,93 112.66,93 113.09,92.57 113.09,91.68 114.52,90.25 123.66,90.25 127.13,86.78 128.79,86.78 v2(129.01,87.01)
  BOTTOM w0.102: v2(129.01,87.01) 129.01,86.81 129.22,86.6 VRAM1.P5 ; v2(107.11,95.8) 106.74,95.43 U8.D16
VMA_WCK45: length 35.1
  IN3 w0.089: v2(137.01,113.41) 136.93,113.32 136.68,113.32 136.59,113.41 136.59,114.66 135.86,115.39 133.58,115.39 133.16,115.81 132.27,115.81 130.74,117.33 125.79,117.33 121.09,112.63 119.51,112.63 118.63,111.75 118.63,110.55 117.79,109.71 116.19,109.71 115.45,108.97 115.45,108.52 114.82,107.89 114.34,107.89 114.11,108.11 113.4,108.11 112.91,107.63 112.91,106.47 113.22,106.16 113.22,106.03 v2(112.96,105.78)
  BOTTOM w0.102: v2(112.96,105.78) 113.23,105.78 113.33,105.68 U8.T24 ; v2(137.01,113.41) 137.41,113.8 VRAM2.P4
VMA_WCK45#: length 35.1
  IN3 w0.089: v2(113.75,105.8) 113.57,105.8 113.4,105.98 113.4,106.23 113.09,106.54 113.09,107.56 113.47,107.94 114.03,107.94 114.26,107.71 114.9,107.71 115.63,108.44 115.63,108.9 116.27,109.54 117.86,109.54 118.81,110.48 118.81,111.68 119.59,112.46 121.17,112.46 125.87,117.16 130.67,117.16 132.2,115.63 133.08,115.63 133.5,115.21 135.79,115.21 136.41,114.59 136.41,113.34 136.6,113.14 136.71,113.14 137.01,112.85 v2(137.01,112.61)
  BOTTOM w0.102: VRAM2.P5 137.41,113 v2(137.01,112.61) ; v2(113.75,105.8) 113.74,105.8 U8.U24
VMA_WCK67: length 20
  IN3 w0.089: v2(113.73,107.45) 114.08,107.1 116.45,107.1 117.79,108.44 118.68,108.44 124.32,114.08 128.43,114.08 128.77,113.75 128.87,113.75 129.01,113.89 v2(129.01,114.21)
  BOTTOM w0.102: VRAM2.D4 129.41,113.81 v2(129.01,114.21) ; U8.V24 v2(113.73,107.45)
VMA_WCK67#: length 19.9
  IN3 w0.089: v2(128.99,113.4) 128.81,113.57 128.69,113.57 128.36,113.91 124.39,113.91 118.75,108.27 117.87,108.27 116.52,106.92 114.02,106.92 v2(113.72,106.62)
  BOTTOM w0.102: VRAM2.D5 129.39,113 v2(128.99,113.4) ; U8.V25 113.82,107.05 113.72,106.95 v2(113.72,106.62)
VR_READY: length 2.6
  BOTTOM w0.102: PU7000.38 142.31,56.27 142.49,56.45 142.49,57.26 v1(142.7,57.46) 142.87,57.29 PR7067.2
VR_SVID_ALERT#_VCORE: length 57.4
  TOP w0.102: PR7002.2 141.19,60.37 140.95,60.61 140.57,60.99 v1(140.57,60.99)
  IN1 w0.089: v1(140.57,60.99) 140.46,60.99 138.75,62.7 133.98,62.7 132.87,63.82 132.87,67.43 130.02,70.28 123.85,70.28 122.66,71.48 121.63,71.48 117.93,75.18 108.18,75.18 107.16,76.2 105.09,76.2 104.88,75.98 101.56,75.98 100.9,75.32 100.9,74.23 99.93,73.27 v1(99.63,73.27)
  BOTTOM w0.102: PR7020.2 140.9,60.74 140.82,60.74 v1(140.57,60.99) ; v1(99.63,73.27) 99.93,72.96 99.93,72.22 100.4,71.76 R2461.2 100.34,72.21 100.34,73.03 R2460.2
VRON: length 121.4
  TOP w0.102: U37.69 200.03,17.38 200.07,17.43 200.34,17.43 v1(200.64,17.12) 200.77,17 200.77,15.69 201.28,15.18 R25311.1
  IN1 w0.089: v1(144.92,37.93) 144.92,38.52 144.25,39.19 144.25,44.26 144.32,44.33 144.32,46.4 145.83,47.91 145.83,52 145.39,52.44 144.84,52.44 143.57,53.71 142.94,53.71 142.17,54.47 142.17,56.88 143.7,58.41 143.7,60.95 143.01,61.63 v1(143.01,61.95)
  IN2 w0.089: v1(200.64,17.12) 200.64,15.91 200.37,15.63 200.37,14.67 200.21,14.51 200.21,12.89 200.62,12.48 201.76,12.48 202.42,13.14 204.15,13.14 204.76,13.75 204.76,18.3 203.39,19.67 203.39,23.99 203.08,24.29 201.92,24.29 201.69,24.52 201.69,25.06 201.31,25.44 201.31,26.4 200.7,27.01 198.99,27.01 195.95,30.06 191.88,30.06 191.08,30.86 185.58,30.86 183.88,32.57 177.72,32.57 176.91,31.76 174.95,31.76 174.59,31.4 174.48,31.4 174.16,31.72 170.77,31.72 170.08,32.42 165.62,32.42 164.97,33.07 161.09,33.07 159.05,35.11 155.88,35.11 155.74,34.97 149.21,34.97 149.15,35.03 146.87,35.03 144.92,36.98 v1(144.92,37.93)
  BOTTOM w0.102: v1(143.01,61.95) 142.77,61.71 PR7025.2
VSEN_CORE: length 47.5
  TOP w0.203: PC7007.1 145.19,50.87 144.29,51.77 143.72,51.77 143.24,51.29 PC7008.2 142.86,51.29 142.6,51.55 v1(142.6,51.55)
  TOP w0.254: v1(118.75,52.59) 118.88,52.59 119.19,52.89 PR7044.2
  IN1 w0.127: v1(118.75,52.59) 119.52,51.83 120.86,51.83 122.69,49.99 122.69,46.41 124.05,45.06 124.72,45.06 124.96,44.82 134.59,44.82 135.46,45.68 136.66,45.68 137.32,45.03 138.55,45.03 138.95,45.43 141.78,45.43 143.65,47.3 v1(143.65,47.66) 143.8,47.66 144.56,48.43 144.56,49.01 143.14,50.43 142.33,50.43 142.08,50.68 142.08,51.14 142.49,51.55 v1(142.6,51.55)
  BOTTOM w0.203: v1(143.65,47.66) 143.65,47.66 143.83,47.48 144.03,47.48 144.36,47.15 144.36,46.7 144.16,46.5 PC7010.1 143.48,46.5 143.42,46.43 PR7047.2 ; PU7000.47 142.38,52.67 142.59,52.47 142.59,51.57 v1(142.6,51.55)
VSEN_GT: length 94.2
  TOP w0.203: PC7013.1 137.85,57.91 v1(137.29,58.47)
  TOP w0.254: v1(95.95,80.83) 95.54,81.24 PR7051.2
  IN1 w0.102: v1(95.95,80.83) 97.51,79.27 99.39,79.27 101.15,77.5 102.65,77.5 103.33,78.19 103.33,79.11 104.96,80.74 107.6,80.74 109.24,82.38 112.21,82.38 112.52,82.07 115.69,82.07 117.76,80 122.2,80 122.69,79.51 125.19,79.51 126.13,78.56 131.08,78.56 131.5,78.14 132.3,78.14 132.95,78.79 139.28,78.79 141.41,76.66 141.41,72.95 139.2,70.74 139.2,64.46 141.48,62.18 141.48,60.09 139.16,57.77 137.7,57.77 137.29,58.19 v1(137.29,58.47)
  BOTTOM w0.203: v1(137.29,58.47) 137.35,58.41 PU7000.27
  BOTTOM w0.254: PR7054.2 PC7016.2 132.5,56.62 132.5,59.51 PC7014.2 133.02,61.43 133.34,61.75 134.29,61.75 134.68,61.36 134.68,60.95 135.09,60.54 135.09,60.16 134.68,59.76 134.68,58.76 135.24,58.2 135.7,58.2 136.21,58.71 137.05,58.71 v1(137.29,58.47)
VSEN_SA: length 40.5
  TOP w0.203: v1(145.27,51.89) PC7022.2 ; PR7058.2 117.9,44.03 118.71,44.83 v1(118.71,45.73)
  IN1 w0.127: v1(118.71,45.73) 120.24,45.73 120.56,45.41 121.44,45.41 122.48,44.37 124.43,44.37 124.67,44.13 134.99,44.13 135.85,45 136.27,45 136.92,44.35 138.83,44.35 139.23,44.75 142.07,44.75 145.25,47.93 145.25,50.38 145.23,50.4 145.23,51.85 v1(145.27,51.89)
  BOTTOM w0.203: PR7059.2 145.68,52.3 v1(145.27,51.89) 144.88,51.89 144.51,51.52 PC7019.1 144.95,51.31 145,51.26 PC7020.1
VSTBY_FSPI: length 24.1
  TOP w0.102: R359.2 176.54,26.15 176.91,26.52 176.91,28.5 177.16,28.75 R25330.2 177.4,29.29 v1(177.7,29.58) 178.01,29.89 v1(178.01,30.28) ; U37.106 193.65,29.11 193.46,28.93 193.32,28.93 193.14,28.75 192.65,28.75 192.36,28.46 191.83,28.46 191.6,28.24 191.6,27.88 v2(191.98,27.49)
  IN2 w0.089: v2(191.98,27.49) 190.59,27.49 189.78,28.3 188.88,28.3 187.65,29.53 183.86,29.53 183.49,29.9 178.38,29.9 v1(178.01,30.28)
WIGIG_LED: length 6.6
  BOTTOM w0.102: CN17.6 189.73,29.88 189.55,30.06 189.55,31.67 189.84,31.96 190.72,31.96 190.9,32.14 190.9,32.67 190.77,32.79 190.77,33.53 190.9,33.66 190.9,33.82 TP9029.1
WLAN_RST#: length 3.1
  BOTTOM w0.102: R2665.1 191.91,19.75 191.91,18.82 191.47,18.38 CN17.52
WLANPWR#: length 2.2
  TOP w0.102: TP2090.1 186.37,13.14 185.84,13.14 185.65,13.33 U37.35
WRST#: length 6.9
  TOP w0.102: U37.14 182.48,22.98 181.83,22.34 C6571.1 181.02,21.94 180.4,21.94 180,22.34 R25300.1 179.52,22.34 179.08,21.9 178.26,21.9 v1(178.07,22.08) 177.83,22.33 D63.2
XCLK_BIASREF: length 6.6
  BOTTOM w0.102: U2030.E42 94.65,59.16 95.13,58.68 96.25,58.68 96.31,58.73 97.6,58.73 97.68,58.82 98.97,58.82 99.22,58.57 R2490.1
XDP_BPM#0: length 5
  BOTTOM w0.102: U2030.C55 96.48,67.11 100.66,67.11 TP2075.1
XDP_BPM#1: length 12.4
  BOTTOM w0.102: U2030.D55 95.96,67.03 96.27,66.71 96.54,66.71 96.65,66.83 99.7,66.83 100.3,66.23 101.3,66.23 101.45,66.38 102.86,66.38 103.19,66.71 103.48,66.71 104.14,66.05 104.3,66.05 104.93,65.43 105.07,65.43 105.43,65.06 TP2074.1
XDP_BPM#2: length 8.3
  BOTTOM w0.102: U2030.B54 97.1,66.09 97.7,66.09 98.21,65.58 98.21,65.14 98.67,64.68 99.96,64.68 100.65,65.37 100.79,65.37 101.58,66.15 103.21,66.15 TP2077.1
XDP_BPM#3: length 6
  BOTTOM w0.076: 97.84,67.93 97.74,68.03 97.23,68.03 97.16,68 96.63,68 96.22,67.59 U2030.C56
  BOTTOM w0.079: 97.84,67.93 98.21,67.93
  BOTTOM w0.102: TP2073.1 100.9,68.16 100.14,68.16 99.43,68.87 99.15,68.87 98.21,67.93
XDP_PRDY#: length 11.3
  BOTTOM w0.102: U2030.D56 95.63,67.59 95.94,67.28 96.21,67.28 96.28,67.35 96.52,67.35 96.56,67.31 101.57,67.31 102.27,66.61 102.8,66.61 103.11,66.92 103.57,66.92 104.23,66.25 104.38,66.25 104.92,65.72 105.34,65.72 TP2076.1
XDP_PREQ#: length 8.7
  BOTTOM w0.076: 98.03,70.56 97.99,70.52 97.24,70.52 97.22,70.5 97.18,70.48 96.9,70.48 96.85,70.43 96.12,70.43 96.05,70.37 95.72,70.37 U2030.D61
  BOTTOM w0.079: 98.03,70.56 98.27,70.56
  BOTTOM w0.102: TP2072.1 102.62,70.12 101.41,70.12 100.93,70.6 100.35,70.6 99.92,71.03 98.88,71.03 98.41,70.56 98.27,70.56
XDP_TCK0: length 12.7
  BOTTOM w0.076: 98.1,70.35 97.31,70.35 97.21,70.32 96.97,70.32 U2030.B61 ; 98.13,70.35 98.33,70.35
  BOTTOM w0.102: 98.1,70.35 98.13,70.35 ; U2030.A59 97.57,69.14 98.33,69.14 98.89,69.7 99.47,69.7 100.37,68.8 101.16,68.8 101.44,69.08 102.17,69.08 102.36,69.26 R2480.2 102.36,69.81 102.26,69.91 101.33,69.91 100.84,70.39 100.27,70.39 99.94,70.73 98.89,70.73 98.52,70.35 98.33,70.35
XDP_TCK1: length 9.2
  BOTTOM w0.076: 97.75,67.72 97.61,67.86 97.28,67.86 97.21,67.84 96.97,67.84 U2030.B56
  BOTTOM w0.079: 97.75,67.72 98.29,67.72
  BOTTOM w0.102: R2485.2 104.1,67.12 103.02,67.12 102.72,66.81 102.35,66.81 101.64,67.52 100.93,67.52 100.55,67.91 100,67.91 99.41,68.49 99.05,68.49 98.29,67.72
XDP_TDI_CPU: length 13.3
  BOTTOM w0.076: 98.15,68.73 97.87,68.73 97.64,68.5 97.3,68.5 97.13,68.56 96.99,68.56 96.76,68.49 96.63,68.49 96.45,68.57 95.79,68.57 U2030.D59 95.42,69.18 U2030.D60
  BOTTOM w0.102: 98.15,68.73 98.5,68.73 98.89,69.12 99.47,69.12 100.23,68.36 101.41,68.36 101.71,68.06 102.07,68.06 102.48,67.66 103.18,67.66 103.52,67.32 104.46,67.32 104.63,67.5 105.23,67.5 R2484.2 105.81,67.78 v1(105.81,67.12)
XDP_TDO_CPU: length 14
  IN1 w0.089: v1(106.53,68.07) 106.06,68.54 102.86,68.54 102.45,68.13 99.98,68.13 99.92,68.07 v1(99.21,68.07) 98.54,68.74 98.54,69.34 v1(98.11,69.78)
  BOTTOM w0.076: U2030.A56 97.62,67.59 97.7,67.52 98.3,67.52
  BOTTOM w0.102: v1(98.11,69.78) 97.67,69.78 U2030.A61 ; v1(106.53,68.07) 106.68,67.92 R2487.2 ; v1(99.21,68.07) 98.66,67.52 98.3,67.52
XDP_TMS_CPU: length 8.4
  BOTTOM w0.076: U2030.C60 96.07,69.18 U2030.C59 96.28,68.95 96.49,68.74 96.66,68.66 96.74,68.66 96.97,68.72 97.16,68.72 97.33,68.66 97.51,68.66 97.79,68.94 98.11,68.94
  BOTTOM w0.102: 98.11,68.94 98.42,68.94 98.91,69.43 99.45,69.43 100.31,68.57 101.5,68.57 101.8,68.26 102.51,68.26 R2482.2
XDP_TRST#: length 6.1
  BOTTOM w0.076: 96.92,68.95 U2030.B59 96.72,69.62 96.27,70.07 U2030.C61
  BOTTOM w0.079: 97.97,69.34 97.31,69.34 96.92,68.95
  BOTTOM w0.102: R2481.2 100.27,69.19 99.56,69.9 98.81,69.9 98.25,69.34 97.97,69.34
XTAL1: length 2.6
  TOP w0.102: U24.28 44.33,108.14 44.89,108.7 45.15,108.7 45.65,109.2 R511.2
XTAL2: length 2.1
  TOP w0.102: R512.1 43.93,108.21 U24.29
XTAL24_IN: length 15.8
  BOTTOM w0.102: Y2002.3 102.78,64.3 102.78,63.41 102.48,63.11 102.08,63.11 C2563.2 101.87,62.5 101.87,61.62 R2491.1 101.5,61.25 101.5,57.96 101.13,57.58 98.66,57.58 98.35,57.28 96.69,57.28 96.53,57.44 96.27,57.44 96.16,57.34 95.96,57.34 95.87,57.43 95.59,57.43 95.43,57.26 95.31,57.26 94.68,56.63 U2030.E37
XTAL24_IN_E3: length 9.8
  BOTTOM w0.102: R2535.1 97.29,32.37 97.42,32.5 97.42,32.82 97.07,33.17 96.93,33.17 96.81,33.06 96.71,33.06 96.54,33.23 96.54,33.37 96.84,33.67 96.84,33.82 95.97,34.69 95.83,34.69 95.49,34.35 95.32,34.35 95.19,34.48 95.19,34.62 95.71,35.14 95.71,35.29 95.57,35.42 95.41,35.42 95.04,35.05 94.9,35.05 94.79,35.15 94.79,35.86 94.96,36.02 95.52,36.02 95.61,36.11 95.61,36.28 95.1,36.79 U2030.E3
XTAL24_IN_E3_R: length 3.4
  BOTTOM w0.102: R2535.2 97.13,31.47 R2534.1 97.13,29.97 97.12,29.97 C2591.1 97.12,28.39 Y2003.3
XTAL24_OUT: length 15.3
  BOTTOM w0.102: Y2002.1 103.51,63.56 C2564.2 102.64,62.07 102.36,61.78 R2491.2 101.87,60.84 101.87,57.84 101.31,57.28 98.86,57.28 98.47,56.89 96.62,56.89 96.5,56.77 96.29,56.77 96.18,56.88 95.95,56.88 95.85,56.79 95.64,56.79 95.53,56.89 95.33,56.89 95.01,56.57 95.01,56.08 U2030.E35
XTAL24_OUT_C7: length 8.4
  BOTTOM w0.102: R2530.1 97.98,32.55 97.12,33.41 97.12,33.83 96.31,34.64 96.08,34.87 96.08,35.86 95.9,36.04 95.9,36.43 96,36.53 96,36.8 95.81,36.99 95.6,36.99 95.39,37.2 95.39,37.44 95.75,37.8 95.75,38.6 96.07,38.93 U2030.C7
XTAL24_OUT_C7_R: length 5.2
  BOTTOM w0.102: R2530.2 97.91,31.52 R2534.2 97.91,29.68 C2589.1 97.65,28.99 97.65,27.61 97.8,27.46 98.05,27.21 Y2003.1
XTAL_SSIN: length 5
  BOTTOM w0.102: R331.1 98.61,89.95 99.17,90.51 99.71,90.51 100.9,91.7 100.9,92.22 U8.A10
N06325: length 7.2
  TOP w0.102: R25471.1 68.38,16.89 Q29.3 67.55,15.4 v1(67.84,15.1) 67.96,15.1 68.46,15.61 R25473.2 68.71,15.34 68.9,15.15 70.08,15.15 R573.2
N108478: length 14.4
  BOTTOM w0.076: U2030.BA11 75.13,42.08 74.55,42.08 74.31,41.84 74.03,41.84
  BOTTOM w0.102: 74.03,41.84 72.15,41.84 70.32,40.01 70.32,36.68 69.78,36.14 69.78,35.67 68.51,34.4 68.51,33.91 68.21,33.6 C2593.2 68.21,32.85 R2546.1
N109300: length 11.7
  BOTTOM w0.076: U2030.AY13 76.05,43 75.84,43 75.62,43.23 75.47,43.28 75.34,43.28 75.11,43.22 74.97,43.22 74.81,43.29 74.4,43.29 74.22,43.11 74.02,43.11 74,43.08
  BOTTOM w0.102: R2527.1 68.24,38.6 68.24,39.74 71.58,43.08 74,43.08
N109332: length 11.3
  BOTTOM w0.076: U2030.BA13 75.13,42.74 74.19,42.74 74.13,42.68
  BOTTOM w0.102: R2525.1 67.7,37.04 68.64,37.98 68.64,39.57 71.75,42.68 74.13,42.68
N109356: length 11.5
  BOTTOM w0.076: U2030.BB13 74.35,43.01 74.27,42.92 74.09,42.92 74.05,42.88
  BOTTOM w0.102: 74.05,42.88 71.67,42.88 68.44,39.65 68.44,38.29 67.6,37.45 66.74,37.45 66.68,37.4 R2529.1
N109380: length 12.7
  BOTTOM w0.076: 74.04,42.47 74.2,42.47 74.3,42.57 75.29,42.57 75.45,42.74 75.88,42.74 76.18,42.44 U2030.AY12
  BOTTOM w0.102: R2531.1 68.85,37.73 68.85,39.47 71.85,42.47 74.04,42.47
N112429: length 6
  BOTTOM w0.102: U2030.B7 97.01,39.5 97.96,39.5 TP2080.1
N112433: length 3.4
  TOP w0.079: R2205.2 96.52,41.59 95.4,42.72 95.05,42.72 94.79,42.46 v4(94.34,42.46)
  BOTTOM w0.102: v4(94.34,42.46) 94.34,42.6 U2030.E13
N16824426: length 3.8
  BOTTOM w0.102: U11.2 99.83,120.56 99.58,120.31 99.58,119.87 R323.2 98.72,120.03 97.69,120.03 R324.2
N16946786: length 1.6
  BOTTOM w0.102: R2486.1 110.42,62.6 110.42,62.66 Q2024.1
N17002655: length 4.6
  BOTTOM w0.203: U20.39 208.33,34.03 208.45,34.15 208.88,34.15 209.13,34.4 209.13,34.89 209,35.01 209,35.43 209.66,36.09 209.66,36.11 210.12,36.56 C572.2
N17002661: length 5.6
  BOTTOM w0.203: C566.2 209.42,38.58 209.33,38.49 209.33,36.48 208.68,35.83 v1(208.62,35.83) 208.11,35.33 208.11,35.03 207.91,34.82 U20.37
N17002676: length 1.9
  BOTTOM w0.203: U20.34 206.06,36.29 206.79,37.03 C567.1
N17002678: length 2.9
  BOTTOM w0.203: U20.19 200.93,32.82 200.39,33.36 199.81,33.36 199.36,32.91 C573.1
N17002722: length 4.6
  BOTTOM w0.102: R454.2 R453.2 209.93,29.55 208.47,29.55 208.11,29.91 208.11,30.32 208.01,30.43 U20.48
N17002952: length 3.3
  BOTTOM w0.102: C578.1 203.37,26.87 203.68,27.18 203.68,28.36 204.01,28.69 204.23,28.69 204.46,28.92 U20.7
N17002968: length 9.1
  TOP w0.102: R741.2 202.17,28.16 v2(202.17,28.06)
  BOTTOM w0.102: U20.11 202.86,29 202.17,28.31 v2(202.17,28.06) 202.17,27.95 201.73,27.51 201.73,27.22 201.15,26.64 201.15,25.72 200.27,24.84 R739.1 200.49,24.36 200.49,23.56 v1(200.73,23.32) 200.54,23.13 R738.1
N17002995: length 5.4
  BOTTOM w0.102: R740.1 200.93,26.19 200.93,26.86 R742.2 200.43,27.41 200.9,27.88 200.9,28.1 C846.1 201.6,28.55 201.67,28.47 201.98,28.47 202.46,28.95 U20.12
N17003129: length 4.9
  BOTTOM w0.203: C566.1 208.22,38.88 208.09,38.74 208.09,37.53 207.17,36.61 206.81,36.61 206.46,36.26 U20.35
N17003186: length 3.4
  BOTTOM w0.203: R450.1 199.19,33.97 v1(199.42,33.74) 199.5,33.67 200.52,33.67 200.96,33.22 U20.20
N17004316: length 4.9
  TOP w0.102: D12.1 209.43,23.2 208.31,22.08 208.31,21.12 208.3,21.11 208.3,20.97 v1(208,20.66) 207.67,20.66 207.43,20.91 Q21.3
N17046941: length 5.4
  TOP w0.203: PR13.1 105.17,17.09 v1(105.01,17.25)
  BOTTOM w0.508: PJ1.3 105.45,18.31 105.45,18.3 105.45,17.7 v1(105.01,17.25)
N17047007: length 5.4
  TOP w0.198: PR1.1 54.09,113.71 52.5,113.71 51.75,114.46 51.75,116.13 51.56,116.32 PR3.1
  vias: v1(50.97,118.68)
N17047009: length 1.8
  BOTTOM w0.178: PU1.20 133.68,27.48 133.47,27.27 132.9,27.27 132.83,27.34 PR5.1
N17047028: length 1.6
  BOTTOM w0.178: PR6.1 133.51,26.86 133.78,27.13 133.97,27.13 134.08,27.23 PU1.19
N17047083: length 2
  TOP w0.102: PR14.1 101.45,22.12 v1(101.45,22.5)
  BOTTOM w0.102: v1(101.45,22.5) PJ1.5
N17047087: length 12.5
  BOTTOM w0.152: PR209.1 113.05,28.24 112.89,28.08 112.89,26.48 113.48,25.9 121.03,25.9 121.11,25.82 PR210.2
  vias: v1(117.73,28.9) v1(117.71,28.21) v1(118.35,28.21) v1(118.36,28.9) v1(119.03,28.92) v1(119.04,28.23) v1(119.67,28.92) v1(119.68,28.23) v1(120.32,28.91) v1(120.32,28.23)
N17047112: length 177.1
  TOP w0.508: PQ1.4 43.45,121.4 43.64,121.2 PC1.2 44.55,121.2 PC2.2 44.81,122.45 v1(44.52,122.45) ; v1(43.39,116.14) 43.39,115.96 43.9,115.45 PQ9054.4
  IN1 w0.254: v1(44.52,122.45) 45.83,121.14 45.83,120.28 46.87,119.24 50.47,119.24 53.8,115.91 61.23,115.91 v1(62.65,114.49)
  IN2 w0.381: v1(115.07,70.78) 114.9,70.95 113.7,70.95 113.32,71.33 113.32,74.55 112.91,74.95 107.94,74.95 106.33,76.57 106.33,79.78 105.12,80.99 105.12,86.05 104.79,86.37 104.79,86.91 v1(104.96,87.08)
  IN3 w0.254: v1(62.65,114.49) 63.23,113.91 65.83,113.91 68.31,116.38 68.31,118.31 68.82,118.82 68.82,119.52 70.57,121.27 76.69,121.27 76.8,121.16 83.84,121.16 89.63,115.37 90.69,115.37 93.56,112.5 93.56,101.57 94.6,100.53 94.6,98.13 96.15,96.57 96.15,95.81 96.52,95.44 97.39,95.44 97.62,95.21 97.62,94.85 98,94.47 98,94.41 99.69,92.72 99.69,92.17 101.7,90.17 103.78,90.17 104.92,89.03 104.92,87.12 v1(104.96,87.08)
  IN3 w0.381: v1(134.86,34.94) 134.89,34.91 134.89,34.83 134.52,34.47 133.98,34.47 132.84,35.61 132.29,35.61 129.9,38 127.64,38 124.32,41.32 123.28,42.35 123.28,48.62 120.8,51.11 120.8,52.14 119.58,53.36 119.58,62.07 116.41,65.24 116.41,68.99 116.09,69.3 116.09,70.17 115.48,70.78 v1(115.07,70.78)
  BOTTOM w0.203: v1(134.86,34.94) 134.86,34.28 PR29.1
  BOTTOM w0.508: v1(44.52,122.45) 44.52,121.28 43.39,120.15 v1(43.39,116.14)
N17047335: length 1.6
  TOP w0.508: PC19.1 127.27,28.62 PR33.2
N17047399: length 1.7
  TOP w0.508: PC15.2 129.1,30.38 v1(129.04,30.44)
  BOTTOM w0.508: v1(129.04,30.44) 129.04,29.73 PR11.2
N17047425: length 6.5
  TOP w0.203: PR12.1 103.62,16.02 v1(103.62,17.25)
  BOTTOM w0.508: v1(103.62,17.25) 103.62,18.17 103.45,18.35 PJ1.4
N17047601: length 4.5
  TOP w0.102: v1(125.8,31.26) 125.55,31.26 PQ2.4
  TOP w0.305: PC17.2 123.73,28.2 124.53,29 PR4.1
  TOP w0.381: PR4.1 124.83,29.53 124.65,29.7 PQ2.4
N17398787: length 1.5
  TOP w0.203: v1(134.96,32.83) 134.96,33.12 134.93,33.16 PR30.2
  BOTTOM w0.178: PU1.5 134.88,32.64 134.96,32.73 v1(134.96,32.83)
N17424918: length 2
  BOTTOM w0.102: PR19.2 137.94,29.73 137.32,29.73 137.15,29.91 PU1.11
N17424920: length 1.8
  BOTTOM w0.102: PU1.12 137.04,29.51 137.12,29.42 138.14,29.42 PR17.2
N17424921: length 1.4
  BOTTOM w0.178: 135.68,32.33 PU1.7
  BOTTOM w0.203: PR32.2 135.98,32.63 135.68,32.33
N17424925: length 1.7
  BOTTOM w0.198: PU1.9 137.02,30.71 137.78,31.47 PR25.2
N17424950: length 3.5
  TOP w0.203: v1(136.26,28) 136.52,28.26 136.64,28.26 136.95,28.57 PR205.2 137.34,28.75 137.76,28.33 PR8.2
  BOTTOM w0.178: v1(136.26,28) 136.26,27.71 136.03,27.47 135.78,27.47 135.68,27.57 PU1.15
N17661815: length 2.5
  BOTTOM w0.198: PU1.8 137.03,31.11 137.49,31.57 137.49,31.72 137.63,31.86 138.12,31.86 138.29,32.03 PR26.2
N18020348: length 2
  TOP w0.102: TP2029.1 80.07,48.98 v4(80.88,49.79)
  BOTTOM w0.102: v4(80.88,49.79) 81.11,49.55 U2030.AM23
N18021386: length 1.7
  TOP w0.102: v4(80.88,48.87) 80.86,48.85 TP2030.1
  BOTTOM w0.102: U2030.AM22 80.88,48.64 v4(80.88,48.87)
N18022283: length 2.2
  TOP w0.102: v4(92,54.46) 92.01,54.45 92.01,53.38 TP2027.1
  BOTTOM w0.102: v4(92,54.46) 92,54.31 U2030.K32
N18022286: length 2
  TOP w0.102: v1(82.95,53.33) 82.95,53.86 TP2028.1
  BOTTOM w0.102: v1(82.95,53.33) 82.95,53.5 82.56,53.89 U2030.AK32
N18137715: length 17.3
  TOP w0.102: TP2046.1 63.71,37.76 64.32,38.37 65.06,38.37 65.61,37.81 66.87,37.81 67.4,38.34 71.43,38.34 73.3,40.21 75.41,40.21 76.2,41 77.65,41 78.21,41.56 v4(78.26,41.56)
  BOTTOM w0.102: v4(78.26,41.56) 78.26,41.6 U2030.AU11
N18867812:
  vias: v1(20.41,29.9)
N18954271: length 6.8
  BOTTOM w0.102: R2458.1 100.01,76.08 99.35,75.43 99.35,74.34 98.47,73.46 98.47,73.04 98.07,72.64 97.91,72.64 97.48,72.21 96.62,72.21 U2030.C64
N18954889: length 2.4
  TOP w0.102: v4(79.46,68.12) 79.1,68.49 78.31,68.49 TP2023.1
  BOTTOM w0.102: U2030.AP56 79.81,67.77 v4(79.46,68.12)
N18990234: length 49
  TOP w0.254: R395.2 98.34,124.45 97.88,124.45 97.71,124.29 R25585.1 ; 87.68,93.59 v2(87.18,94.09) ; 87.68,93.59 R397.2 R404.2 R25490.2 ; 87.68,93.59 R403.2 ; v1(96.84,121.6) 96.84,121.83 96.22,122.44 96.22,123.37 97.14,124.29 R25585.1 ; R25584.1 97.19,124.86 97.35,124.69 97.35,124.3 R25585.1
  IN1 w0.254: v1(96.84,121.6) 97.09,121.34 97.09,120.48 96.8,120.2 95.38,120.2 94.28,119.1 93.97,119.1 93.28,118.4 93.28,117.57 91.05,115.34 91.05,109.17 90.32,108.44 90.32,100.36 89.63,99.67 88.83,99.67 88.14,98.98 88.14,96.08 87.18,95.13 v2(87.18,94.09) 86.45,94.09 85.91,93.56 85.91,92.39 86.29,92.02 v1(86.77,92.02)
  BOTTOM w0.254: v1(86.77,92.02) 86.87,91.92 86.87,91.64 87.1,91.41 R399.2 87.84,90.91 87.81,90.88 R391.2
N18994895: length 4.2
  BOTTOM w0.102: C2594.2 92.82,32.88 92.82,33.98 92.37,34.44 92.37,34.68 91.81,35.24 91.81,35.94 U2030.L1
N19018012: length 21.8
  TOP w0.079: v4(88.91,41.3) 88.94,41.3 89.22,41.59 89.57,41.93 91.09,41.93 91.66,41.37 91.66,39.44 91.71,39.39 91.71,38.53 92.23,38.01 92.23,37.71 C2599.1 92.46,37.48 92.46,37.24 94.1,35.6 97.08,35.6 97.73,34.96 98.02,34.96
  TOP w0.102: R2593.2 101.4,31.11 101.4,32.59 99.54,34.45 98.72,34.45 98.21,34.96 98.02,34.96
  BOTTOM w0.102: v4(88.91,41.3) 88.69,41.3 U2030.U11 U2030.U12
N19138106: length 1.3
  TOP w0.102: v2(111.33,96.66) 110.88,97.11 R321.2
  BOTTOM w0.102: U8.F22 111.63,96.95 v2(111.33,96.66)
N19138109: length 2.1
  TOP w0.102: R322.2 110.77,99.6 111.57,99.6 111.98,99.19 v2(112.11,99.19)
  BOTTOM w0.102: U8.J22 v2(112.11,99.19)
N19521323: length 2
  TOP w0.102: PR6006.1 143.29,31.29 v1(142.69,31.29) 142.49,31.09 PQ6000.3
N19521733: length 26.1
  TOP w0.102: PR6012.1 141.14,30.43 141.51,30.06 141.51,29.04 141.54,29.02 PQ6000.2 141.4,28.18 v1(140.85,28.18) ; PR9268.1 159.93,26.59 PR9269.1 159.17,26.68 159.12,26.73 158.91,26.73 v1(158.76,26.88)
  IN3 w0.089: v1(140.85,28.18) 141.18,27.85 142.73,27.85 143.04,27.55 143.04,26.66 143.72,25.98 147.51,25.98 148.94,27.41 155.02,27.41 155.18,27.57 158.08,27.57 v1(158.76,26.88)
N19549602: length 153.2
  TOP w0.102: v1(174.51,16.8) 175.02,17.31 175.65,17.31 175.8,17.46 PR9271.1 PR9270.1 ; PR6024.1 44.37,15.53 PQ6001.2 45.34,16.77 45.65,17.08 45.65,21.83 45.17,22.31 v1(44.74,22.31)
  IN2 w0.089: v1(44.74,22.31) 44.99,22.06 46.06,22.06 48.15,19.97 52,19.97 53.32,18.66 80.12,18.66 83.55,22.08 89.11,22.08 89.81,21.39 92,21.39 92.54,20.85 95,20.85 95.97,19.88 95.97,19.12 98.49,16.6 99.97,16.6 101.92,14.65 111.4,14.65 112.22,15.47 118.72,15.47 119.92,14.27 148.31,14.27 148.78,14.74 v1(148.78,16.42)
  BOTTOM w0.102: v1(148.78,16.42) 148.78,15.61 150,14.39 165.44,14.39 168.84,17.79 173.52,17.79 v1(174.51,16.8)
N20915811: length 1.9
  TOP w0.079: v4(81.57,42.73) 81.88,43.03 81.88,43.65 TP2036.1
  BOTTOM w0.102: U2030.AK13 81.82,42.73 v4(81.57,42.73)
N20946170: length 4.9
  TOP w0.102: R2222.1 44.28,34.42 43.04,35.66 43.04,36.71 42.89,36.87 42.89,38.1 U2012.E9
N20946459: length 4.6
  TOP w0.102: R2158.1 43.65,71.2 42.95,71.91 42.95,72.77 U2010.E9
N20946794: length 3.6
  TOP w0.102: U2011.E9 42.86,51.28 42.86,48.47 R2190.1
N20947128: length 8.6
  TOP w0.102: R2134.1 49.05,84.87 43.49,84.87 42.85,85.51 42.85,85.94 U2009.E9
N21263014: length 10.1
  TOP w0.102: TP65.1 102.02,89.53 100.14,91.41 99.55,91.99 99.55,93.57 100,94.02 100,95.2 100.19,95.39 100.64,95.39 100.89,95.64 100.89,96.17 v2(101.38,96.66)
  BOTTOM w0.102: U8.E10 101.38,96.56 v2(101.38,96.66)
N21263017: length 16.5
  TOP w0.102: v2(102.17,96.68) 101.84,96.35 101.84,95.53 102.17,95.2 102.17,92.16 102.87,91.46 103,91.46 104.98,89.48 107.01,89.48 107.43,89.06 108,89.06 110.17,86.89 TP66.1
  BOTTOM w0.102: U8.F10 101.78,97.07 v2(102.17,96.68)
N21450006: length 2.8
  BOTTOM w0.254: JDIM2000.255 57.33,30.71 56.83,31.2 56.32,31.2 v1(56.02,30.9)
  vias: v1(55.1,30.2)
N21450098: length 1.1
  TOP w0.508: C2250.2 53.61,57.87 R2192.2
N21567140: length 9.1
  BOTTOM w0.102: U2030.G4 94.14,37.36 94.14,34.69 96.23,32.61 96.23,30.66 R2547.1
N22413276: length 11.5
  TOP w0.203: PQ7.3 127.66,52.01 127.58,52.08 127.58,53.17 PR79.2 127.58,53.84 127.67,53.94 PR80.1 127.41,54.87 126.4,54.87 126.18,54.65 PQ10.2 125.15,53.95 124.14,52.94 124.14,52.11 PQ25.2
N22413302: length 5.2
  TOP w0.102: PR105.2 120.69,51.59 v1(123.09,53.99) 124,54.9 PQ10.3
N22415444:
  vias: v1(110.48,39.97) v1(110.48,39.33) v1(110.5,38.7) v1(110.5,38.06) v1(110.5,37.43) v1(111.14,39.97) v1(111.14,39.33) v1(111.16,38.7) v1(111.16,38.06) v1(111.16,37.43)
N22415652: length 1.4
  TOP w0.508: PR99.2 PC82.1
N22415656: length 14.1
  TOP w0.152: PR9259.1 111.32,32.6 116.03,32.6 120.22,36.79 v1(120.83,36.79)
  BOTTOM w0.203: PC225.2 121.9,36.28 121.8,36.18 PR269.1 121.31,36.29 121.31,36.31 v1(120.83,36.79)
N22415672: length 1.2
  TOP w0.508: PC235.2 115.78,40.17 115.86,40.09 PR277.1
N23833251:
  vias: v1(212.57,16.43)
N24359231: length 3.5
  BOTTOM w0.102: PC7056.2 132.92,44.14 v1(132.62,43.84)
  BOTTOM w0.305: PC7056.2 132.17,45.57 132.17,46.32 132.36,46.51 PU7001.4
N24359390: length 9.3
  IN3 w0.508: v1(132.7,45.96) 131.86,45.12 129.35,45.12 128.2,43.97 v1(128.2,42.18)
  BOTTOM w0.305: PU7001.3 132.86,46.12 v1(132.7,45.96)
  BOTTOM w0.508: v1(128.2,42.18) 128.22,42.18 PR7078.1
N24444747: length 37.9
  TOP w0.102: PR7017.2 133.4,53.1 132.73,53.1 132.71,53.12 132.71,53.12 132.62,53.21 132.62,54.95 132.17,55.41 v1(132.17,56.22)
  TOP w0.203: PR7017.2 134.01,53.71 135.35,53.71 PR7031.1 135.47,55.25 PR7018.1
  IN2 w0.089: v1(132.17,56.22) 132.72,56.78 132.72,57.25 132.9,57.42 132.9,60.16 132.29,60.76 132.29,63.6 132.9,64.2 132.9,67.21 130.09,70.02 130.09,75.91 127.25,78.74 126.4,78.74 125.51,79.64 v1(125.51,80.27)
  BOTTOM w0.203: PR7021.2 124.94,80.27 v1(125.51,80.27)
N24444757: length 1.5
  TOP w0.203: PC7023.1 145.82,52.13 PR7063.2
N24445360: length 6.8
  BOTTOM w0.102: PU7000.37 142.15,56.67 142.25,56.77 142.25,58.25 142.66,58.66 v1(142.66,58.77) 142.71,58.83 142.71,60.36 PC7005.1 142.99,60.99 142.78,61.2 141.9,61.2 141.53,61.56 PR7025.1
N24445593: length 9.3
  BOTTOM w0.203: PR7069.2 141.54,45.99 141.54,48.5 141.35,48.69 141.15,48.89 PR7066.2 141.03,49.13 140.76,49.4 139.38,49.4 139.15,49.64 138.07,49.64 137.75,49.96 137.75,50.34 138.15,50.74 PU7000.8
N24445614: length 64.7
  IN3 w0.102: v1(126.27,73.6) 125.89,73.98 122.77,73.98 121.19,72.4 118.09,72.4 117.41,71.72 117.41,65.4 120.41,62.41 120.41,53.75 124.13,50.03 124.13,43.63 125.45,42.3 125.45,42.1 126.32,41.23 129.43,41.23 129.82,41.62 129.82,42.68 130.63,43.48 132.52,43.48 133.05,44.02 134.96,44.02 135.96,45.02 135.96,45.94 135.09,46.82 134.8,46.82 134.52,47.11 134.52,47.45 135.31,48.25 v1(136.05,48.25)
  BOTTOM w0.203: v1(136.05,48.25) 136.19,48.11 PR7026.1 PR7030.1 137.16,46.95 137.32,47.11 PR7016.2 ; v1(126.27,73.6) 126.44,73.43 PR7032.2
N24446268: length 1.2
  TOP w0.203: PR7038.1 137,50.43 136.49,49.93 PR7037.2
N24459302: length 32.1
  IN1 w0.089: v1(126.35,62.47) 126.05,62.17 126.05,60.26 127.32,58.99 129.75,58.99 130.02,58.72 130.02,57.61 132.86,54.77 132.86,53.39 133.99,52.26 135.34,52.26 136.23,51.37 137.71,51.37 138.4,50.68 139.55,50.68 141.09,49.14 141.09,46.54 140.81,46.26 138.58,46.26 v1(138.24,45.91)
  BOTTOM w0.203: v1(138.24,45.91) 138.24,45.06 PR7076.1 ; PR7073.2 v1(126.35,62.47)
N24492000: length 2.3
  BOTTOM w0.102: PC7012.1 143.66,45.49 v1(143.85,45.68)
  BOTTOM w0.203: PR7049.1 142.66,45.82 142.68,45.82 PC7012.1
N24507636:
  vias: v1(168.27,22.62) v1(168.9,22.62)
N24507642: length 4
  TOP w0.381: PR6418.2 PC9097.1 PR283.1 160.71,25.72 161.17,25.27 v1(161.17,25)
  BOTTOM w0.381: v1(161.17,25) 161.16,25 161.16,24.48 PU3003.6
N24507664: length 11.4
  TOP w0.381: v1(162.24,27.77) 161.64,27.77 PR6418.1 PC9097.2
  BOTTOM w0.381: PR6414.1 168.84,25.2 167.83,26.21 167.5,26.21 v1(166.84,26.87) 166.35,27.36 166.35,27.69 165.64,28.4 162.66,28.4 162.24,27.98 v1(162.24,27.77)
N24507676: length 10
  TOP w0.102: v1(162.88,27.72) 162.49,27.34 PC6229.2 163.35,26.66 PR6417.1
  BOTTOM w0.102: v1(162.88,27.72) 163.18,28.03 165.49,28.03 165.77,27.75 165.77,26.35 164.4,24.98 164.4,24.62 164.03,24.25 PU3003.1
N24507691: length 8.2
  TOP w0.102: PR284.2 165.22,28.09 v1(165.22,27.6)
  BOTTOM w0.102: PU3003.5 161.33,23.3 162.3,24.28 162.56,24.28 163.14,24.85 163.79,24.85 165.22,26.28 v1(165.22,27.6)
N24515156: length 1.3
  BOTTOM w0.203: PR7056.1 133.01,54.95 PC7018.1
N24602110: length 22.8
  IN1 w0.102: v1(131.13,58.09) 132.02,58.09 134.1,56.02 134.1,54.12 134.39,53.83 134.91,53.83 136.67,52.08 140.22,52.08 141.58,50.72 141.58,50.49 v1(143.44,48.63)
  BOTTOM w0.203: PR7014.1 PR7013.2 144.96,50.02 144.72,49.77 144.58,49.77 143.44,48.64 v1(143.44,48.63) ; PR7007.2 v1(131.13,58.09)
N24622727: length 51.3
  TOP w0.203: PR7100.1 133.07,55.48 PR7099.2 134.35,55.02 v1(134.69,55.02)
  IN3 w0.102: v1(114.51,84.21) 114.57,84.16 114.69,84.16 118.06,80.8 120.98,80.8 122.12,81.94 127,81.94 129.25,79.68 129.25,77.51 130.95,75.81 130.95,70.85 133.64,68.16 133.64,63.49 136.04,61.09 136.04,58.63 135.7,58.3 134.39,58.3 133.54,57.45 133.54,55.19 133.91,54.81 134.48,54.81 v1(134.69,55.02)
  BOTTOM w0.203: v1(114.51,84.21) 114.51,83.96 114.14,83.59 PR7101.1
N24742093:
  vias: v1(68.33,97.53)
N24742096: length 5.7
  BOTTOM w0.254: PR9075.2 75.34,102.34 74.59,101.59 74.59,99.76 74.36,99.53 PQ9011.3 74.59,99.06 v1(75.22,98.43) 75.22,97.75 PD9001.2
N24742104: length 12.7
  BOTTOM w0.102: PQ9009.2 70.47,103.75 71.82,103.75 72.32,104.24 PR9077.1 PR9074.2 74.31,104.24 v1(74.66,103.89) ; v1(74.66,103.89) 74.66,103.03 73.41,101.78 PQ9011.2 ; v1(74.66,103.89) 75.35,103.89 75.9,104.44 76.36,104.44 76.68,104.12 76.68,103.55 PQ9010.3
N24742107:
  vias: v1(22.13,98.39)
N24742118: length 1.4
  BOTTOM w0.254: PR9078.1 78.74,98.13 78.48,98.38 PU9003.3
N24742123: length 1.9
  BOTTOM w0.381: PQ9009.3 71.05,102.12 PR9073.2
N24742126: length 15.1
  BOTTOM w0.254: PR9282.2 77.91,103.22 77.51,102.82 PQ9010.2 78.11,101.24 78.11,99.87 78.44,99.54 78.81,99.54 79.32,99.04 v1(79.59,99.04) 80.05,98.58 80.05,97.42 79.22,96.59 79.22,94 78.9,93.68 PR9079.1 78.45,93.68 77.9,94.23 PC9073.1 77.79,94.35 78.48,95.04 PU9003.4
N24742146: length 2
  BOTTOM w0.102: PR9080.2 v1(74.81,93.47)
  BOTTOM w0.508: PR9080.2 76.76,93.47 PC9071.1
N24742181:
  vias: v1(20.56,92.03) v1(20.6,91.39) v1(25.84,91.3) v1(25.84,90.66)
N24742207: length 1.9
  TOP w0.203: PU9002.10 22.94,95.18 23.2,95.44 23.2,95.59
  TOP w0.254: PC9063.1 23.2,96.01 23.2,95.59
N24742208: length 1.8
  TOP w0.203: 22.14,95.22 PU9002.12
  TOP w0.254: PC9062.1 22.14,95.97 22.14,95.22
N24742222: length 6
  TOP w0.203: PU9002.5 22.94,91.64 v1(23.06,91.52)
  TOP w0.254: v1(23.06,91.52) 23.63,90.95 23.63,90.95 PC9060.1 24.21,90.67 24.42,90.46 24.42,88.88 PR9070.1 24.93,88.6 25.38,88.15 PR25541.2
N24742230: length 6
  TOP w0.203: PU9002.3 22.14,91.61 21.88,91.35 21.88,91.15
  TOP w0.254: 21.88,91.15 PC9064.1 22.18,90.67 22.39,90.46 22.39,88.89 22.75,88.53 PR9277.2 22.75,88.07 23.17,87.64 PR9072.2
N24995566: length 3.2
  BOTTOM w0.102: PU3002.5 78.37,26.08 78.34,26.06 PC6228.1 77.09,26.06 PR3020.2 76.3,25.89 v1(76.11,26.08)
N24995570: length 2.3
  BOTTOM w0.102: PR3021.1 83.3,26.08 PU3002.1 81.88,26.74 v1(82.01,26.87)
N24995581: length 5.2
  BOTTOM w0.102: PR3022.1 78.7,23.55 80.27,23.55 80.9,24.18 PU3002.3 82.84,24.18 v1(82.88,24.15)
N25167244: length 3.8
  TOP w0.102: v2(52.46,53.54) 52.46,52.9 52.7,52.65 52.7,52.55 TP2031.1
  BOTTOM w0.102: v2(52.46,53.54) 52.04,53.95 JDIM2000.162
N25167247: length 5.4
  TOP w0.102: v2(54.83,52.87) 54.68,52.73 54.68,52.01 TP2034.1
  BOTTOM w0.102: JDIM2000.165 57.54,53.2 57.07,53.67 55.48,53.67 54.83,53.02 v2(54.83,52.87)
N25369936: length 3.1
  TOP w0.102: R560.2 92.89,29.14 R561.1 92.41,28.05 92.76,27.7 92.76,27.55 92.56,27.35 Q27.1
N25369945: length 4.3
  TOP w0.079: 95.31,26.33 R557.1 94.96,27.04 R558.2
  TOP w0.102: 95.31,26.33 94.69,25.71 v1(94.67,25.71) 94.33,26.05 Q27.4
N25430953: length 2
  BOTTOM w0.508: PR111.2 107.08,33.96 107.54,33.5 108.03,33.5 PQ14.3
N25430988:
  vias: v1(29.44,9.03)
N25430994: length 4.2
  BOTTOM w0.381: PR126.2 v1(105.21,27.75) PQ19.3
N25431520: length 3.2
  BOTTOM w0.102: PR9227.2 10.12,20.75 10.12,20.13 9.88,19.89 PQ9050.3
N25804343: length 2.1
  BOTTOM w0.102: v1(70.61,115.33) 70.16,114.88 PR9030.2
  BOTTOM w0.254: PR9030.2 70.16,114.07 70.27,113.96 PR9027.2
N25817818: length 2.3
  TOP w0.508: PQ9085.3 136.8,78.37 v1(137.28,78.85) 137.74,79.31 PR9099.2
N25817820: length 5.2
  TOP w0.508: PQ9085.2 134.8,79.42 v1(134.35,79.88) 133.62,79.15 PR9100.2 133.54,78.97 PR9101.1 133.51,77.82 PQ9086.3
N25821251: length 1.6
  TOP w0.508: PR9092.2 136.64,66.32 PC9088.1
N27391730: length 8.7
  BOTTOM w0.102: U2030.AY3 75.71,37.3 75.17,37.3 75,37.13 74.6,37.13 74.38,36.91 74.38,35.67 74.94,35.11 74.94,34.97 75.18,34.73 75.58,34.73 75.73,34.58 75.73,34.32 75.83,34.22 75.83,32.59 76.71,31.71 R2587.1
N27391896: length 5.9
  BOTTOM w0.178: U2030.AY71 75.85,76.32 75.79,76.39 75.79,76.55 75.65,76.69 75.65,77.7 72.77,80.58 R2457.1
N27752748: length 2.4
  BOTTOM w0.102: R737.1 R736.1 196.38,33.97 R450.2
N27760009: length 1.4
  TOP w0.079: R2501.1 95.49,40.08 v4(94.96,40.61)
  BOTTOM w0.102: v4(94.96,40.61) 94.65,40.31 U2030.E8
N27761335: length 0.8
  BOTTOM w0.102: TP2084.1 66.94,32.63 R2546.2
N28053888: length 22.3
  IN1 w0.102: v1(131.13,58.87) 130.72,58.47 130.72,57.92 130.97,57.67 132.16,57.67 133.9,55.93 133.9,54 134.37,53.53 134.93,53.53 136.59,51.87 140.14,51.87 141.38,50.63 141.38,50.36 143.04,48.71 143.04,48.46 143.28,48.22 143.67,48.22 v1(144.08,48.63)
  BOTTOM w0.203: PR7006.1 144.96,49.26 144.77,49.08 144.33,48.63 v1(144.08,48.63) ; v1(131.13,58.87) PR7007.1
N28054550: length 2.4
  BOTTOM w0.305: PR7077.2 132.22,50.72 v1(132.22,50.31) 132.36,50.18 PU7001.5
N28087213:
  vias: v1(25.77,111.92) v1(25.82,111.25)
N28088374: length 1.2
  TOP w0.203: PC7004.1 140.88,54.01 141.4,54.54 PR7008.2
N28089786: length 1.2
  TOP w0.203: PR7040.1 139.38,52.44 139.25,52.3 PR7035.1
N28089833: length 1.9
  TOP w0.203: PR7041.2 138.12,51.07 v1(138.45,50.74) 138.85,50.74 138.9,50.79 PR7036.2
N28100067: length 1.7
  BOTTOM w0.102: CN33.8 69.32,22.11 69.45,22.24 R572.1
N28107941: length 1.2
  TOP w0.508: PC7096.2 119.74,78 PR7095.1
N28108994: length 46.1
  TOP w0.203: v1(135.58,59.51) 135.74,59.35 136.39,59.35 PR7098.1
  IN3 w0.089: v1(114.72,82.68) 115.68,82.68 117.93,80.43 121.17,80.43 122.43,81.68 126.77,81.68 128.88,79.57 128.88,77.48 130.69,75.67 130.69,70.77 133.42,68.04 133.42,63.23 135.46,61.19 135.46,59.63 v1(135.58,59.51)
  BOTTOM w0.203: PR7096.2 112.98,79.06 112.65,79.39 112.65,81.66 113.17,82.18 114.22,82.18 v1(114.72,82.68)
N28123718: length 1.3
  BOTTOM w0.203: PR7033.1 PR7030.2
N28123995: length 2.1
  TOP w0.102: v1(136.09,54.68) 135.92,54.51 PR7031.2
  TOP w0.203: PR7031.2 135.92,53.62 135.47,53.17 PR7034.1
N28124269: length 1
  TOP w0.203: PR7017.1 133.05,54.33 PR7010.2
N28124298: length 1.2
  BOTTOM w0.203: PR7009.2 PR7016.1
N28127437: length 5.3
  TOP w0.102: PR7102.1 138.82,58.91 v1(138.42,59.31)
  TOP w0.381: PR7102.1 139.63,58.52 140.25,58.52 PC7001.1 PR7001.1 PR7002.1 141.75,59.59 141.83,59.67 PR7003.1
N28129355: length 1.2
  TOP w0.203: PR7022.1 PR7027.1
N28129385: length 1.2
  TOP w0.203: PR7023.1 PR7028.1
N28129414: length 2.2
  TOP w0.102: v1(139.78,48.62) 139.93,48.77 139.93,48.9 140.1,49.06 PR7024.1
  TOP w0.203: PR7029.1 139.41,49.26 139.58,49.44 PR7024.1
N28159674: length 24.5
  TOP w0.203: v1(145.02,55.89) 145.12,55.79 145.12,55.18 144.79,54.85 PR7092.1 PR7091.1
  IN3 w0.102: v1(145.02,55.89) 145.05,55.87 145.05,54.09 144.84,53.89 144.84,52.23 144.56,51.95 144.56,50.68 142.65,48.77 142.65,47.08 140.04,44.46 139.81,44.46 139.81,44.46 139.18,44.46 138.08,43.37 134.45,43.37 v1(133.18,42.1)
  BOTTOM w0.102: v1(133.18,42.1) 133.2,42.12 PR7093.1
N28160119: length 1.5
  TOP w0.457: PC7078.2 137.47,40.3 136.78,40.99 PR7087.1
N28160139: length 29.9
  TOP w0.203: PR7090.2 144.31,58.06 144.31,57.57 v1(144.41,57.47)
  IN3 w0.102: v1(131.17,40.6) 131.46,40.89 131.46,41.25 133.78,43.57 138,43.57 139.09,44.66 139.72,44.66 139.72,44.67 139.92,44.67 142.42,47.17 142.42,48.83 144.31,50.72 144.31,51.98 144.64,52.31 144.64,53.97 144.84,54.17 144.84,55.16 144.61,55.38 144.61,56.78 144.41,56.98 v1(144.41,57.47)
  BOTTOM w0.102: PR7088.2 130.58,38.86 130.34,39.1 130.34,39.77 v1(131.17,40.6)
N28379472: length 4.4
  BOTTOM w0.102: v1(74.96,113.27) 74.93,113.3 PC9025.1
  BOTTOM w0.254: PC9025.1 73.99,113.3 73.21,112.52 PR9023.1 72.78,112.52 72.18,111.92 PR9024.1 72.16,110.99 PR9021.2
N28379477: length 2.4
  TOP w0.102: PR9019.1 84.41,107.86 v1(84.57,108.02)
  TOP w0.508: PC9024.1 83.46,107.26 83.58,107.38 PR9019.1
N28380796: length 0.7
  TOP w0.102: PR9017.1 72.83,114.16 TP9000.1
N28380828: length 5
  TOP w0.254: v1(68.49,113.63) 68.49,113.11 68.91,112.68 69.04,112.68 PC9004.1 69.62,111.53 69.65,111.5 PR9002.1
  BOTTOM w0.254: v1(68.49,113.63) 68.49,114.6 PR9000.2
N28414264: length 15.4
  TOP w0.254: PU9000.13 72.73,108.5 72.47,108.25 v1(72.08,108.25)
  IN1 w0.203: v1(72.08,108.25) 73.24,109.41 75.2,109.41 75.35,109.56 75.35,110.88 75.5,111.03 77.35,111.03 78.98,112.66 78.98,115.38 v1(79.34,115.73)
  BOTTOM w0.203: v1(79.34,115.73) 79.74,116.14 PR9274.1
  BOTTOM w0.254: v1(72.08,108.25) 72.04,108.29 PR9033.1
N28607521: length 1.4
  TOP w0.254: PR9034.1 77.05,111.11 76.97,111.03 PU9000.22
N28712850: length 2.9
  BOTTOM w0.102: R2486.2 111.72,62.07 Q2025.2
N29093947: length 3.2
  BOTTOM w0.102: Q16.3 91.85,117.84 R386.1 92.4,117.76 92.56,117.92 Q14.2
N30319022:
  vias: v1(138.47,75.96) v1(139.1,76.02) v1(139.74,75.96) v1(140.37,75.96) v1(141.01,75.96)
N30319317: length 20
  TOP w0.254: PR9263.2 141.82,77.71 v1(142.66,78.55)
  IN2 w0.254: v1(142.66,78.55) 142.84,78.36 142.84,69.45 142.28,68.89 141.51,68.89 141.21,68.59 141.21,67.6 141.88,66.93 141.88,64.64 v1(142.47,64.04)
  BOTTOM w0.254: v1(142.47,64.04) 142.28,64.04 142.05,63.82 PR9094.1 PC9089.2
N30319351: length 2.2
  BOTTOM w0.508: PR9089.1 139.43,71.96 138.35,70.88 PC9079.2
N30442035:
  vias: v1(19.37,25.64)
N30442060: length 4.1
  TOP w0.102: PU6002.4 23.68,27.27 23.76,27.34 PC6051.1 25.02,26.88 25.64,26.88 26,27.24 PR6023.1
N30442062: length 1.9
  TOP w0.102: PU6002.12 20.49,26.87 20.42,26.79 19.85,26.79 19.76,26.88 PC6056.1
N30442063: length 1.9
  TOP w0.102: PC6057.1 19.34,27.73 20.47,27.73 20.53,27.67 PU6002.10
N30442080: length 3.9
  TOP w0.102: PU6002.5 23.39,27.67 23.48,27.57 24.09,27.57 24.56,28.04 PC6053.1 24.56,28.33 PR6028.2 26.05,29.07 v1(26.08,29.1)
N30442084: length 4.8
  TOP w0.102: PU6002.3 24.08,26.87 PC6052.1 24.57,26.38 v1(25.42,25.52) 25.6,25.52 26.48,26.4 PR6027.2
N30568314: length 8.4
  TOP w0.203: PR6014.2 145.71,32.23 PR6010.1 146.22,33.18 146.22,33.62 v1(146.4,33.79) 146.44,33.83 146.44,35.6 145.8,36.24 v1(145.52,36.24) 145.11,35.82 144.4,35.82 PC6024.2
  BOTTOM w0.203: PU6000.12 v1(146.4,33.79)
N30568326: length 1.3
  TOP w0.254: PC6024.1 145.79,35.34 PR6011.1
N30568424: length 7.3
  BOTTOM w0.203: PC6059.2 46.32,14.47 v1(46.47,14.61) 46.69,14.61 46.93,14.37 PR6031.2 47.34,14.4 PR6030.1
  BOTTOM w0.229: PU6003.9 44.22,16.69 44.83,16.08 46.72,16.08 47.34,15.46 PR6030.1
N30568429: length 1
  BOTTOM w0.203: PR6029.1 45.55,13.77 PC6059.1
N30568472: length 5.4
  BOTTOM w0.229: PC6054.1 42.42,15.9 v1(42.36,15.96) 42.36,16.35 42.87,16.86 PU6003.12
  BOTTOM w0.381: PC6054.1 42.08,14.56 41.79,14.27 41.41,14.27 41.07,13.93 41.07,13.27 PR6025.1
N30568498: length 3.4
  TOP w0.102: v1(48.12,12.61) 48.12,13.8 PQ6001.3
  BOTTOM w0.102: v1(48.12,12.61) 48.12,13.36 PR6021.1
N30568535: length 6
  BOTTOM w0.127: PR6007.1 142.88,36.19 v1(142.76,36.07) 142.69,36 142.69,33.91 PR6005.2
  BOTTOM w0.203: PR6004.1 143.52,38.2 PR6003.2 143.06,37.08 PR6007.1
N30795487: length 17.7
  TOP w0.102: R2164.2 105.14,72.64 v1(105.83,71.95) 106.32,71.46 v1(106.69,71.46)
  IN1 w0.089: v1(106.69,71.46) 106.28,71.46 105.73,72.02 103.48,72.02 102.47,71 98.86,71 98.7,70.84 96.89,70.84 96.34,70.3 94.94,70.3 v1(94.43,70.81)
  BOTTOM w0.102: U2030.G65 93.43,72.33 93.76,72 93.76,71.19 94.14,70.81 v1(94.43,70.81)
