# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
DFN8-2X2-5-9P
  rect 0.305x0.94 smd: 1(-0.75,-1.125) 2(-0.25,-1.125) 3(0.25,-1.125) 4(0.75,-1.125) 5(0.75,1.125) 6(0.25,1.125) 7(-0.25,1.125) 8(-0.75,1.125)
  rect 1.118x0.533 smd: 9(0,0)
DFN8-2X2-5-9P-MAX8902B
  rect 0.305x0.889 smd: 1(-0.75,-1.15) 2(-0.25,-1.15) 3(0.25,-1.15) 4(0.75,-1.15) 5(0.75,1.15) 6(0.25,1.15) 7(-0.25,1.15) 8(-0.75,1.15)
  rect 1.295x0.711 smd: 9(0,0)
DFN14-3X2-4-15P-0_85H
  rect 0.203x0.711 smd: 1(-1.2,-1) 2(-0.8,-1) 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 6(0.8,-1) 7(1.2,-1) 8(1.2,1) 9(0.8,1) 10(0.4,1) 11(0,1) 12(-0.4,1) 13(-0.8,1) 14(-1.2,1)
  rect 2.591x0.914 smd: 15(0,0)
DFN1006-3-1X0_6-0_55H-3P
  rect 0.356x0.254 smd: 1(0.325,0.225) 2(0.325,-0.225)
  rect 0.457x0.559 smd: 3(-0.275,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
ESD10-4_1X2-8-11P
  rect 0.203x0.508 smd: 1(-1.8,-0.95) 2(-1,-0.95) 3(-0.2,-0.95) 4(0.6,-0.95) 5(1.4,-0.95) 6(1.8,0.95) 7(1,0.95) 8(0.2,0.95) 9(-0.6,0.95) 10(-1.4,0.95)
  rect 1.397x0.787 smd: 11(-0.4,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
ESD-6X3
  rect 0.152x0.079 smd: 1(0,0)
ESD-6X6
  custom 0.035x0.035 smd: 1(0,0)
FPC-51578-00401-V01-4P-L
  rect 0.305x0.889 smd: 1(-0.75,3.05) 2(-0.25,3.05) 3(0.25,3.05) 4(0.75,3.05)
  rect 0.991x2.007 smd: 5(-2.85,0) 6(2.85,0)
H-C75D75N
  round 1.905 hole 1.905 unplated: (0,0)
H-C98D98N
  round 2.489 hole 2.489 unplated: (0,0)
H-C256I186D102P2
  round 6.502 hole 2.591: 1(0,0)
H-DAVIDOFF-1
  round 5.994 hole 3.2: 1(0,0)
H-S158D158N
  rect 4.013x4.013 hole 4.013 unplated: (0,0)
H-TIC157BC276D150P2
  round 7.01 hole 3.81: 1(0,0)
HDMI-10591-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
HG-C276D126P2
  round 7.01 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
HG-C354I158D118P2
  round 8.992 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
HG-C354I274D220P2
  round 8.992 hole 5.588: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.683) 3(2.604,2.604) 4(3.683,0) 5(2.604,-2.604) 6(0,-3.683) 7(-2.604,-2.604) 8(-3.683,0) 9(-2.604,2.604)
HG-O335X315D252X232P2
  oval 8.509x8.001 hole 6.401x5.893: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.556) 3(2.514,2.514) 4(3.683,0) 5(2.514,-2.514) 6(0,-3.556) 7(-2.514,-2.514) 8(-3.683,0) 9(-2.514,2.514)
HG-ZAU-1
  custom 2.25x2.25 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.048) 3(2.155,2.155) 4(3.048,0) 5(2.155,-2.155) 6(0,-3.048) 7(-2.155,-2.155) 8(-3.048,0) 9(-2.155,2.155)
HG-ZAU-2
  custom 2.15x2.15 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
LGA16-3X3-5
  rect 0.305x0.94 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 9(1,1.525) 10(0.5,1.525) 11(0,1.525) 12(-0.5,1.525) 13(-1,1.525)
  rect 0.94x0.305 smd: 6(1.525,-0.5) 7(1.525,0) 8(1.525,0.5) 14(-1.525,0.5) 15(-1.525,0) 16(-1.525,-0.5)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
NGFF-NASE0-S6701-TS40-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TSH4-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
POWER-3X3-65-5P
  rect 0.508x0.406 smd: 1(1.5,-0.975) 2(1.5,-0.325) 3(1.5,0.325) 4(1.5,0.975)
  custom 0.588x0.588 smd: 5(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-26P-0_8H
  rect 0.279x0.991 smd: 1(-1,-1.9) 2(-0.5,-1.9) 3(0,-1.9) 4(0.5,-1.9) 5(1,-1.9) 11(1,1.9) 12(0.5,1.9) 13(0,1.9) 14(-0.5,1.9) 15(-1,1.9)
  rect 0.991x0.279 smd: 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0) 9(1.9,0.5) 10(1.9,1) 16(-1.9,1) 17(-1.9,0.5) 18(-1.9,0) 19(-1.9,-0.5) 20(-1.9,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.75,-0.75) 23(0.75,-0.75) 24(0.75,0.75) 25(-0.75,0.75) 26(0,0)
QFN12-3X3-45-0_6H
  rect 0.229x0.787 smd: 1(-0.619,-1.5) 6(-0.619,1.5)
  rect 0.229x1.346 smd: 2(0.101,-1.225) 3(1.001,-1.225)
  rect 0.229x2.286 smd: 4(0.551,0.76)
  rect 0.229x2.261 smd: 5(-0.169,0.76)
  rect 0.787x0.229 smd: 7(-1.5,1.125) 8(-1.5,0.675) 9(-1.5,0.225) 10(-1.5,-0.225) 11(-1.5,-0.675) 12(-1.5,-1.125)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN18-2X2-4-19P-0_4H-SMT
  custom 0.05x0.05 smd: 1(-0.8,-1.178) 5(0.8,-1.178) 6(1.178,-0.6) 9(1.178,0.6) 10(0.8,1.178) 14(-0.8,1.178) 15(-1.178,0.6) 18(-1.178,-0.6)
  rect 0.203x0.864 smd: 2(-0.4,-1.178) 3(0,-1.178) 4(0.4,-1.178) 11(0.4,1.178) 12(0,1.178) 13(-0.4,1.178)
  rect 0.864x0.203 smd: 7(1.178,-0.2) 8(1.178,0.2) 16(-1.178,0.2) 17(-1.178,-0.2)
  rect 0.889x0.889 smd: 19(0,0)
QFN20-4X3-5-27P
  rect 0.203x0.61 smd: 1(-1.25,-1.4) 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 6(1.25,-1.4) 11(1.25,1.4) 12(0.75,1.4) 13(0.25,1.4) 14(-0.25,1.4) 15(-0.75,1.4) 16(-1.25,1.4)
  rect 0.61x0.203 smd: 7(1.9,-0.75) 8(1.9,-0.25) 9(1.9,0.25) 10(1.9,0.75) 17(-1.9,0.75) 18(-1.9,0.25) 19(-1.9,-0.25) 20(-1.9,-0.75)
  rect 2.591x1.6 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-1,-0.5) 23(0,-0.5) 24(1,-0.5) 25(1,0.5) 26(0,0.5) 27(-1,0.5)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN24-4X4-5-25P-RT8813D
  custom 0.075x0.075 smd: 1(-1.25,-1.975) 6(1.25,-1.975) 7(1.975,-1.25) 12(1.975,1.25) 13(1.25,1.975) 18(-1.25,1.975) 19(-1.975,1.25) 24(-1.975,-1.25)
  rect 0.305x0.838 smd: 2(-0.75,-1.975) 3(-0.25,-1.975) 4(0.25,-1.975) 5(0.75,-1.975) 14(0.75,1.975) 15(0.25,1.975) 16(-0.25,1.975) 17(-0.75,1.975)
  rect 0.838x0.305 smd: 8(1.975,-0.75) 9(1.975,-0.25) 10(1.975,0.25) 11(1.975,0.75) 20(-1.975,0.75) 21(-1.975,0.25) 22(-1.975,-0.25) 23(-1.975,-0.75)
  rect 2.54x2.54 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN30-4X4-4-32P
  custom 0.05x0.05 smd: 1(-1.4,-2) 7(1.4,-2) 8(2,-1.4) 15(2,1.4) 16(1.4,2) 22(-1.4,2) 23(-2,1.4) 30(-2,-1.4)
  rect 0.203x0.787 smd: 2(-0.6,-2) 3(-0.2,-2) 4(0.2,-2) 5(0.6,-2) 6(1,-2) 17(1,2) 18(0.6,2) 19(-0.2,2) 20(-0.6,2) 21(-1,2)
  rect 0.787x0.203 smd: 9(2,-1) 10(2,-0.6) 11(2,-0.2) 12(2,0.2) 13(2,0.6) 14(2,1) 24(-2,1) 25(-2,0.6) 26(-2,0.2) 27(-2,-0.2) 28(-2,-0.6) 29(-2,-1)
  rect 1.092x2.591 smd: 31(-0.75,0)
  rect 1.194x2.591 smd: 32(0.7,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN32-5X5-5-37P-0_85H
  rect 0.279x0.838 smd: 1(-1.75,-2.55) 2(-1.25,-2.55) 3(-0.75,-2.55) 4(-0.25,-2.55) 5(0.25,-2.55) 6(0.75,-2.55) 7(1.25,-2.55) 8(1.75,-2.55) 17(1.75,2.55) 18(1.25,2.55) 19(0.75,2.55) 20(0.25,2.55) 21(-0.25,2.55) 22(-0.75,2.55) 23(-1.25,2.55) 24(-1.75,2.55)
  rect 0.838x0.279 smd: 9(2.55,-1.75) 10(2.55,-1.25) 11(2.55,-0.75) 12(2.55,-0.25) 13(2.55,0.25) 14(2.55,0.75) 15(2.55,1.25) 16(2.55,1.75) 25(-2.55,1.75) 26(-2.55,1.25) 27(-2.55,0.75) 28(-2.55,0.25) 29(-2.55,-0.25) 30(-2.55,-0.75) 31(-2.55,-1.25) 32(-2.55,-1.75)
  rect 3.759x3.759 smd: 33(0,0)
  round 0.508 hole 0.254: 34(-0.6,-0.6) 35(0.6,-0.6) 36(0.6,0.6) 37(-0.6,0.6)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN48-6X6-4-49P-EXC7900-SG11
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.293x4.293 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RC3720-SMT
  rect 3.759x1.016 smd: 1(0,1.008) 2(0,-1.008)
RJ45-2RJ1622-001111F-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.803x2.616 hole 0.787x1.6: 9(8.4,-7.8) 10(8.4,0) 11(-8.4,-7.8) 12(-8.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON10-2_5X1-5-0_55H
  rect 0.305x0.559 smd: 1(-1,-0.385) 2(-0.5,-0.385) 4(0.5,-0.385) 5(1,-0.385) 6(1,0.385) 7(0.5,0.385) 9(-0.5,0.385) 10(-1,0.385)
  rect 0.33x0.559 smd: 3(0,-0.385) 8(0,0.385)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_8-95-6P-1_1H
  rect 1.092x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,0) 6(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT363-2_1-65-6P-1_1H
  rect 1.219x0.254 smd: 1(1.038,-0.65) 2(1.038,0) 3(1.038,0.65) 4(-1.038,0.65) 5(-1.038,0) 6(-1.038,-0.65)
SPAD-C315NP
  round 8.001 smd: 1(0,0)
SPAD-C354NP
  round 8.992 smd: 1(0,0)
SPAD-DAVIDOFF-1
  custom 1.275x1.275 smd: 1(0,0)
SPAD-RE197X138NP
  rect 5.004x3.505 smd: 1(0,0)
SPAD-RE209X315NP
  rect 5.309x8.001 smd: 1(0,0)
SW-NDT016-G1A-KKKT-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
UB3-USB-097-1R09HG-9P
  round 1.295 hole 0.813: 1(3.5,7.2) 2(1,7.2) 3(-1,7.2) 4(-3.5,7.2) 5(-4,5.7) 6(-2,5.7) 7(0,5.7) 8(2,5.7) 9(4,5.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.45) 11(-6.4,6.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0) 13(7.85,-3)
UB31-C12321-1242D-L-24P
  round 0.66 hole 0.66 unplated: (-3.45,5.8)
  oval 0.838x0.66 hole 0.838x0.66 unplated: (3.45,5.8)
  rect 0.508x0.305 smd: 1(-3.2,6.49) 2(-1,6.49) 3(1,6.49) 4(3.2,6.49)
  oval 0.991x1.6 hole 0.508x1.092: 5(-4.475,6.2)
  oval 0.889x1.499 hole 0.508x1.092: 6(4.475,6.2)
  oval 0.991x2.007 hole 0.508x1.499: 7(-6.075,3.865) 8(6.075,3.865) 9(-6.075,0) 10(6.075,0)
  rect 0.305x0.61 smd: A1(-2.75,5.74) A2(-2.25,5.74) A3(-1.75,5.74) A4(-1.25,5.74) A5(-0.75,5.74) A6(-0.25,5.74) A7(0.25,5.74) A8(0.75,5.74) A9(1.25,5.74) A10(1.75,5.74) A11(2.25,5.74)
  custom 0.076x0.076 smd: A12(2.75,5.74)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,4.665) B12(-3.2,4.665)
  round 0.61 hole 0.406: B2(2.5,3.765) B3(1.7,3.765) B4(1.3,4.665) B5(0.85,3.765) B6(0.4,4.665) B7(-0.4,4.665) B8(-0.85,3.765) B9(-1.3,4.665) B10(-1.7,3.765) B11(-2.5,3.765)
unnamed
  round 1.016 smd: 1(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1V8_AON_S: PC9057.1 PC9058.1 PR9068.1 PU9002.8 PU9002.9
1V8_MAIN_EN_N17: R374.1 U8.F9
3V_1V8_MAIN_EN: PQ9083.2 PR9012.2 PR9072.1 PR9105.1 PR25541.1 R374.2 R403.1 R25561.2
3V_MAIN_EN_N16: R25561.1 U8.A3
3V_MAIN_PWGD: PR9278.1 PR9282.1 Q6551.3 R25538.2 R25539.1
5V_HSMBCK: D14.1 R490.1
5V_HSMBDT: D14.2 R491.1
8813VID: PR9015.2 PR9017.2 PU9000.5
8813VOUT1: PC9027.1 PC9028.1 PR9028.1 PU9000.11(VSNS)
8813VREF: PC9023.1 PR9021.1 PR9033.2 PU9000.8
+1.2VSUS: C2088.1 C2089.1 C2090.2 C2091.1 C2094.1 C2095.2 C2106.1 C2107.2 C2110.1 C2132.1 C2133.1 C2134.1 C2135.1 C2136.2 C2137.1 C2138.1 C2139.1 C2146.2 C2153.1 C2157.1 C2160.1 C2161.1 C2162.1 C2166.1 C2167.2 C2171.1 C2187.1 C2191.2 C2209.1 C2212.2 C2228.2 C2230.2 C2238.1 C2249.2 C2252.1 C2265.2 C2266.2 C2267.1 C2269.1 C2278.1 C2279.1 C2293.1 C2294.1 C2298.1 C2302.1 C2305.1 C2306.1 C2310.1 C2313.1 C2314.1 C2315.1 C2316.1 C2317.1 C2318.1 C2334.1 C2339.1 C2535.1 JDIM2000.12 JDIM2000.33 JDIM2000.54 JDIM2000.75 JDIM2000.96 JDIM2000.111 JDIM2000.112 JDIM2000.117 JDIM2000.118 JDIM2000.123 JDIM2000.124 JDIM2000.129 JDIM2000.130 JDIM2000.135 JDIM2000.136 JDIM2000.141 JDIM2000.142 JDIM2000.147 JDIM2000.148 JDIM2000.153 JDIM2000.154 JDIM2000.159 JDIM2000.160 JDIM2000.163 JDIM2000.178 JDIM2000.199 JDIM2000.220 JDIM2000.241 PC162.1 PC285.2 PC9065.1 PC9066.1 PJ7001.2 PQ9008.5 PU26.24 Q2023.2 R2140.1 R2167.1 R2168.1 R2169.1 R2172.1 R2173.1 R2176.1 R2177.1 R2178.1 R2179.1 R2180.1 R2185.1 R2187.1 R2198.1 R2220.2 R2526.1 U2009.A1 U2009.A9 U2009.B3 U2009.B9 U2009.C1 U2009.D1 U2009.D9 U2009.E2 U2009.E7 U2009.F2 U2009.F8 U2009.G1 U2009.G7 U2009.G9 U2009.J1 U2009.J2 U2009.J8 U2009.J9 U2009.L1 U2009.L9 U2009.R1 U2009.T9 U2010.A1 U2010.A9 U2010.B3 U2010.B9 U2010.C1 U2010.D1 U2010.D9 U2010.E2 U2010.E7 U2010.F2 U2010.F8 U2010.G1 U2010.G7 U2010.G9 U2010.J1 U2010.J2 U2010.J8 U2010.J9 U2010.L1 U2010.L9 U2010.R1 U2010.T9 U2011.A1 U2011.A9 U2011.B3 U2011.B9 U2011.C1 U2011.D1 U2011.D9 U2011.E2 U2011.E7 U2011.F2 U2011.F8 U2011.G1 U2011.G7 U2011.G9 U2011.J1 U2011.J2 U2011.J8 U2011.J9 U2011.L1 U2011.L9 U2011.R1 U2011.T9 U2012.A1 U2012.A9 U2012.B3 U2012.B9 U2012.C1 U2012.D1 U2012.D9 U2012.E2 U2012.E7 U2012.F2 U2012.F8 U2012.G1 U2012.G7 U2012.G9 U2012.J1 U2012.J2 U2012.J8 U2012.J9 U2012.L1 U2012.L9 U2012.R1 U2012.T9 U2030.AU23 U2030.AU28 U2030.AU35 U2030.AU42 U2030.BB23 U2030.BB32 U2030.BB41 U2030.BB47 U2030.BB51
+1.5V: PJ3008.2 Q21.2 R449.1 R462.2 R2280.2
+1.05V_LAN: C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 R25503.2 U24.3 U24.8 U24.22 U24.30
+1.05V_LAN_REGOUT: C20000.1 R25503.1 U24.24
+1.8V: PQ9.1(S) PR9227.1 R448.1 R733.2 R25332.1 R25590.1
+1.8V_DEEP_SUS: R180.1 R664.1 U35.5(VCC) U36.5(VCC)
+1.8V_S5: PJ9005.2 PQ9.3 PR9281.2 R2298.2 R2299.2 R2593.1 R9041.1 R9048.1
+1.8V_SW: C6544.1 C6545.1 C6546.1 EC6500.1 R9048.2 R25273.2 R25274.2 R25276.2 R25278.2 R25332.2 U6502.12(VDD)
+1.35V_GFX: C438.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C471.1 C472.1 C473.1 C474.1 C475.1 C476.1 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.1 C485.1 C486.1 C487.1 C488.1 C489.1 C490.1 C491.2 C492.2 C493.2 C494.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.1 C501.1 C502.1 C503.1 C504.1 PJ9002.1 PR9099.1 R314.2 R316.1 R318.1 R321.1 R322.1 R407.1 R25284.1 U8.B26 U8.C25 U8.E23 U8.E26 U8.F14 U8.F21 U8.G13 U8.G14 U8.G15 U8.G16 U8.G18 U8.G19 U8.G20 U8.G21 U8.H24 U8.H26 U8.J21 U8.K21 U8.L22 U8.L24 U8.L26 U8.M21 U8.N21 U8.R21 U8.T21 U8.V21 U8.W21 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM2.B1 VRAM2.B3 VRAM2.B12 VRAM2.B14 VRAM2.C5 VRAM2.C10 VRAM2.D1 VRAM2.D3 VRAM2.D11 VRAM2.D12 VRAM2.D14 VRAM2.E5 VRAM2.E10 VRAM2.F1 VRAM2.F3 VRAM2.F12 VRAM2.F14 VRAM2.G1 VRAM2.G2 VRAM2.G4 VRAM2.G11 VRAM2.G13 VRAM2.G14 VRAM2.H3 VRAM2.H12 VRAM2.K3 VRAM2.K12 VRAM2.L1 VRAM2.L2 VRAM2.L4 VRAM2.L11 VRAM2.L13 VRAM2.L14 VRAM2.M1 VRAM2.M3 VRAM2.M12 VRAM2.M14 VRAM2.N5 VRAM2.N10 VRAM2.P1 VRAM2.P3 VRAM2.P11 VRAM2.P12 VRAM2.P14 VRAM2.R5 VRAM2.R10 VRAM2.T1 VRAM2.T3 VRAM2.T12 VRAM2.T14
+1V8_MAIN_EN_G: PQ9083.3 PQ9084.2 PR9102.2 PR9104.1
+1V_S5: C2268.2 C2274.2 C2276.2 C2280.2 C2281.2 C2282.2 C2286.2 C2291.2 C2292.2 C2296.2 C2299.2 C2307.1 C2320.1 C2578.1 C2581.1 C2584.2 C2586.2 PJ3005.1 PQ11.3 PQ35.5 R2490.2 R2501.2 U2030.A10 U2030.A14 U2030.AB17 U2030.AB19 U2030.AB20 U2030.AF18 U2030.AF19 U2030.AF20 U2030.AF21 U2030.AK20 U2030.K15 U2030.K17 U2030.K19 U2030.L15 U2030.L19 U2030.L21 U2030.N15 U2030.N16 U2030.N17 U2030.N18 U2030.N20 U2030.P15 U2030.P16 U2030.P18 U2030.T1 U2030.T19 U2030.T20 U2030.V15 U2030.V20 U2030.V21 U2030.Y18
+1V_S5_ON: PR274.2 U37.95
+1V_SUS: PC83.2 PQ11.1(S) PR105.1 PR7102.2 R2499.1 R2506.1
+1V_VCCST: C2543.1 C2559.2 C2579.2 C20023.2 Q2024.3 R2229.2 R2458.2 R2459.1 R2461.1 R2476.1 R2478.2 R2479.1 R2482.1 R2484.1 R2487.1 R2499.2 U2029.5 U2030.A18
+2.5V_SUS: C2092.2 C2093.1 C2100.1 C2101.2 C2102.1 C2124.1 C2131.1 C2158.2 C2159.1 C2206.1 C2210.2 C2251.1 C2311.1 C2319.2 C2322.1 C2349.1 C2351.1 JDIM2000.257 JDIM2000.259 PR9267.1 U2009.B1 U2009.R9 U2010.B1 U2010.R9 U2011.B1 U2011.R9 U2012.B1 U2012.R9
+3V: C452.2 C546.2 C559.1 C618.2 C619.1 C628.2 C1687.1 C1688.1 C1689.1 C1690.1 C1691.1 C1692.1 C1693.1 C2297.1 C2300.1 C2369.2 C20006.2 CN35.29 CN35.30 CN35.31 EC10.1 EC11.1 PR106.1 PR275.1 PR6416.1 PR7068.1 PR9075.1 PR9088.1 PR9245.2 PR9255.1 PR9265.2 PR9283.1 Q41.2 Q41.5 Q2026.2 Q2026.5 Q6507.2 Q6531.2 Q6533.2 R134.2 R340.2 R378.2 R385.1 R386.2 R439.1 R440.1 R452.2 R455.1 R460.2 R494.1 R502.1 R509.1 R576.1 R582.1 R638.2 R641.2 R732.2 R741.1 R742.1 R746.2 R747.2 R1239.2 R2208.1 R2269.2 R2273.1 R2274.1 R2278.1 R2281.1 R2282.1 R2286.1 R2287.1 R2288.2 R2301.1 R2483.2 R2533.2 R2542.1 R2544.1 R2549.2 R2554.1 R2555.1 R2557.1 R2603.1 R2604.2 R2610.2 R2612.1 R2613.2 R2614.2 R2615.1 R2648.2 R2650.2 R2661.2 R2666.2 R25271.2 R25294.1 R25307.1 R25312.2 R25346.1 R25348.2 R25367.2 R25372.1 R25444.2 R25445.2 R25459.1 R25465.1 R25474.1 R25475.2 R25482.1 R25486.2 R25502.2 R25519.2 R25537.2 R25548.2 R25558.2 U11.5 U19.4 U19.5 U23.1 U23.18(VDD#2) U23.22 U2019.5(VCC) U6505.5(VCC)
+3V3_TPM: C740.2 C741.1 C742.1 C744.1 R580.2 R25346.2 U33.8 U33.22
+3V3_TPM_VSB: C743.1 C745.2 R25348.1 U33.1(VSB)
+3V3AUX: C375.2 C380.2 C386.2 L4.2 U8.F11
+3V_CCD_PWR1_C: CN29.32 CN29.33 R25459.2
+3V_DMIC: CN38.4 R25486.1
+3V_EC: C1189.1 R25307.2 R25317.2 U37.11
+3V_GFX_+1V8_GFX_MAIN: L4.1 L7.1 L8.1 PR9067.1 PR9103.1 PR25542.1 R299.2 R25507.1 R25508.1 R25522.1 R25538.1 R25547.2 R25563.2 R25564.2 R25566.1 R25568.1 R25575.1 R25576.2 R25581.2 R25582.1 R25583.1 R25584.2 R25588.1
+3V_LAN: C641.1 C642.1 C643.1 C644.1 R25296.1 U24.11 U24.23(VDDREG) U24.32
+3V_LDO_EC: D63.1(CATHODE) PR6017.2 R359.1 R361.2 R369.2 R2630.2 R25300.2 R25306.1 R25309.2 R25313.2 R25314.2
+3V_MAIN_1V8_AON: PR9009.1 PR9018.1 PR9068.2 PR9076.2 R297.2 R330.2 R362.1 R364.1 R365.1 R382.2 R25322.2 R25520.2 R25535.1 R25540.2 R25553.1 R25565.1 R25567.1 R25574.1 R25577.2 R25579.1 R25580.2 R25585.2
+3V_PCH_ME: C2608.2 R2620.1 R2624.2 R2627.2 R2630.1 R2631.1 U2031.8(VCC)
+3V_RTC: C2420.1 D2012.3(COMMON ANODE) R2214.2 R2216.2 R2359.1 R2360.1 R25310.1
+3V_RTC_1: D2012.1 R2378.2
+3V_RTC_2: D2012.2 R2357.1 R2358.2
+3V_S5: C695.1 C2321.2 C2335.2 CN33.1 PC242.1 PC302.1 PC571.1 PC572.1 PR9244.1 PU26.3 PU3003.4(VIN) PU3004.3(VIN) Q27.2 Q27.5 Q29.2 Q6505.2 R36.2 R38.2 R383.2 R559.2 R562.2 R566.1 R567.1 R574.2 R2212.1 R2225.1 R2289.2 R2290.2 R2300.1 R2303.1 R2304.2 R2313.2 R2314.2 R2315.2 R2316.2 R2317.2 R2318.2 R2448.2 R2508.1 R2514.1 R2516.1 R2518.2 R2519.2 R2522.1 R2536.1 R2551.2 R2562.2 R2571.1 R2573.2 R2574.2 R2575.2 R2576.2 R2578.2 R2579.2 R2586.2 R2588.2 R2589.2 R2590.2 R2591.1 R2592.1 R2594.2 R2595.2 R2596.2 R2597.2 R2598.2 R2599.2 R2600.2 R2601.2 R2602.2 R2605.1 R2606.1 R2607.1 R2627.1 R2667.2 R6504.1 R6505.1 R6506.1 R6508.1 R6510.1 R6515.1 R6516.1 R25296.2 R25304.2 R25317.1 R25330.1 R25413.1 R25415.1 R25437.1 R25472.2 R25477.1 R25480.1 R25586.1 U2014.5(VCC) U2015.5
+3V_SSD: C785.2 C786.2 C2616.2 CN16.2 CN16.4 CN16.12 CN16.14 CN16.16 CN16.18 CN16.70 CN16.72 CN16.74 EC9.2 R649.1 R2661.1
+3V_WLAN_P: C800.1 C801.1 C802.1 C804.1 C805.2 C2609.1 C2610.1 C2611.1 C2612.1 CN17.2 CN17.4 CN17.72 CN17.74 Q33.2 Q63.2 R651.1 R652.1 R671.2 R672.2 R2666.1 R2667.1
+3VLCD_CON: C560.1 C561.1 C562.1 R25458.1 U19.1(VOUT)
+3VLCD_CON_R: C543.2 C544.2 CN29.34 CN29.35 CN29.36 R25456.1 R25458.2
+3VLCD_CON_R_C: CN29.37 R25456.2
+3VPCU: C842.1 CN24.2 CN24.3 CN35.32 HE1.2(VCC) PC6015.1 PC6016.1 PJ6001.1 PR9.2 PR15.2 PR18.2 PR204.2 PR6003.1 PR9275.2 PU6001.1 PU6001.2 PU6001.6 PU6001.7 R736.2 R2291.2 R2357.2 R25295.1 R25323.2 R25368.2 R25370.1 R25505.2
+3VPCU_EC: C6565.1 C6569.1 C6570.1 C6574.1 C6575.1 C6577.1 C6578.1 L29.1 L30.2 R25306.2 U37.26 U37.50 U37.92 U37.114 U37.121
+3VPCU_ECPLL: C6573.1 L30.1 U37.127
+3VSPI: R583.2 R586.2
+5V: C545.1 C550.1 C596.1 C597.2 C734.1 C770.1 C771.1 C772.1 L15.1 L16.1 PR126.1 PR9249.2 Q30.1(S) Q6508.3 R575.1 R579.1 R639.1 R25373.1 R25462.1 R25504.1
+5V_FAN: FAN3.1 R575.2
+5V_HDMIC: C6560.1 CN37.18 D14.3(COMMON ANODE) D50.2 Q6508.1(VOUT)
+5V_KB: C736.1 C737.2 CN13.2 CN13.4 Q30.3
+5V_PVDD: C574.1 C575.1 C576.1 C577.1 L15.2 U20.41 U20.46
+5V_S5: C512.1 C524.1 C6502.1 C6503.1 C6504.1 C6547.1 C6548.1 C6549.1 PR256.2 PR7064.1 PR7065.1 PR7069.1 PR7080.1 PR7103.2 PR7108.1 PR7112.1 PR7116.1 PR9001.1 PR9013.1 PR9074.1 PR9087.1 PR9091.2 PR9100.1 PR9248.1 R6507.1 R6603.2 U15.5 U18.5 U6503.2 U6503.3 U6503.4 U6503.5(VAUX)
+5VA: C568.1 C569.1 C598.2 C599.1 L16.2 U20.26
+5VODD: C773.2 C774.2 C775.2 C776.2 C777.1 C778.1 CN15.9 CN15.10 CN15.11 CN15.12 CN15.13 CN15.14 CN15.15 R639.2
+5VPCU: C508.1 PC6036.1 PC6037.1 PC9059.1 PC9072.1 PJ6003.1 PR98.2 PR104.1 PR6013.1 PR6023.2 PU6002.1 PU6002.2 PU6002.6 PU6002.7 PU9002.4 PU9003.1(VCC) R417.1 R418.1 R737.2 U14.1
+A3VPCU: C6566.1 L29.2 U37.74
+V3A_LX: PC6001.2 PL6000.1 PR6001.1 PU6000.2 PU6000.3
+V3A_LX_R: PC6006.1 PR6001.2
+V3A_OUT: PC6008.1 PC6009.1 PC6010.1 PC6011.1 PC6012.1 PC6013.1 PC6014.1 PJ6001.2 PL6000.2 PR6008.1
+V5P5A_LX: PL6001.1 PR6018.1 PR6019.1 PU6003.2 PU6003.3
+V5P5A_LX_R: PC6038.1 PR6019.2
+V5P5A_OUT: PC6044.1 PC6045.1 PC6046.1 PC6047.1 PC6048.1 PC6049.1 PC6050.1 PJ6003.2 PL6001.2 PR6026.2
+VCC_CORE: C2175.2 C2176.2 C2177.2 C2178.2 C2179.1 C2182.2 C2183.2 C2184.2 C2185.2 C2186.2 C2189.2 C2190.2 C2192.2 C2193.2 C2194.2 C2195.2 C2196.1 C2197.1 C2198.2 C2199.2 C2200.2 C2201.2 C2202.2 C2203.2 C2204.1 C2205.1 C2207.2 C2208.2 C2211.2 C2213.2 C2214.1 C2215.1 C2216.2 C2217.2 C2218.2 C2219.2 C2220.2 C2221.1 C2222.2 C2223.2 C2224.1 C2225.2 C2226.2 C2227.2 C2231.2 C2232.1 C2233.1 C2234.2 C2235.2 C2253.1 C2254.2 C2256.1 C2257.1 C2270.2 C2277.1 C2285.2 C2290.2 C2565.2 C2566.2 C2567.2 C2568.2 C2569.2 C2570.2 PC7039.2 PC7040.1 PC7041.1 PC7042.1 PC7043.1 PC7044.1 PC7045.1 PC7057.2 PC7058.1 PC7059.1 PC7060.1 PC7061.1 PC7062.1 PL7000.2 PL7001.2 PR7043.2 PR7074.1 PR7083.1 R2181.2 R2182.1 R2183.1 R2184.2 R2493.1 U2030.A30 U2030.A34 U2030.A39 U2030.A44 U2030.AK33 U2030.AK35 U2030.AK37 U2030.AK38 U2030.AK40 U2030.AL33 U2030.AL37 U2030.AL40 U2030.AM32 U2030.AM33 U2030.AM35 U2030.AM37 U2030.AM38 U2030.G30 U2030.G32 U2030.G33 U2030.G35 U2030.G37 U2030.G38 U2030.G40 U2030.G42 U2030.J30 U2030.J33 U2030.J37 U2030.J40 U2030.K33 U2030.K35 U2030.K37 U2030.K38 U2030.K40 U2030.K42 U2030.K43
+VCC_V3A: PC6022.1 PU6000.9
+VCC_V5P5A: PC6058.1 PU6003.11
+VCCATS_1P8: C2352.1 R2298.1 U2030.AA1
+VCCDSW: C2347.2 R2291.1 R2303.2 U2030.AD17 U2030.AD18 U2030.AJ17
+VCCDSW_1P0: C2602.1 U2030.AL1
+VCCGT: C2108.2 C2109.2 C2111.2 C2112.2 C2113.2 C2115.2 C2119.2 C2120.2 C2121.2 C2122.2 C2126.2 C2127.2 C2128.2 C2130.2 C2140.2 C2141.1 C2142.2 C2143.2 C2144.2 C2145.2 C2147.2 C2148.2 C2149.2 C2150.2 C2151.2 C2152.2 C2155.2 C2168.2 C2531.1 C2532.1 C2533.1 C2534.1 C2536.1 C2537.1 C2538.2 C2539.2 C2540.2 C2544.2 C2545.2 C2546.1 PC7087.2 PC7088.1 PC7089.1 PC7090.1 PC7091.1 PC7092.1 PC7093.1 PC7094.1 PC7095.1 PL7003.2 PR7050.2 PR7097.1 R2165.1 R2170.1 R2174.2 R2175.1 R2456.1 U2030.A58 U2030.A62 U2030.A66 U2030.AA63 U2030.AA64 U2030.AA66 U2030.AA67 U2030.AA69 U2030.AA70 U2030.AA71 U2030.AC64 U2030.AC65 U2030.AC66 U2030.AC67 U2030.AC68 U2030.AC69 U2030.AC70 U2030.AC71 U2030.J53 U2030.J55 U2030.J56 U2030.J58 U2030.J60 U2030.K53 U2030.K55 U2030.K56 U2030.K58 U2030.K60 U2030.L62 U2030.L63 U2030.L64 U2030.L65 U2030.L66 U2030.L67 U2030.L68 U2030.L69 U2030.L70 U2030.L71 U2030.M62 U2030.N63 U2030.N64 U2030.N66 U2030.N67 U2030.N69 U2030.N70 U2030.N71 U2030.R63 U2030.R64 U2030.R65 U2030.R66 U2030.R67 U2030.R68 U2030.R69 U2030.R70 U2030.R71 U2030.T62 U2030.U65 U2030.U68 U2030.U71 U2030.W63 U2030.W64 U2030.W65 U2030.W66 U2030.W67 U2030.W68 U2030.W69 U2030.W70 U2030.W71 U2030.Y62
+VCCGT_+VCORE: R2174.1 R2181.1 R2184.1 U2030.A48 U2030.A53 U2030.J43 U2030.J45 U2030.J46 U2030.J48 U2030.J50 U2030.J52 U2030.K48 U2030.K50
+VCCGTX_1: R2165.2 TP2024.1 U2030.AK52 U2030.AK53 U2030.AK55 U2030.AK56 U2030.AK58 U2030.AK60 U2030.AK70 U2030.AL53 U2030.AL56 U2030.AL60 U2030.AM53 U2030.AM56 U2030.AM58 U2030.AU58 U2030.AU63 U2030.BB57 U2030.BB66
+VCCGTX_+VCORE: C2154.1 C2156.1 C2169.1 C2170.1 C2172.1 R2175.2 R2182.2 R2183.2 U2030.AK42 U2030.AK43 U2030.AK45 U2030.AK46 U2030.AK48 U2030.AK50 U2030.AL43 U2030.AL46 U2030.AL50 U2030.AM48 U2030.AM50 U2030.AM52
+VCCHDA: C2348.2 R2280.1 R2282.2 U2030.AJ19
+VCCIO: C2174.2 C2181.2 C2229.2 C2240.1 C2246.2 C2248.1 C2354.2 C2355.2 C2541.2 C2562.2 PC236.2 PC756.1 PQ35.1 PQ35.2 PQ35.3(S3) PR22.2 PR111.1 PR7011.2 R2171.2 R2209.1 R2451.1 R2454.2 U2030.AK28 U2030.AK30 U2030.AL30 U2030.AL42 U2030.AM28 U2030.AM30 U2030.AM42
+VCCPGPPA: C2362.1 R2318.1 U2030.AK15
+VCCPGPPB: C2361.1 R2317.1 U2030.AG15
+VCCPGPPC: C2358.1 R2314.1 U2030.Y16
+VCCPGPPD: C2357.1 R2313.1 U2030.Y15
+VCCPGPPE: C2359.1 R2315.1 U2030.T16
+VCCPGPPF: R2299.1 U2030.AF16
+VCCPGPPG: C2360.1 R2316.1 U2030.AD15
+VCCPLL: C2580.2 C20022.2 R2506.2 U2030.K20 U2030.K21
+VCCPRIM_3P3: C2275.2 R2300.2 U2030.AJ21 U2030.V19
+VCCPRTC: C2295.1 C2301.2 R2214.1 U2030.AK19 U2030.BB14
+VCCPRTCPRIM_3P3: C2601.2 C2603.1 R2586.1 U2030.AK17
+VCCPSPI: R2212.2 U2030.AJ16
+VCCRTC_2: CN1.1 R2378.1
+VCCSA: C2237.1 C2239.1 C2241.1 C2242.1 C2243.1 C2244.1 C2245.1 C2258.2 C2259.2 C2260.2 C2261.2 C2262.2 C2263.2 C2264.2 C2271.1 C2272.1 C2273.1 C2283.1 C2284.1 C2287.1 PC7072.1 PC7073.1 PC7074.1 PC7075.1 PC7076.1 PC7077.1 PL7002.2 PR7057.2 PR7089.1 R2193.1 U2030.AK23 U2030.AK25 U2030.G23 U2030.G25 U2030.G27 U2030.G28 U2030.J22 U2030.J23 U2030.J27 U2030.K23 U2030.K25 U2030.K27 U2030.K28 U2030.K30
+VCCSTG: C2308.2 C2309.2 R2209.2 U2030.A22 U2030.G20
+VDD33_12: C371.1 C376.1 C378.1 R25565.2 R25566.2 U8.G10 U8.G12
+VDD33_34: C392.1 C394.1 C398.1 C401.1 R25567.2 R25568.2 U8.G8 U8.G9
+VDDQ: PC280.1 PR254.2 R2135.1 R2196.1
+VDDQ_VTT: C2063.1 C2064.1 C2065.1 C2066.1 C2079.1 C2080.1 C2081.1 C2082.1 C2087.1 C2097.1 C2344.1 C2345.1 C2346.1 C2350.1 C2353.1 JDIM2000.258(VTT) PC299.1 PU26.25 PU26.27(VTTSNS) R2088.1 R2089.1 R2090.1 R2091.1 R2092.1 R2099.1 R2100.1 R2101.1 R2102.1 R2103.1 R2104.1 R2105.1 R2106.1 R2107.1 R2109.1 R2110.1 R2111.1 R2112.1 R2114.1 R2116.1 R2117.1 R2118.1 R2119.1 R2121.1 R2124.1 R2126.1 R2130.1 R2137.1
+VDDQC: C2188.1 C2255.2 R2185.2 U2030.AL23 U2030.AM40
+VIN: C542.1 PC7.1 PC12.1 PC81.1 PC170.1 PC172.1 PC217.1 PC218.1 PC221.1 PC288.1 PC289.1 PC290.2 PC292.2 PC6000.1 PC6002.2 PC6003.2 PC6004.1 PC6005.1 PC6030.1 PC6031.2 PC6032.1 PC6033.1 PC6034.2 PC7031.1 PC7032.1 PC7033.1 PC7034.1 PC7035.2 PC7036.1 PC7037.1 PC7038.1 PC7049.1 PC7050.1 PC7051.1 PC7052.1 PC7053.1 PC7054.2 PC7055.1 PC7066.1 PC7067.1 PC7068.1 PC7069.2 PC7070.1 PC7080.1 PC7081.1 PC7082.1 PC7083.1 PC7084.1 PC7085.2 PC7086.1 PC9001.1 PC9002.1 PC9003.1 PC9005.1 PC9006.1 PC9007.1 PC9015.1 PC9016.1 PC9017.1 PC9018.1 PC9019.1 PC9074.1 PC9076.1 PC9077.1 PC9078.1 PQ2.5 PQ30.5 PQ7000.3 PQ7000.4 PQ7000.9 PQ7001.3 PQ7001.4 PQ7001.9 PQ7002.5 PQ7004.3 PQ7004.4 PQ7004.9 PQ9000.3 PQ9000.4 PQ9000.9 PQ9001.3 PQ9001.4 PQ9001.9 PR2.1 PR3.2 PR59.1 PR79.1 PR116.1 PR191.1 PR268.2 PR7000.2 PR9000.1 PR9086.2 PR9102.1 PU16.8 PU16.9 PU16.22 PU16.24 PU26.19 PU26.20 PU26.21 PU26.22 PU26.31 PU6000.5 PU6003.5 PU9004.8 PU9004.9 PU9004.22 PU9004.24 R25285.1
+VIN_BLIGHT: C536.1 C537.1 CN29.39 CN29.40 R25285.2
AVDD2: C845.1 L28.2 U20.40
DVDD_IO: C584.1 C585.1 R460.1 R462.1 U20.9
