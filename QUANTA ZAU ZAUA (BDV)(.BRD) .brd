# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 13.14,112.46 14.39,112.46 15.86,110.98 15.86,109.54 16.06,109.33 16.06,107.15 15.02,107.15 15.02,104.42 13.66,103.05 12.05,103.05 11.91,103.2 11.7,103.7 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8.3,112.44 8.96,113.3 9.26,113.6 12,113.6
GND on BOTTOM (solid shape): outline of 124 points within 51.52,17.46 68.24,22.9
GND on BOTTOM (solid shape): 124.21,79.77 124.21,79.77 124.27,79.72 124.27,79.41 123.48,78.62 123.48,77.1 120.01,73.63 119.82,73.44 119.19,72.81 118.15,72.81 117.79,73.16 117.16,73.16 115.98,71.99 115.77,71.99 115.69,72.01 115.61,72.02 115.35,71.91 115.23,71.64 115.27,71.47 115.38,71.34 115.42,71.27 115.39,71.19 115.32,71.12 115.29,71.11 115.26,71.11 115.17,71.15 115.07,71.16 114.8,71.05 114.69,70.78 114.7,70.72 114.71,70.67 114.69,70.59 114.61,70.55 114.36,70.43 114.26,70.17 114.37,69.9 114.64,69.78 114.7,69.79 114.78,69.77 114.82,69.69 114.82,68.19 114.62,67.98 109.1,67.98 108.98,68.11 108.98,69.66 109.15,69.84 112.74,69.84 112.96,70.06 112.96,72.96 115.94,75.93 117.28,75.93 118.3,75.93 118.38,75.93 120.71,78.27 120.99,78.27 121.47,77.79 121.8,77.79 122.46,78.45 122.46,80.12 122.9,80.55 123.43,80.55
GND on BOTTOM (solid shape): outline of 120 points within 169.35,16.75 179.35,25.41
GND on BOTTOM (solid shape): 186.6,32.7 186.61,32.68 186.6,32.6 186.6,32.54 186.62,32.47 186.62,32.02 186.22,31.61 186.19,31.61 186.12,31.63 186.05,31.63 185.8,31.53 185.7,31.28 185.7,31.22 185.7,31.2 185.69,31.18 185.23,30.72 184.47,30.72 184.21,30.97 184,30.97 184,30.98 182.44,30.98 182.18,30.72 182.18,30.34 181.93,30.09 181.54,30.09 181.42,30.21 181.42,30.49 181.44,30.57 181.44,30.63 181.44,30.7 181.42,30.77 181.42,31.74 181.48,31.8 181.5,31.81 181.53,31.81 181.57,31.8 181.61,31.8 181.86,31.9 181.96,32.16 181.96,32.21 181.94,32.29 181.9,32.36 181.9,32.55 182.13,32.77 182.14,32.78 182.16,32.79 185.32,32.79 185.41,32.75 185.42,32.66 185.41,32.6 185.41,32.55 185.76,32.19 186.12,32.55 186.11,32.6 186.1,32.66 186.12,32.75 186.2,32.79 186.51,32.79 186.51,32.79
GND on BOTTOM (solid shape): outline of 128 points within 115.86,114.51 122.85,125.16
GND on BOTTOM (solid shape): outline of 100 points within 115.43,59.8 136.49,69.96
GND on BOTTOM (solid shape): outline of 154 points within 13.78,6.95 23.53,14.21
GND on BOTTOM (solid shape): outline of 87 points within 73.24,78.57 85.8,85.56
GND on BOTTOM (solid shape): 73.7,21.73 73.7,20.71 74.05,20.36 74.06,20.33 74.06,20.3 74.03,20.22 74.01,20.13 74.13,19.86 74.4,19.75 74.53,19.77 74.65,19.84 74.72,19.87 74.79,19.84 74.9,19.77 75.04,19.75 75.31,19.86 75.42,20.13 75.42,20.17 75.41,20.23 75.42,20.25 75.47,20.31 75.87,20.31 75.94,20.27 75.97,20.19 75.96,20.14 76.07,19.88 76.32,19.78 76.48,19.82 76.6,19.92 76.69,19.96 76.77,19.92 76.91,19.8 77.08,19.75 77.35,19.87 77.46,20.14 77.46,20.19 77.48,20.27 77.56,20.31 79.44,20.31 79.59,20.15 79.59,18.15 79.28,17.84 77.71,17.84 76.72,18.83 71,18.83 70.62,19.21 70.62,19.8 70.63,19.82 70.64,19.84 70.73,19.94 70.77,20.06 70.77,20.08 71.08,20.38 71.3,20.38 71.42,20.26 71.44,20.24 71.44,20.21 71.43,20.17 71.43,20.13 71.54,19.86 71.81,19.75 71.94,19.77 72.06,19.84 72.13,19.87 72.2,19.84 72.32,19.77 72.45,19.75 72.72,19.86 72.83,20.13 72.82,20.24 72.77,20.34 72.76,20.35 72.76,20.39 72.91,20.53 72.91,21.73 73.04,21.85 73.57,21.85
GND on BOTTOM (solid shape): outline of 220 points within 59.55,90.11 67.65,104.91
GND on BOTTOM (solid shape): outline of 268 points within 0.51,20.97 15.38,28.79
GND on BOTTOM (solid shape): outline of 277 points within 33.56,95.06 44.69,98.56
GND on BOTTOM (solid shape): outline of 262 points within 77.2,99.1 88.83,108.47
GND on BOTTOM (solid shape): outline of 385 points within 100.11,43.19 131.8,51.68
GND on BOTTOM (solid shape): outline of 591 points within 85.91,44.28 94.19,49.49
GND on BOTTOM (solid shape): outline of 1502 points within 0.51,5.69 219.29,127.49
GND on SGND (solid shape): outline of 2501 points within 0.51,0.51 219.29,127.49
GND on IN1 (solid shape): 19.34,72.2 19.77,72.2 21.91,70.06 21.91,66.53 18.73,63.36 17,63.36 16.01,62.37 16.01,60.36 15.51,59.85 13.16,59.85 12.76,60.26 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.42,62.18 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99 6.72,67.99 7.64,67.07 8.75,67.07 9.61,67.93 9.61,71.05 9.92,71.05 10.02,71.04 10.12,71.04 10.36,71.04 10.81,70.6 12.36,70.6 14.62,72.86 18.68,72.86
GND on IN1 (solid shape): 13.93,90.79 13.93,88.25 11.75,86.07 11.09,86.07 10.76,85.74 10.76,84.82 11.09,84.49 12.1,84.49 12.58,84.01 12.58,83.17 12.08,82.66 11.06,82.66 10.32,81.93 10.32,81.51 9.61,81.51 9.61,84.49 8.77,85.33 7.61,85.33 6.69,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.7,88.7 11.91,89.2 11.91,90.99 12.09,91.17 13.55,91.17
GND on IN1 (solid shape): 15.38,51.24 15.38,50.56 15.78,50.15 15.78,47.79 13.57,45.58 13.57,43.42 15.3,41.69 15.3,40.37 14.84,39.91 13.19,39.91 12.76,40.35 12.76,41.84 12.01,42.81 10.88,42.35 8.9,42.35 8.42,42.18 8.16,41.75 3.45,41.75 3.25,41.95 3.25,46.93 3.45,47.13 8.16,47.13 8.42,46.7 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,48.98 12.94,49.16 13.57,49.16 14.03,49.62 14.03,51.34 14.31,51.62 15,51.62
GND on IN1 (solid shape): 16.27,113.68 16.27,105.22 13.55,102.5 11.91,102.5 11.91,103.2 11.7,103.7 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8.16,112.41 8.91,113.01 9.14,113.24 11.82,113.24 12.74,114.16 15.78,114.16
GND on IN1 (solid shape): outline of 141 points within 0.51,0.51 41.49,13.55
GND on IN1 (solid shape): outline of 270 points within 0.51,18.63 15.33,31.56
GND on IN1 (solid shape): outline of 1370 points within 0.51,5.27 219.29,127.49
GND on IN2 (solid shape): 6.46,13.09 6.46,9.94 10.91,5.5 10.91,2.22 11.61,1.52 40.48,1.52 40.48,2.86 40.6,2.98 41.44,2.98 41.49,2.93 41.49,1 41.35,0.65 41,0.51 1,0.51 0.65,0.65 0.51,1 0.51,10.64 3.23,10.64 4.36,10.18 5.11,11.15 5.11,11.87 5.12,11.87 5.12,12.33 5.65,12.86 5.65,13.22 5.73,13.3 6.26,13.3
GND on IN2 (solid shape): 15.38,51.24 15.38,50.61 14.92,50.15 14.92,48.83 15.38,48.37 15.38,47.62 14.95,47.19 14.95,46.95 13.57,45.58 13.57,43.42 14.95,42.05 14.95,41.48 15.17,41.26 15.17,40.24 14.84,39.91 13.19,39.91 12.76,40.35 12.76,41.84 12.01,42.81 10.88,42.35 8.9,42.35 8.42,42.18 8.16,41.75 3.45,41.75 3.25,41.95 3.25,46.93 3.45,47.13 8.16,47.13 8.42,46.7 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,48.98 12.94,49.16 13.57,49.16 14.03,49.62 14.03,51.34 14.31,51.62 15,51.62
GND on IN2 (solid shape): 14.67,114.69 15.89,114.69 16.31,114.26 16.31,105.39 13.41,102.48 11.91,102.48 11.91,103.2 11.7,103.7 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8.24,112.42 8.95,113.17 9.23,113.45 10.78,113.45 12.46,115.12 14.24,115.12
GND on IN2 (solid shape): outline of 273 points within 0.51,18.63 15.33,31.56
GND on IN2 (solid shape): outline of 172 points within 0.51,59.85 20.42,91.17
GND on IN2 (solid shape): outline of 1272 points within 0.51,5.27 219.29,127.49
GND on IN2 (solid shape): outline of 28530 points within 26.43,31.84 83.78,98.11
GND on SVCC (solid shape): 15.45,114.41 15.58,114.25 15.78,114.18 15.83,114.19 16.72,113.29 16.89,113.18 17.08,113.14 17.71,113.14 16.34,111.77 16.32,111.75 16.32,111.72 16.32,105.27 13.52,102.48 13.43,102.48 13.43,103.2 12.78,104.78 11.2,105.43 8.58,105.43 7.76,106.31 6.6,106.63 5.2,106.63 4.35,106.46 3.63,105.99 3.63,110.7 3.63,110.85 3.61,110.99 3.79,110.97 3.97,110.97 5.93,110.97 6.42,111.02 6.9,111.17 9.62,111.45 10.36,114.08 10.69,114.41
GND on SVCC (solid shape): 122.71,125.93 123.59,124.45 125.2,123.87 131.2,123.87 132.81,124.45 133.69,125.93 133.7,125.97 142.97,125.97 142.97,125.19 142.93,125.11 142.84,125.09 142.67,125.12 142.5,125.13 140.87,123.5 142.5,121.87 142.67,121.88 142.84,121.91 142.93,121.89 142.97,121.81 142.97,80.87 142.47,80.38 126.64,80.38 118.02,88.99 117.86,89.1 117.66,89.14 113.56,89.14 110.24,92.46 110.25,92.48 110.15,92.83 109.81,92.92 109.78,92.92 109.13,93.56 109.09,93.6 108.85,93.78 108.55,93.71 108.1,93.71 105.75,96.06 105.7,96.12 105.63,96.17 103.82,97.99 103.82,98.71 106.19,101.08 106.31,101.08 106.32,101.07 106.56,100.98 106.81,101.08 107.26,101.08 107.57,100.91 107.87,101.08 108.1,101.08 108.4,100.91 108.7,101.08 108.87,101.13 109.01,101.23 110.78,103 110.89,103.17 110.93,103.36 110.93,108.17 111.24,108.52 110.93,108.87 110.93,111.79 111.21,112.06 111.49,112.17 111.6,112.45 112.8,113.66 113.14,113.76 113.24,114.1 117.39,118.24 117.5,118.41 117.54,118.6 117.54,125.51 118,125.97 122.7,125.97
GND on SVCC (solid shape): outline of 269 points within 25.46,30.59 87.18,101.2
GND on IN3 (solid shape): 21.91,70.06 21.91,66.53 18.73,63.36 17,63.36 16.01,62.37 16.01,60.36 15.51,59.85 13.16,59.85 12.76,60.26 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.42,62.18 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99 6.72,67.99 7.64,67.07 8.75,67.07 9.61,67.93 9.61,70.95 10.45,70.95 10.81,70.6 12.36,70.6 14.62,72.86 19.11,72.86
GND on IN3 (solid shape): 13.93,90.79 13.93,88.25 11.75,86.07 11.09,86.07 10.76,85.74 10.76,84.82 11.09,84.49 12.1,84.49 12.58,84.01 12.58,83.17 12.08,82.66 11.06,82.66 10.32,81.93 10.32,81.6 9.61,81.6 9.61,84.49 8.77,85.33 7.61,85.33 6.69,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.7,88.7 11.91,89.2 11.91,91.17 13.55,91.17
GND on IN3 (solid shape): 15.38,51.24 15.38,50.66 15.89,50.15 15.89,48.42 14.31,46.84 14.31,46.32 13.57,45.58 13.57,43.42 14.31,42.68 14.31,42.28 15.17,41.42 15.17,40.24 14.84,39.91 13.19,39.91 12.76,40.35 12.76,41.84 12.01,42.81 10.88,42.35 8.9,42.35 8.42,42.18 8.16,41.75 3.45,41.75 3.25,41.95 3.25,46.93 3.45,47.13 8.16,47.13 8.42,46.7 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,48.98 12.94,49.16 13.57,49.16 14.03,49.62 14.03,51.34 14.31,51.62 15,51.62
GND on IN3 (solid shape): 16.06,113.88 16.06,113.27 16.31,113.02 16.31,105.32 13.49,102.5 11.91,102.5 11.91,103.2 11.7,103.7 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8.25,112.42 8.95,113.19 9.28,113.52 11.48,113.52 12.2,114.24 15.7,114.24
GND on IN3 (solid shape): outline of 141 points within 0.51,0.51 41.49,13.55
GND on IN3 (solid shape): outline of 334 points within 0.51,18.63 15.17,31.56
GND on IN3 (solid shape): outline of 1223 points within 0.51,5.27 219.29,127.49
GND on SGND1 (solid shape): outline of 2530 points within 0.51,0.51 219.29,127.49
VCC1_CORE on BOTTOM (solid shape): 118.04,68.49 118.08,68.47 118.1,68.44 118.1,67.58 118.08,67.54 118.04,67.52 117.74,67.52 116.89,66.68 115.31,66.68 115.31,66.68 115.21,66.68 115.1,66.79 115.1,68.16 115.38,68.44 115.91,68.44 116.32,68.03 117.35,68.03 117.82,68.49
VCC_GT on BOTTOM (solid shape): 129.18,79.8 129.18,79.4 129.32,79.26 131.33,79.26 131.41,79.18 131.41,78.54 131.12,78.26 130.3,78.26 129.98,78.57 129.32,78.57 128.92,78.17 128.65,78.17 128.62,78.18 128.6,78.22 128.6,79.15 128.61,79.15 128.49,79.26 128.49,79.82 128.65,79.98 129,79.98
5213LX_1.8V on TOP (solid shape): 41.3,32.06 41.3,31.78 41.16,31.64 41.07,31.64 40.98,31.55 40.98,30.9 40.81,30.72 40.77,30.72 40.73,30.73 40.71,30.73 39.82,30.73 39.73,30.7 39.69,30.61 39.69,30.3 39.69,30.27 39.71,30.23 39.71,30.19 39.81,30.09 40.68,30.09 40.7,30.06 40.7,29.83 40.68,29.81 39.71,29.81 39.24,29.34 39.24,28.68 39.05,28.48 38.14,28.48 37.96,28.66 37.96,30.67 38.29,31 39.13,31 39.3,31.18 39.3,32.12 39.41,32.22 41.14,32.22
8813BOOT1 on TOP (solid shape): 76.39,114.78 76.39,113.39 75.36,112.35 75.17,112.35 75.09,112.43 75.09,113.12 75.61,113.63 75.61,114.8 75.67,114.86 76.32,114.86
8813BOOT2 on TOP (solid shape): 76.59,108.7 77.15,108.7 77.92,107.93 77.92,107.61 77.61,107.31 77.22,107.31 76.71,107.82 76.08,107.82 76.07,107.82 75.97,107.82 75.4,108.39 75.09,108.39 75.08,108.41 75.08,109.14 75.15,109.22 76.07,109.22
8813LGAT1 on TOP (solid shape): 78.57,115.45 78.57,114.74 78.57,112.97 76.99,111.39 75.6,111.39 75.57,111.41 75.55,111.44 75.55,111.65 75.58,111.68 76.51,111.68 77.13,112.3 77.13,112.31 77.91,113.09 77.91,115.46 78.02,115.57 78.44,115.57
8813LGAT1 on BOTTOM (solid shape): 76.81,117.61 76.81,116.32 77.52,115.62 78.4,115.62 78.57,115.44 78.57,114.96 78.45,114.84 76.98,114.84 75.91,115.91 75.91,116.16 75.86,116.21 75.84,116.24 75.82,116.26 75.09,116.98 75.09,117.61 75.14,117.66 76.76,117.66
8813LGAT2 on BOTTOM (solid shape): 84.11,110.1 84.11,108.63 84.37,108.36 84.91,108.36 85.05,108.22 85.05,107.87 84.91,107.73 83.37,107.73 83.22,107.89 83.22,110.1 83.45,110.32 83.88,110.32
8813PHASE1 on TOP (solid shape): 78.18,116.33 78.18,116.08 77.73,115.64 77.73,113.24 76.39,111.9 75.6,111.9 75.57,111.91 75.55,111.95 75.55,112.08 75.65,112.18 75.75,112.18 76.99,113.41 76.99,116.06 77.5,116.57 77.94,116.57
8813PHASE1 on BOTTOM (solid shape): 79.64,121.93 79.64,117.19 78.22,115.77 77.61,115.77 76.94,116.44 76.94,116.86 76.95,116.9 76.95,117.51 76.94,117.55 76.94,117.66 76.94,117.67 76.94,117.8 76.85,117.89 76.24,117.89 75.96,118.17 75.96,121.25 76.89,122.18 79.4,122.18
8813PHASE2 on TOP (solid shape): 76.92,109.46 77.06,109.46 77.14,109.44 77.2,109.43 77.84,109.43 77.86,109.46 78.37,109.46 78.9,108.93 78.9,108.72 78.4,108.22 78.17,108.22 77.53,108.85 76.64,108.85 76.11,109.38 75.65,109.38 75.55,109.49 75.55,109.59 75.63,109.66 76.72,109.66
8813PHASE2 on BOTTOM (solid shape): 82.41,115.07 82.41,110.93 82.84,110.5 82.84,108.98 82.71,108.85 79.56,108.85 79.16,109.26 79.16,114.57 79.89,115.3 82.18,115.3
8813UGATE1 on TOP (solid shape): 75.15,114.48 75.15,113.53 74.86,113.24 74.86,112.38 74.85,112.35 74.81,112.33 74.62,112.33 74.59,112.35 74.57,112.38 74.57,113.18 74.56,113.18 74.56,113.86 74.38,114.04 74.38,114.45 74.53,114.6 75.03,114.6
8813UGATE1 on BOTTOM (solid shape): 75.15,115.26 75.15,114.08 74.89,113.82 73.83,113.82 73.7,113.95 73.7,114.31 73.99,114.61 73.99,115.57 74.05,115.62 74.8,115.62
8813UGATE1_1 on BOTTOM (solid shape): 71.41,117.49 71.41,116.9 71.68,116.63 72.31,116.63 73.24,115.69 73.32,115.69 73.43,115.58 73.43,114.77 73.4,114.73 72.75,114.73 72.73,114.74 72.72,114.75 72.15,115.31 71.63,115.83 71.26,115.83 70.62,116.47 70.62,117.49 70.72,117.59 71.31,117.59
8813UGATE2 on TOP (solid shape): 74.81,109.23 74.85,109.22 74.86,109.18 74.86,108.34 74.97,108.24 75.37,108.24 75.92,107.69 75.95,107.66 76.46,107.15 76.47,107.15 76.75,106.87 76.95,106.87 77.28,106.54 77.28,105.75 77.18,105.65 76.59,105.65 75.64,106.61 75.64,106.8 75.12,107.32 75.12,107.45 74.56,108.01 74.56,108.39 74.57,108.39 74.57,109.18 74.59,109.22 74.62,109.23
8813UGATE2_1 on BOTTOM (solid shape): 84.37,104.34 84.42,104.34 84.46,104.34 84.52,104.35 84.64,104.35 84.72,104.28 84.73,104.26 84.73,104.24 84.73,104.07 84.75,104.06 84.75,103.87 84.71,103.84 84.7,103.83 84.6,103.76 84.53,103.66 84.53,103.65 84.21,103.34 83.35,103.34 83.3,103.39 83.3,103.97 83.35,104.02 83.86,104.02 83.88,104.02 84.21,104.35 84.32,104.35
9336ADJ on BOTTOM (solid shape): 74.61,97.14 77.03,97.14 77.18,97.29 77.61,97.29 78.04,96.86 78.04,95.13 77.86,94.96 77.38,94.96 77.13,95.21 77.13,96.25 76.96,96.42 76.21,96.42 76.1,96.3 75.02,96.3 73.76,95.05 73.6,95.05 73.43,95.21 73.43,95.68 73.58,95.82 73.58,96.32 73.65,96.39 73.65,97.6 73.77,97.73 74.03,97.73
24780_DH on BOTTOM (solid shape): 124.21,31.63 124.21,31.11 123.91,30.81 122.62,30.81 122.49,30.94 122.49,31.23 122.61,31.35 123.5,31.35 123.82,31.67 124.17,31.67
24780_LX on BOTTOM (solid shape): 126.48,31.44 126.48,30.5 126.34,30.36 126.34,27.78 126.2,27.64 123.65,27.64 123.15,27.14 120.79,27.14 120.78,27.15 120.78,30.66 120.8,30.68 122.75,30.68 122.78,30.68 123.97,30.68 124.37,31.07 124.37,31.56 124.6,31.79 126.12,31.79
24780_VCC on BOTTOM (solid shape): 132.01,31.73 132.19,31.64 132.43,31.66 132.45,31.65 132.78,31.32 132.78,31.04 132.74,31.01 130.93,31.01 130.74,30.82 130.06,30.82 130.05,30.82 130.05,31.64 130.14,31.73
+1.03_GFX on TOP (solid shape): 89.8,104.99 89.8,104.53 89.67,104.41 89.04,104.41 88.5,104.94 88.15,104.94 88.15,105.4 88.2,105.45 89.34,105.45
+1.03_GFX on TOP (solid shape): 120.76,121.67 120.76,121.4 120.59,121.23 120.59,121.22 120.19,120.81 119.27,120.81 119.05,120.6 118.8,120.6 118.59,120.81 117.69,120.81 117.54,120.97 117.54,121.73 117.71,121.91 120.53,121.91
+1.03_GFX on TOP (solid shape): 111.72,109.18 111.72,108.7 111.64,108.62 111.22,108.62 111.1,108.51 111.1,108.4 110.99,108.28 110.78,108.28 110.39,108.67 110.15,108.67 110.02,108.8 110.02,109.21 110.17,109.36 111.54,109.36
+1.03_GFX on TOP (solid shape): 107.69,121.58 107.69,121.11 107.32,120.74 107.32,120.43 106.82,119.92 105.42,119.92 105.27,120.08 105.27,121.14 105.28,121.15 105.28,121.56 105.41,121.7 107.57,121.7
+1.03_GFX on TOP (solid shape): 96.83,115.43 96.83,114.73 96.41,114.31 96.23,114.31 91.48,109.56 88.73,109.56 88.58,109.71 88.58,110.78 88.78,110.97 90.14,110.97 93.26,114.09 94.41,114.09 94.41,114.03 94.42,113.98 94.43,113.93 94.45,113.88 94.48,113.84 94.52,113.8 94.56,113.77 94.61,113.74 94.66,113.72 94.71,113.71 94.76,113.7 94.82,113.71 94.87,113.72 94.92,113.74 94.96,113.77 95.01,113.8 95.04,113.84 95.07,113.88 95.1,113.93 95.11,113.98 95.12,114.03 95.12,114.09 95.11,114.14 95.1,114.19 95.07,114.24 95.04,114.28 95.01,114.32 94.96,114.36 94.92,114.38 94.87,114.4 94.82,114.41 94.76,114.42 94.71,114.41 94.66,114.4 94.61,114.38 94.56,114.36 94.52,114.32 94.48,114.28 94.45,114.24 94.43,114.19 94.42,114.14 94.41,114.09 93.26,114.09 95.46,116.29 95.97,116.29
+1.03_GFX on BOTTOM (solid shape): 74.03,103.57 74.03,102.86 72.96,101.79 72.96,98.79 73.39,98.36 73.39,97.34 73.32,97.27 72.91,97.27 71.84,98.33 70.43,98.33 70.33,98.44 70.33,100.05 70.45,100.16 71.54,100.16 71.69,100.32 71.69,102.6 72.91,103.82 73.77,103.82
+1.03_GFX on BOTTOM (solid shape): 120.04,118.97 120.04,115.2 119.89,115.05 118.1,115.05 117.08,114.02 116.83,114.02 116.52,113.72 116.52,113.22 115.94,112.64 115.1,112.64 112.61,110.15 112.6,110.15 111.17,108.72 111.17,108.47 110.99,108.29 110.75,108.29 110.61,108.43 110.61,108.75 111.48,109.63 111.49,109.63 112.26,110.4 112.33,110.4 113.09,111.16 113.09,111.29 115.02,113.22 115.86,113.22 116.09,113.45 116.09,113.98 115.71,114.37 115.71,115.81 116.85,116.95 116.85,118.11 116.98,118.24 117.85,118.24 117.89,118.2 118.76,118.2 119.01,118.45 119.01,118.68 119.37,119.04 119.98,119.04
+1.03_GFX on IN1 (solid shape): 120.92,122.15 120.92,120.17 119.69,118.94 119.69,115.79 118.99,115.09 117.68,115.09 117.39,115.38 117.39,123.42 115.94,124.87 113.67,124.87 110.29,121.49 108.01,121.49 107.35,120.82 106.76,120.82 106.54,121.04 106.54,121.62 107.35,122.43 109.54,122.43 112.95,125.84 117.22,125.84
+1.03_GFX on IN1 (solid shape): outline of 688 points within 71.05,103.19 89.51,111.32
+1.03_GFX on IN2 (solid shape): 107.59,121.54 107.59,117.95 103.22,113.58 102.62,113.58 102.26,113.23 97.13,113.23 95.59,114.76 95.59,114.77 95.44,114.92 95.44,115.3 95.67,115.53 96.51,115.53 96.74,115.31 96.74,114.85 97.47,114.12 100.94,114.12 101.09,114.27 103.05,114.27 106.32,117.54 106.32,121.4 106.64,121.72 107.41,121.72
+601_VCC on TOP (solid shape): 204.91,17.33 204.91,15 205.32,14.59 205.88,14.59 206.49,13.98 206.49,13.6 206.77,13.32 207.12,13.32 207.38,13.58 207.38,14.25 207.93,14.8 207.93,15.3 208.14,15.51 209.22,15.51 209.24,15.48 209.24,15.23 208.02,14 207.99,13.98 207.92,13.91 207.92,12.71 208.06,12.58 208.36,12.58 208.42,12.64 208.7,12.64 208.82,12.51 208.82,12 208.51,11.68 205.95,11.68 205.84,11.8 205.84,12.75 205.98,12.89 205.98,13.22 205.48,13.72 204.86,13.72 204.37,14.21 204.37,17.31 204.44,17.39 204.86,17.39
+601_VCC on TOP (solid shape): 214.9,18.32 215.02,18.26 215.15,18.2 215.2,18.15 215.27,18.15 215.28,18.14 216,17.94 216.75,17.87 216.82,17.87 216.97,17.87 217.13,17.88 217.61,17.4 217.61,13.58 216.09,12.05 215.56,12.05 215.47,12.14 215.47,12.6 215.25,12.81 214.55,12.81 214.44,12.93 214.44,13.45 214.56,13.58 215.96,13.58 217.03,14.64 217.03,15.79 217.03,15.83 217.03,16.43 217.03,16.6 216.92,16.71 216.87,16.75 216.37,17.26 212.02,17.26 211.92,17.36 211.92,17.77 212.47,18.32
+601_VCC on IN2 (solid shape): 212.89,13.43 213.33,13.43 213.44,13.54 216.41,13.54 216.67,13.27 216.67,12.66 216.33,12.32 213.53,12.32 213.43,12.41 213.43,12.55 213.27,12.71 212.85,12.71 212.45,12.32 209.49,12.32 209.23,12.06 208.36,12.06 208.24,12.18 208.24,12.69 208.56,13.01 209.51,13.01 210.05,13.54 212.78,13.54
+AZA_VDD on TOP (solid shape): 206.87,29.3 206.87,28.79 207.28,28.38 210.25,28.38 210.4,28.54 210.75,28.54 210.86,28.43 210.86,28.03 210.75,27.93 207.02,27.93 206.79,27.7 206.59,27.7 206.46,27.82 206.46,28.38 206.23,28.61 206.23,29.37 206.34,29.48 206.69,29.48
+AZA_VDD on BOTTOM (solid shape): 206.83,30.09 207.15,30.09 208.11,29.12 208.11,27.37 208.1,27.33 208.06,27.32 207.4,27.32 207.03,27.68 206.6,27.68 206.46,27.83 206.46,28.72 206.76,29.02 206.76,30.04 206.76,30.06 206.79,30.09
+FB_PLLAVDD on IN3 (solid shape): 110.14,98.56 112.25,98.56 112.36,98.46 112.36,98.26 112.25,98.16 108.62,98.16 108.62,98.16 108.32,98.16 108.01,97.85 107.86,97.85 107.81,97.84 107.76,97.83 107.71,97.8 107.67,97.77 107.63,97.74 107.6,97.69 107.58,97.65 107.56,97.6 107.55,97.54 107.45,97.4 107.04,97.4 106.56,97.87 106.56,98.23 107.02,98.23 107.02,98.18 107.03,98.13 107.05,98.08 107.07,98.03 107.1,97.99 107.14,97.96 107.18,97.93 107.22,97.9 107.27,97.89 107.33,97.88 107.38,97.88 107.43,97.89 107.48,97.9 107.52,97.93 107.57,97.96 107.6,97.99 107.63,98.03 107.66,98.08 107.67,98.13 107.68,98.18 107.68,98.23 107.67,98.29 107.66,98.33 107.63,98.38 107.6,98.42 107.57,98.46 107.52,98.49 107.48,98.51 107.43,98.53 107.38,98.54 107.33,98.54 107.27,98.53 107.22,98.51 107.18,98.49 107.14,98.46 107.1,98.42 107.07,98.38 107.05,98.33 107.03,98.29 107.02,98.23 106.56,98.23 106.56,98.61 106.77,98.82 108.82,98.82 108.9,98.89 109.81,98.89
+G_SEN_PW on TOP (solid shape): 60.39,21.96 60.67,21.96 62.77,19.85 62.77,18.06 62.77,18.06 62.77,14.92 62.57,14.72 61.76,14.72 61.53,14.95 61.53,17.44 61.35,17.61 58.51,17.61 57.59,18.53 57.59,18.78 57.63,18.81 58.74,18.81 58.74,20.05 57.57,20.05 57.43,20.19 57.43,21.16 57.42,21.16 57.42,21.68 57.72,21.98 60.36,21.98
+G_SEN_PW on TOP (solid shape): 50.96,21.47 50.96,20.28 50.94,20.22 50.93,20.15 50.94,20.09 50.96,20.02 50.96,19.93 50.25,19.21 49.98,19.21 49.98,19.22 49.85,19.24 49.72,19.22 49.71,19.21 49.52,19.21 49.39,19.34 49.39,19.67 49.49,19.77 49.95,19.77 50.25,20.08 50.25,20.99 50.18,21.07 50.18,21.78 50.2,21.8 50.63,21.8
+PEX_IOVDDQ on TOP (solid shape): 103.34,110.04 103.34,109.26 103.74,108.85 103.74,108.42 103.64,108.32 103.24,108.32 103.14,108.42 103.14,108.88 102.96,109.05 102.3,109.05 102.2,109.16 102.2,109.46 101.92,109.74 101.18,109.74 101.08,109.84 101.08,110.15 101.2,110.27 103.11,110.27
+PEX_IOVDDQ on TOP (solid shape): outline of 153 points within 108.53,109.08 121.83,121.27
+PEX_IOVDDQ on BOTTOM (solid shape): 115.96,113.78 115.96,113.57 115.73,113.35 114.97,113.35 111.67,110.04 111.67,109.97 110.93,109.23 109.05,109.23 108.29,108.47 107.28,108.47 106.87,108.06 103.34,108.06 102.86,108.55 102.22,108.55 102.2,108.52 101.92,108.52 101.41,109.03 101.41,109.54 101.1,109.84 101.1,110.12 101.2,110.22 101.46,110.22 101.61,110.07 101.81,110.07 101.97,110.22 102.22,110.22 102.37,110.07 102.68,110.07 102.86,110.25 103.11,110.25 103.44,109.92 104.18,109.92 104.38,109.71 104.38,109.51 104.07,109.21 104.07,108.8 104.25,108.62 105.95,108.62 106.44,109.1 106.44,109.71 106.63,109.9 108.28,109.9 108.55,110.17 108.9,110.17 109.03,110.04 109.28,110.04 109.38,110.15 109.74,110.15 109.82,110.07 110.09,110.07 110.17,110.15 110.58,110.15 110.68,110.04 110.96,110.04 111.44,110.53 111.47,110.53 113.75,112.81 113.83,112.81 114.11,113.09 114.11,113.17 115.25,114.31 115.43,114.31
+TP_PWR_C on BOTTOM (solid shape): 58.45,107.6 58.49,107.59 58.5,107.55 58.5,106.71 58.7,106.71 58.7,107.55 58.71,107.59 58.75,107.6 58.97,107.6 59,107.54 59,106.66 58.95,106.61 58.95,106.31 58.68,106.03 58.36,106.03 58.15,106.24 58.15,106.68 58.18,106.71 58.2,106.71 58.2,107.55 58.21,107.59 58.25,107.6
+TYPEC_VBUS on TOP (solid shape): 11.03,21.22 11.03,20.74 10.96,20.66 10.76,20.66 10.07,19.98 8.88,19.98 8.7,20.15 8.7,21.2 8.88,21.37 10.88,21.37
+TYPEC_VBUS on TOP (solid shape): 18.76,15.99 18.76,14.01 18.71,13.96 18.05,13.96 17.84,13.75 17.84,13.14 17.61,12.91 17.05,12.91 16.8,12.66 16.8,11.87 17.17,11.5 17.44,11.5 18.68,10.26 19.48,10.26 20.38,9.36 20.38,8.65 20.23,8.5 19.7,8.5 18.59,9.6 18.26,9.6 17.16,10.7 16.09,10.7 15.68,11.11 15.2,11.11 15.02,11.29 15.02,15.61 15.61,16.19 18.55,16.19
+TYPEC_VBUS on BOTTOM (solid shape): 17.03,16.5 17.03,12.74 16.65,12.36 14.9,12.36 14.44,12.81 14.44,14.55 14.44,14.56 14.46,14.69 14.44,14.82 14.44,14.83 14.44,16.31 14.46,16.4 14.46,16.49 14.46,16.51 14.48,16.53 14.54,16.6 16.93,16.6
+TYPEC_VBUS on IN2 (solid shape): outline of 1335 points within 5.68,8.88 17.31,21.33
+TYPEC_VBUS_C on TOP (solid shape): 22.41,16.65 22.41,16.37 21.63,15.58 21.63,13.3 21.4,13.07 20.7,13.07 20.69,13.07 20.56,13.09 20.43,13.07 20.42,13.07 19.29,13.07 19.16,13.19 19.16,16.95 19.39,17.18 21.88,17.18
+TYPEC_VBUS_C on BOTTOM (solid shape): 21.86,17.05 22.11,17.05 22.62,16.55 22.74,16.55 22.82,16.47 23.05,16.47 23.05,16.46 23.65,16.46 23.71,16.39 23.71,16.31 23.69,16.27 23.66,16.26 23.05,16.26 23.05,15.96 23.66,15.96 23.69,15.94 23.71,15.91 23.71,15.78 23.68,15.76 22.57,15.76 22.26,15.45 22.26,15.36 22.26,15.35 22.22,15.27 22.21,15.18 22.22,15.1 22.25,15.03 22.25,15.01 22.25,14.98 22.19,14.92 20.99,14.92 20.1,14.03 17.66,14.03 17.41,14.29 17.41,15.94 18.68,17.21 21.7,17.21
+USBPWR0 on TOP (solid shape): 19.53,50.73 19.53,49.81 19.44,49.72 18.63,49.72 18.57,49.73 18.53,49.73 18.11,49.73 17.84,50 17.23,50 17,50.23 17,50.86 17.11,50.96 18.14,50.96 18.33,51.16 19.1,51.16
+USBPWR0 on BOTTOM (solid shape): outline of 1195 points within 14.28,44.44 22.31,58.94
+USBPWR1 on BOTTOM (solid shape): outline of 339 points within 14.28,32.37 20.89,43.75
+VGPU_CORE on TOP (solid shape): 86.27,123.55 86.27,123.39 86.26,123.23 86.32,122.52 86.5,121.83 86.5,121.82 87.39,120.34 88.78,119.34 88.79,119.33 89.67,118.45 89.67,112.43 89.5,112.27 87.75,112.27 86.93,111.44 86.93,110.4 86.63,110.1 85.43,110.1 81.6,113.93 81.6,123.38 82.03,123.81 86.02,123.81
+VGPU_CORE on TOP (solid shape): outline of 1677 points within 98.74,99.05 117.16,124.95
+VGPU_CORE on BOTTOM (solid shape): 115.41,125.32 115.41,121.65 115.89,121.17 116.6,121.17 116.74,121.04 116.74,119.96 116.65,119.87 115.38,119.87 114.49,118.99 114.49,118.47 112.88,116.86 112.88,115.85 112.86,115.83 112.33,115.3 107.96,115.3 107.38,115.89 107.38,117.23 107.12,117.49 107.12,118.02 107.63,118.53 107.63,121.06 107.64,121.07 110.3,121.07 110.3,117.66 110.63,117.33 112.76,117.33 113.09,117.66 113.09,121.07 112.89,121.27 110.5,121.27 110.3,121.07 107.64,121.07 107.85,121.28 108.24,121.28 108.69,121.73 108.69,122.33 109.05,122.7 109.05,124.43 108.93,124.55 108.93,125.52 109.18,125.77 114.96,125.77
+VGPU_CORE on BOTTOM (solid shape): outline of 121 points within 81.6,104.58 90.28,122.67
+VGPU_CORE on IN2 (solid shape): outline of 4199 points within 81.24,99.35 115.73,124.06
+VGPU_CORE on SVCC (solid shape): 99.3,125.97 99.68,125.59 100.06,125.97 104.49,125.97 104.84,125.68 105.19,125.97 116.06,125.97 116.52,125.51 116.52,118.81 110.48,112.78 110.16,112.68 110.06,112.36 109.95,112.19 109.92,112 109.92,103.57 108.44,102.09 105.98,102.09 105.79,102.06 105.62,101.95 105.39,101.72 105.28,101.64 105.21,101.53 103.1,99.43 97.05,99.43 95.04,101.43 94.98,101.84 94.57,101.91 86.06,110.41 85.95,110.64 85.72,110.75 85.3,111.17 85.19,111.4 84.96,111.51 84.49,111.98 84.38,112.19 84.17,112.3 83.79,112.69 83.68,112.89 83.48,113 81.72,114.75 81.72,123.47 82.12,123.87 85.2,123.87 86.83,124.46 87.7,125.97
+VGPU_CORE on IN3 (solid shape): outline of 3727 points within 100.14,99.07 116.77,124.09
+VREF_CA_DIMM0 on TOP (solid shape): outline of 181 points within 49.74,53.12 53.27,58.08
ADOGND on TOP (solid shape): 213.17,48.2 213.17,47.51 213.02,47.36 212.84,47.36 212.48,47 211.42,47 211.31,47.1 211.31,47.79 211.58,48.06 211.58,48.26 211.74,48.47 212.18,48.91 212.46,48.91
ADOGND on TOP (solid shape): 214.18,43.7 214.9,43.7 215.1,43.5 215.1,43.14 215.66,42.58 215.66,42.12 215.83,41.95 215.83,41.67 215.71,41.54 214.51,41.54 214.39,41.67 214.39,42.07 214.31,42.15 213.55,42.15 213.41,42.29 213.41,42.79 213.29,42.9 213.29,43.67 213.42,43.8 214.08,43.8
ADOGND on TOP (solid shape): 210.28,40.81 210.52,40.56 210.52,33.54 210.25,33.26 209.87,33.26 209.86,33.26 209.73,33.26 209.59,33.4 209.59,33.53 209.36,33.77 209.1,33.77 209.07,33.8 208.52,33.8 208.24,33.51 207.58,33.51 207.47,33.62 207.47,34.25 207.45,34.27 207.45,34.4 207.58,34.53 208.24,34.53 208.69,34.97 208.69,35.3 208.94,35.56 208.98,35.56 209.87,36.44 209.87,38.47 209.99,38.6 209.99,39.66 209.99,40.12 209.69,40.42 209.18,40.42 207.28,38.52 206.84,38.52 206.28,37.96 206.28,37.43 205.67,36.82 205.67,35.42 205.42,35.17 201.53,35.17 200.34,36.36 200.29,36.36 199.83,36.82 199.83,38.09 200.29,38.54 201.92,39.53 203.49,40.6 203.5,40.61 203.54,40.6 203.77,40.37 203.77,39.54 202.44,38.21 202.44,37.24 202.51,36.87 202.72,36.56 202.97,36.31 203.28,36.1 203.65,36.03 204.32,36.31 204.6,36.98 204.58,37.18 204.52,37.36 204.54,37.46 204.63,37.5 204.68,37.5 205.01,37.68 205.02,38.05 205.02,38.08 205.03,38.11 207.74,40.82 210.24,40.82
ADOGND on BOTTOM (solid shape): 204.63,39.43 204.63,39.05 204.48,38.9 202.68,38.9 202.32,38.54 201.76,38.54 201.51,38.29 201.51,37.88 201.26,37.63 200.34,37.63 199.96,37.25 199.5,37.25 199.45,37.3 199.45,38.06 199.47,38.08 199.48,38.09 200.94,38.93 202.37,39.83 202.38,39.84 204.23,39.84
ADOGND on SGND (solid shape): outline of 138 points within 196.79,29.83 216.34,49.01
ADOGND on SVCC (solid shape): outline of 136 points within 196.79,29.83 216.34,49.01
ADOGND on SGND1 (solid shape): outline of 138 points within 196.79,29.83 216.34,49.01
BAT-V on BOTTOM (solid shape): outline of 1006 points within 95.13,14.03 114.37,35.33
EOPIO_RCOMP on TOP (solid shape): 94.13,77.82 94.19,77.68 94.17,77.61 94.13,77.55 94.08,77.5 94.08,74.53 93.46,73.91 93.4,73.86 93.32,73.85 93.19,73.91 93.13,74.04 93.15,74.11 93.19,74.17 93.7,74.68 93.7,77.65 93.86,77.82 93.92,77.86 93.99,77.87
FBA_VREFC_1 on BOTTOM (solid shape): 133.86,97.45 133.86,97.04 133.92,96.98 133.92,96.17 133.74,95.99 133.74,94.55 133.54,94.35 133.54,93.71 133.28,93.71 133.28,94.73 133.16,94.86 133.16,96.13 133.28,96.25 133.28,96.78 133.48,96.97 133.48,97.47 133.54,97.5 133.81,97.5
G5335-AGND-2 on TOP (solid shape): outline of 288 points within 139.59,63.03 143.24,70.14
G5335-LX-1 on BOTTOM (solid shape): 116.85,40.47 116.85,39.69 117.16,39.38 117.49,39.38 117.51,39.37 117.53,39.36 117.54,39.33 117.54,36.77 117.53,36.74 117.51,36.72 117.41,36.71 117.34,36.65 117.34,35.65 117.32,35.62 117.11,35.63 117.1,35.64 117.09,35.67 117.09,36.48 116.85,36.48 116.85,35.67 116.84,35.64 116.82,35.63 116.79,35.62 116.57,35.62 116.55,35.65 116.55,38.67 116.5,38.67 116.45,38.72 114.39,38.72 114.13,38.47 114.13,36.97 113.96,36.79 111.9,36.79 111.69,36.99 111.69,38.96 116.36,38.96 116.36,39.21 115.57,39.21 115.57,38.96 111.69,38.96 111.69,40.22 112.01,40.53 116.79,40.53
G5335-LX-2 on BOTTOM (solid shape): 137.88,71.54 137.88,70.09 137.73,69.94 136.89,69.94 136.69,69.73 136.69,69.65 136.68,69.62 136.68,69.57 136.67,69.52 136.68,69.47 136.69,69.44 136.69,69.08 136.68,69.08 136.68,68.29 136.69,68.29 136.69,68.06 136.79,67.96 137.35,67.96 137.38,67.95 137.39,67.93 137.4,67.91 137.4,65.39 137.17,65.16 137.17,64.07 136.66,63.56 136.46,63.56 136.33,63.69 136.33,64.29 136.93,64.29 136.93,65.08 136.68,65.08 136.68,64.29 136.33,64.29 136.33,65.21 136.51,65.39 136.51,67.19 136.41,67.3 136.2,67.3 136.2,67.31 135.41,67.31 135.41,67.3 135.29,67.3 135.02,67.56 136.2,67.56 136.2,67.81 135.41,67.81 135.41,67.56 135.02,67.56 134.66,67.93 134.15,67.93 133.28,68.79 133.28,72.01 133.29,72.04 133.31,72.05 133.34,72.06 133.85,72.06 133.94,72.15 137.27,72.15
G5335-VCC-1 on BOTTOM (solid shape): 118.43,42.15 118.44,42.1 118.46,41.96 118.55,41.82 118.55,41.8 118.55,40.85 118.34,40.64 118.34,39.66 118.29,39.6 118.15,39.6 118.1,39.66 118.1,40.49 117.92,40.67 117.92,41.01 117.9,41.03 117.81,41.18 117.67,41.27 117.66,41.27 117.54,41.39 117.54,42.15 117.66,42.28 118.3,42.28
G5719LX1.5V on BOTTOM (solid shape): 166.3,23.99 166.3,21.96 166.18,21.83 163.26,21.83 163.1,21.98 163.1,22.72 163.23,22.85 164.91,22.85 165.03,22.97 165.03,23.3 165.04,23.32 165.05,23.34 165.16,23.61 165.05,23.88 165.03,23.9 165.03,23.99 165.16,24.12 166.18,24.12
L_SPK+ on TOP (solid shape): 115.53,17.69 115.53,16.04 115.54,16.03 115.54,15.87 116.36,15.05 116.36,14.63 116.41,14.59 116.41,14.04 116.39,14.03 114.92,14.03 114.71,14.24 114.71,14.28 114.72,14.3 114.86,14.52 114.91,14.77 114.86,15.04 114.7,15.26 114.39,15.58 114.39,17.66 114.49,17.77 115.45,17.77
L_SPK+ on BOTTOM (solid shape): 210.63,32.65 210.63,32.32 210.5,32.19 209.29,32.19 208.97,32.19 208.75,32.42 208.75,32.68 208.82,32.75 210.53,32.75
L_SPK+ on IN3 (solid shape): 116.44,15.68 116.44,14.5 116.44,14.49 116.44,14.13 116.34,14.03 114.84,14.03 114.74,14.13 114.74,15.66 114.89,15.81 116.32,15.81
L_SPK+ on IN3 (solid shape): 208.62,32.89 209.01,32.89 209.06,32.94 209.22,32.94 209.43,32.73 210.55,32.73 210.6,32.68 210.6,32.32 210.5,32.22 208.72,32.22 207.99,31.48 207.2,31.48 206.94,31.74 206.94,32.5 207.39,32.94 208.57,32.94
L_SPK+_1 on TOP (solid shape): 116.32,23.35 116.32,23 115.66,22.34 115.66,22.31 115.63,22.29 115.63,18.3 115.48,18.15 114.59,18.15 114.49,18.25 114.49,22.58 114.5,22.59 114.5,22.71 115.2,23.4 116.27,23.4
L_SPK+_1 on BOTTOM (solid shape): 116.34,23.89 116.34,22.59 116.62,22.31 116.62,20.66 116.55,20.59 115.58,20.59 115.38,20.79 115.38,21.42 115.2,21.6 115.2,23.94 115.28,24.01 116.22,24.01
L_SPK- on TOP (solid shape): 116.95,17.69 116.95,16.34 117.84,15.45 117.84,14.11 117.77,14.03 116.77,14.03 116.66,14.15 116.66,14.69 116.62,14.74 116.62,15.2 115.94,15.88 115.94,17.69 116.04,17.79 116.85,17.79
L_SPK- on IN3 (solid shape): 119.62,14.46 119.62,13.6 119.54,13.52 116.83,13.52 116.7,13.65 116.7,14.49 116.71,14.52 116.75,14.54 119.54,14.54
L_SPK- on IN3 (solid shape): 210.63,32.07 210.63,31.69 210.55,31.61 209.36,31.61 209.1,31.36 209.1,30.71 209.07,30.64 209,30.61 208.99,30.61 208.63,30.25 208.99,29.9 209.04,29.9 209.1,29.91 209.19,29.9 209.23,29.82 209.23,28.41 208.93,28.1 208.37,28.1 208.33,28.12 208.32,28.15 208.32,29.31 208.04,29.59 208.04,31.17 208.09,31.22 208.21,31.37 208.29,31.54 208.29,31.56 208.85,32.12 210.58,32.12
L_SPK-_1 on TOP (solid shape): 117.75,23.32 117.75,22.82 117.08,22.15 117.08,22.08 117.05,22.06 117.05,18.32 116.88,18.15 116.09,18.15 115.91,18.32 115.91,22.24 116.57,22.9 116.57,23.25 116.72,23.4 117.66,23.4
L_SPK-_1 on BOTTOM (solid shape): 117.74,23.91 117.74,22.59 117.64,22.49 117.64,20.69 117.56,20.61 117.05,20.61 116.95,20.71 116.95,22.34 116.6,22.69 116.6,23.96 116.65,24.01 117.64,24.01
Net_10 on BOTTOM (solid shape): outline of 638 points within 51.36,31.91 57.05,63.3
Net_11 on BOTTOM (solid shape): outline of 144 points within 52.01,64.72 57.18,72.85
Net_12 on BOTTOM (solid shape): 53.2,78.37 53.27,78.34 53.33,78.3 53.39,78.27 53.42,78.25 53.43,78.22 53.43,74.79 52.92,74.29 52.92,72.95 52.88,72.88 52.8,72.85 52.74,72.86 52.6,72.83 52.49,72.74 52.45,72.72 52.41,72.74 52.39,72.77 52.39,72.79 52.39,73.11 52.01,73.48 52.01,75.25 52.03,75.29 52.06,75.3 52.29,75.3 53.1,76.12 53.1,76.23 53.11,76.25 53.24,76.39 53.28,76.55 53.18,76.79 52.95,76.88 52.81,76.85 52.7,76.77 52.66,76.75 52.62,76.77 52.59,76.8 52.59,76.84 52.07,77.36 52.03,77.38 52.01,77.42 52.01,77.42 52.03,77.46 52.06,77.47 52.25,77.47 52.79,78.02 52.79,78.16 52.82,78.23 52.9,78.26 52.91,78.26 53.03,78.28 53.13,78.34
Net_13 on BOTTOM (solid shape): outline of 88 points within 54.29,73.31 57.18,84.1
Net_14 on BOTTOM (solid shape): outline of 108 points within 53.89,89.68 57.18,96.34
PBA_PWR on BOTTOM (solid shape): 66.36,22.92 66.36,22.17 65.89,21.7 65.89,21.52 65.67,21.3 65.67,20.69 65.37,20.38 64.83,20.38 64.7,20.51 64.7,21.09 64.45,21.35 63.49,21.35 63.16,21.68 63.16,22.19 64.11,23.14 66.14,23.14
PBA_PWR_R on BOTTOM (solid shape): 62.8,24.27 62.8,21.6 63.36,21.04 64.35,21.04 64.45,20.94 64.45,20.43 64.4,20.38 63.16,20.38 62.16,21.37 62.16,21.98 61.25,22.9 60.46,22.9 60.34,23.02 60.34,23.58 60.44,23.68 61.91,23.68 62.11,23.89 62.11,24.29 62.19,24.37 62.7,24.37
PEX_PLLVDD on TOP (solid shape): 105.88,110.98 105.88,110.36 105.87,110.34 105.87,108.75 105.68,108.56 105.68,107.8 105.63,107.76 104.97,107.76 104.89,107.83 104.89,108.44 104.61,108.72 104.43,108.72 104.26,108.89 104.26,109.32 104.36,109.42 104.36,110.01 104.47,110.12 104.62,110.12 104.62,110.24 105.03,110.65 105.03,110.97 105.19,111.12 105.73,111.12
PHASE1_CORE on BOTTOM (solid shape): 129.68,66.31 129.68,65.21 130.54,64.35 130.54,63.82 130.78,63.57 131.67,63.57 131.91,63.33 131.91,62.67 131.63,62.39 130.87,62.39 130.44,61.96 130.44,60.29 130.21,60.06 128.33,60.06 128.08,60.31 128.08,62.85 127.82,63.11 126.22,63.11 126.1,63.23 126.1,66.2 126.45,66.56 129.42,66.56
PHASE2_CORE on BOTTOM (solid shape): 130.39,56.65 130.39,56.02 131.02,55.38 131.63,55.38 131.89,55.13 131.89,54.4 131.87,54.36 131.83,54.31 131.79,54.24 131.76,54.22 130.74,54.22 130.62,54.09 130.62,52.95 130.36,52.69 128.33,52.69 128.2,52.56 128.2,50.67 128.01,50.47 124.94,50.47 124.82,50.58 124.82,53.5 127.19,55.86 127.53,55.86 127.73,56.06 127.78,56.11 127.8,56.18 127.8,56.56 127.8,56.6 127.78,56.64 127.78,56.73 127.93,56.88 130.16,56.88
PHASE_GT on BOTTOM (solid shape): 117.63,79.63 119.38,79.63 120.48,78.52 120.48,78.29 118.25,76.06 117.33,76.06 116.27,77.13 114.39,77.13 113.97,77.54 113.97,80.9 114.17,81.1 116.15,81.1
PHASE_SA on BOTTOM (solid shape): 137.09,42.15 137.09,39.94 137.42,39.61 138.08,39.61 138.15,39.53 138.15,39.09 138.09,39.03 137.01,39.03 136.84,38.86 136.84,38.34 136.71,38.21 135.06,38.21 133.92,37.07 132.09,37.07 131.6,37.56 131.6,40.13 132.85,41.38 133.62,41.38 133.7,41.47 134.51,42.28 135.82,42.28 136.14,42.59 136.65,42.59
R_SPK+ on TOP (solid shape): 120.03,17.61 120.03,17.03 120.71,16.34 120.71,16.12 120.25,15.66 119.96,15.66 118.93,16.68 118.93,17.64 119.1,17.81 119.83,17.81
R_SPK+ on TOP (solid shape): 184.63,13.77 184.63,13.36 184.67,13.31 184.7,13.29 185.25,12.74 185.25,12.51 184.86,12.11 184.38,12.11 183.25,13.25 183.25,13.27 183.03,13.75 182.56,13.98 182.52,13.99 182.51,14.03 182.51,14.9 182.64,15.02 183.37,15.02
R_SPK+ on IN3 (solid shape): 186.24,13.32 186.24,13.17 185.33,12.25 184.67,12.25 184.14,12.79 184.14,13.22 184.19,13.27 184.76,13.27 184.94,13.45 185.08,13.45 185.52,13.89 185.67,13.89
R_SPK+ on IN3 (solid shape): 210.65,30.52 210.65,30.03 210.65,30.02 210.61,29.89 210.6,29.75 210.6,28.76 210.45,28.61 209.66,28.61 209.59,28.69 209.59,29.04 209.57,29.21 209.51,29.37 209.51,30.49 209.66,30.64 210.53,30.64
R_SPK+_1 on TOP (solid shape): 120.47,23.39 120.49,23.3 120.53,23.2 120.53,22.7 119.8,21.96 119.8,18.25 119.78,18.21 119.75,18.2 118.98,18.2 118.83,18.35 118.83,21.88 119.39,22.44 119.39,23.23 119.57,23.4 120.46,23.4
R_SPK+_1 on BOTTOM (solid shape): 120.53,23.89 120.53,22.97 119.75,22.19 119.75,20.74 119.65,20.64 119.01,20.64 118.93,20.71 118.93,22.38 119.39,22.84 119.39,23.96 119.41,24 119.44,24.01 120.41,24.01
R_SPK- on TOP (solid shape): 118.5,17.64 118.5,16.06 118.4,15.96 117.92,15.96 117.44,16.45 117.44,17.46 117.77,17.79 118.35,17.79
R_SPK- on TOP (solid shape): 184.44,11.95 185,11.95 185.18,12.13 185.92,12.13 186.03,12.03 186.03,11.1 185.76,10.83 184.16,10.83 182.05,12.94 182.05,13.52 182.18,13.65 182.74,13.65
R_SPK- on IN3 (solid shape): 211.87,30.9 211.87,29.58 211.75,29.45 211.11,29.45 210.86,29.7 210.86,30.47 210.5,30.82 209.43,30.82 209.31,30.95 209.31,31.28 209.48,31.46 211.31,31.46
R_SPK- on IN3 (solid shape): 189.79,13.82 190.34,13.82 190.43,13.73 190.43,12.84 190.36,12.76 189.35,12.76 189.04,12.98 188.68,13.09 187.93,12.97 187.4,12.42 187.27,12.29 187.27,11.4 186.77,10.9 186.71,10.88 186.66,10.86 186.37,10.86 186.36,10.86 186.28,10.89 186.19,10.9 186.11,10.89 186.03,10.86 186.02,10.86 185.69,10.86 185.41,11.14 185.41,11.95 187.59,14.13 189.48,14.13
R_SPK-_1 on TOP (solid shape): 119.12,23.29 119.12,22.53 118.58,21.99 118.58,21.94 118.5,21.87 118.5,18.22 118.41,18.13 117.59,18.13 117.54,18.12 117.41,18.12 117.33,18.2 117.33,22.05 118.01,22.72 118.01,23.24 118.15,23.38 119.04,23.38
R_SPK-_1 on BOTTOM (solid shape): 119.14,23.94 119.14,22.95 118.63,22.44 118.63,20.71 118.61,20.68 118.58,20.66 117.94,20.66 117.92,20.69 117.92,22.41 117.99,22.49 117.99,23.91 118.07,23.99 119.09,23.99
RING2 on TOP (solid shape): 213.1,43.61 213.1,43.2 213.04,43.14 212.05,43.14 211.82,42.91 211.47,42.91 211.29,42.73 211.29,42.63 211.19,42.53 210.83,42.53 210.77,42.59 210.77,43.18 211.03,43.45 211.03,43.7 211.44,44.11 212.61,44.11
RING2 on BOTTOM (solid shape): 214.11,45.55 214.14,45.54 214.16,45.5 214.16,45.3 214.14,45.26 214.11,45.25 212.8,45.25 212.8,45.05 214.11,45.05 214.14,45.04 214.16,45 214.15,44.92 214.15,44.86 214.12,44.78 214.05,44.75 212.8,44.75 212.8,44.55 214.1,44.55 214.16,44.63 214.27,44.61 214.29,44.59 214.31,44.58 214.31,44.55 214.31,44.33 214.23,44.26 212.33,44.26 211.97,43.9 211.97,43.09 211.85,42.96 211.54,42.96 211.51,42.98 211.49,43.01 211.49,44.15 212.54,45.19 212.65,45.34 212.72,45.51 212.72,45.53 212.75,45.55
RING2 on IN3 (solid shape): 211.97,44.16 211.97,43.72 211.82,43.57 209.97,43.57 209.74,43.8 209.74,44.31 209.99,44.56 211.57,44.56
RING2 on IN3 (solid shape): 199.32,33.51 199.32,33.47 199.32,32.8 199.32,32.78 200.52,31.58 200.52,31.46 200.24,31.18 199.88,31.18 198.31,32.75 198.31,33.13 198.18,33.26 198.18,33.77 198.31,33.9 198.94,33.9
SLEEVE on TOP (solid shape): 213.19,42.63 213.19,42.23 213.14,42.18 212.76,42.18 212.58,42.35 212.1,42.35 211.19,41.44 210.86,41.44 210.75,41.54 210.75,42.15 210.88,42.28 211.26,42.28 211.47,42.48 211.47,42.63 211.59,42.76 211.9,42.76 212.15,43.01 212.81,43.01
SLEEVE on BOTTOM (solid shape): 212.8,44.05 214.16,44.05 214.21,44 214.21,42.82 214.13,42.75 212.75,42.75 212.43,42.43 212.1,42.43 211.9,42.23 211.54,42.23 211.49,42.28 211.49,42.71 211.59,42.81 211.85,42.81 212.09,43.05 214.1,43.05 214.1,43.25 212.8,43.25 212.8,43.05 212.09,43.05 212.1,43.06 212.1,43.55 214.1,43.55 214.1,43.75 212.8,43.75 212.8,43.55 212.1,43.55 212.1,43.78 212.38,44.06 212.8,44.06
SLEEVE on IN3 (solid shape): 201.99,33.39 201.99,32.75 201.61,32.37 200.47,32.37 199.83,33.01 199.83,33.26 200.21,33.64 201.74,33.64
SLEEVE on IN3 (solid shape): 212.56,42.91 212.56,42.48 212.46,42.38 212.13,42.38 211.52,41.77 210.25,41.77 209.99,42.02 209.99,42.53 210.22,42.76 210.78,42.76 210.93,42.91 211.92,42.91 212.05,43.04 212.43,43.04
TRA_V_DAC on TOP (solid shape): 34.96,104.58 35,104.57 35.01,104.53 35.01,104.1 34.56,103.64 29.63,103.64 28.54,102.55 28.54,102.09 28.36,101.92 27.82,101.92 27.6,102.14 27.6,103.47 27.72,103.59 27.77,103.59 28.2,103.71 28.5,104.04 28.51,104.05 28.53,104.06 28.74,104.2 28.82,104.43 28.81,104.47 28.84,104.55 28.91,104.58
TRA_V_DAC on IN1 (solid shape): 37.93,105.32 37.93,104.28 37.81,104.15 37.11,104.15 37.02,104.22 37.05,104.33 37.15,104.46 37.18,104.61 37.08,104.86 36.82,104.96 36.66,104.92 36.53,104.81 36.44,104.76 36.36,104.81 36.23,104.92 36.06,104.96 35.9,104.92 35.77,104.81 35.7,104.77 35.63,104.79 35.52,104.84 35.4,104.86 35.13,104.75 35.02,104.48 35.03,104.39 35.07,104.3 35.06,104.2 34.98,104.15 28.94,104.15 28.8,104.29 28.8,104.32 28.81,104.38 28.82,104.43 28.8,104.55 28.74,104.66 28.74,105.37 29.32,105.95 37.3,105.95
USBPWRD2 on BOTTOM (solid shape): outline of 250 points within 206.93,21.96 215.33,30.57
VA on TOP (solid shape): 44.14,122.49 44.14,122.46 44.19,122.28 44.3,122.14 44.33,122.11 44.33,122.09 44.33,121.8 44.18,121.65 43.75,121.65 43.73,121.66 43.72,121.66 43.6,121.78 42.54,121.78 42.38,121.78 42.15,121.55 42.15,117.82 40.3,115.96 39.76,115.96 38.8,115 25.72,115 23.56,112.84 22.34,112.84 21.02,114.16 17.28,114.16 15.26,116.18 15.24,116.22 15.17,116.27 13.5,116.27 12.85,115.62 11.44,115.62 11.29,115.77 11.29,116.22 11.35,116.4 11.37,116.6 11.35,116.8 11.29,116.98 11.29,118.1 11.54,118.35 13.16,118.35 13.21,118.32 13.21,118.31 14.15,117.26 15.5,116.87 22.41,116.87 22.51,116.8 22.48,116.69 22.44,116.65 22.44,115.73 23.1,115.07 24.01,115.07 24.68,115.73 24.68,116.65 24.63,116.69 24.61,116.8 24.7,116.87 32.7,116.87 32.74,116.87 34.8,116.87 36.11,118.18 36.12,118.19 36.22,118.26 36.29,118.36 36.3,118.37 36.59,118.65 36.59,118.68 37.02,119.11 37.02,121.08 37.02,121.09 37.06,121.31 37.02,121.52 37.02,121.53 37.02,122.32 37.02,122.36 37.02,122.57 37.23,122.77 43.85,122.77
VA on BOTTOM (solid shape): 41.92,122.74 41.92,121.25 41.72,121.04 39.41,121.04 39.2,121.25 39.2,121.93 39.08,122.06 37.35,122.06 37.04,122.36 37.04,122.74 37.17,122.87 41.8,122.87
VA on BOTTOM (solid shape): 13.25,118.23 13.26,118.22 14.19,117.23 15.5,116.87 22.12,116.87 22.29,116.7 22.29,116.06 22.28,116.04 22.27,116.03 22.04,115.79 21.24,115 15.5,115 15.45,114.95 15.43,114.95 14.64,114.95 14.24,115.35 11.62,115.35 11.36,115.61 11.36,116.48 11.37,116.54 11.37,116.6 11.37,116.66 11.36,116.72 11.36,118.06 11.57,118.26 13.21,118.26
VA on IN1 (solid shape): 42.15,122.46 42.15,118.78 41.85,118.48 40.4,118.48 36.89,114.97 25.56,114.97 23.43,112.84 22.39,112.84 20.94,114.29 16.83,114.29 16.19,114.92 15.8,114.92 15.77,114.92 14.67,114.92 14.29,115.3 11.49,115.3 11.34,115.45 11.34,116.49 11.34,116.54 11.35,116.6 11.34,116.66 11.34,116.71 11.34,117.69 11.57,117.92 13.42,117.92 13.53,117.8 14.41,117.11 15.5,116.87 32.7,116.87 32.8,116.87 32.9,116.87 32.98,116.88 34.76,116.88 34.78,116.9 34.96,116.9 36.53,118.47 36.53,120.93 36.55,120.96 36.57,120.96 36.85,121.31 36.57,121.66 36.55,121.66 36.53,121.69 36.53,121.85 36.56,121.93 36.63,121.96 37,122.22 36.85,122.66 36.8,122.73 36.83,122.81 36.89,122.87 41.75,122.87
VA on IN2 (solid shape): 42.15,122.46 42.15,117.59 41.72,117.16 40.35,117.16 38.19,115 25.67,115 23.51,112.84 22.44,112.84 20.99,114.29 16.7,114.29 16.04,114.95 14.64,114.95 14.24,115.35 11.44,115.35 10.99,115.81 10.97,115.85 10.99,115.88 11.34,116.73 10.76,117.44 10.74,117.46 10.73,117.49 10.73,117.72 11.27,118.26 13.21,118.26 13.25,118.23 13.26,118.22 14.19,117.23 15.5,116.87 32.7,116.87 32.84,116.87 32.98,116.88 34.76,116.88 36.07,118.19 36.08,118.2 36.2,118.28 36.28,118.4 36.29,118.41 36.53,118.64 36.53,120.91 36.54,120.94 36.57,120.96 36.85,121.31 36.57,121.66 36.54,121.68 36.53,121.71 36.53,121.85 36.56,121.93 36.63,121.96 37,122.22 36.85,122.66 36.8,122.73 36.83,122.81 36.89,122.87 41.75,122.87
VA on SVCC (solid shape): 42.35,122.46 42.35,119.32 39.71,116.68 39.6,116.51 39.56,116.32 39.56,115.51 38.97,114.92 25.74,114.92 25.72,114.92 25.58,114.85 25.48,114.77 23.47,112.76 22.41,112.76 21.04,114.14 21.01,114.15 20.99,114.16 17.29,114.16 16.17,115.28 16,115.39 15.81,115.43 10.43,115.43 10.08,115.78 10.08,118.55 10.29,118.95 10.43,119.37 12.97,119.37 13.72,117.6 15.5,116.87 32.7,116.87 34.49,117.61 35.23,119.4 35.23,122.87 41.94,122.87
VA on IN3 (solid shape): 42.15,122.46 42.15,119.16 41.67,118.68 39.2,118.68 35.49,114.97 25.59,114.97 24.78,114.17 21.12,114.17 20.72,114.57 17.56,114.57 17.18,114.95 14.64,114.95 14.24,115.35 11.11,115.35 10.78,115.69 10.76,115.73 10.79,115.77 11.35,116.64 10.71,117.46 10.69,117.48 10.68,117.51 10.68,117.66 11.27,118.26 13.21,118.26 13.25,118.23 13.26,118.22 14.19,117.23 15.5,116.87 32.7,116.87 32.84,116.87 32.98,116.88 34.76,116.88 36.07,118.19 36.08,118.2 36.2,118.28 36.28,118.4 36.29,118.41 36.53,118.64 36.53,120.93 36.55,120.96 36.57,120.96 36.85,121.31 36.57,121.66 36.54,121.68 36.53,121.71 36.53,121.85 36.56,121.93 36.63,121.96 37,122.22 36.85,122.66 36.8,122.73 36.83,122.81 36.89,122.87 41.75,122.87
VA2 on TOP (solid shape): 46.92,122.39 46.92,121.01 46.44,120.53 45.36,120.53 45.18,120.35 45.17,120.35 44.72,119.89 44.72,116.65 44.5,116.43 43.82,116.43 43.28,116.98 42.76,116.98 42.48,117.26 42.48,120.46 42.73,120.71 44.6,120.71 45.31,121.42 45.58,121.42 45.62,121.43 45.66,121.45 45.68,121.45 46.09,121.86 46.09,122.34 46.19,122.44 46.87,122.44
N17047007 on TOP (solid shape): 51.55,118.91 51.55,114.74 51.23,114.43 46.86,114.43 46.73,114.57 46.11,114.57 45.25,115.43 45.25,119.58 45.63,119.96 50.5,119.96
N17047087 on TOP (solid shape): 122.46,30.65 123.07,30.65 123.21,30.79 123.69,30.79 123.94,30.53 123.94,28.81 123.72,28.58 123.39,28.58 123.18,28.38 123.18,28.07 122.7,27.58 117.65,27.58 117.4,27.84 117.4,29.05 119.43,31.09 122.03,31.09
N17047087 on BOTTOM (solid shape): 120.62,31.08 120.62,27.06 120.19,26.64 113.16,26.64 113.12,26.65 113.11,26.69 113.11,29.86 113.18,29.93 113.31,29.93 114.79,31.41 120.29,31.41
N18867651 on TOP (solid shape): 152.87,26.58 153.3,26.15 153.7,26.15 153.74,26.13 153.75,26.1 153.75,25.38 153.95,25.38 153.95,26.06 153.98,26.11 154.03,26.1 154.11,26.02 154.11,25.39 154.21,25.29 154.22,25.28 154.22,25.26 154.22,25.08 154.39,24.91 154.39,23.81 154.21,23.63 152.44,23.63 152.31,23.76 152.31,24.16 152.31,24.16 152.34,24.29 152.31,24.42 152.31,24.43 152.31,24.5 151.78,25.03 151.78,26.53 151.83,26.58 152.33,26.58
