# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N30795490: length 14.9
  TOP w0.102: R2163.2 106.21,72.6 v1(106.69,72.12)
  IN1 w0.089: v1(106.69,72.12) 106.08,72.74 105.08,72.74 104.55,72.21 103.42,72.21 102.4,71.18 99.12,71.18 98.66,71.64 95.34,71.64 v1(95.11,71.87)
  BOTTOM w0.102: v1(95.11,71.87) 94.4,71.87 94.06,72.2 U2030.F65
N31069510:
  vias: v1(157.07,25.82)
N31161958: length 3.9
  TOP w0.203: v1(154.93,28.71) 154.85,28.64 PU6001.4
  BOTTOM w0.102: v1(155.47,26.92) 155.48,26.92 PR6013.2
  BOTTOM w0.203: PR6013.2 PC6025.1 154.93,28.12 v1(154.93,28.71)
N31161974: length 2
  TOP w0.203: PC6028.1 155.25,24.61 PU6001.12
N31161976: length 2
  TOP w0.203: PU6001.10 154.45,25.23 154.77,24.9 154.77,24.34 154.93,24.19 PC6029.1
N31162017: length 5.6
  TOP w0.203: v1(154.29,28.71) 154.29,28.48 154.42,28.36 154.42,28.35 154.45,28.32 PU6001.5
  BOTTOM w0.102: PR6016.2 151.26,27.15 v1(151.08,26.97)
  BOTTOM w0.203: PR6016.2 PC6027.1 152.02,27.88 152.35,28.2 154.13,28.2 154.29,28.36 v1(154.29,28.71)
N31162025: length 4.2
  TOP w0.203: v1(155.59,28.69) 155.25,28.35 PU6001.3
  BOTTOM w0.102: v1(157.68,28.78) 157.44,29.02 PR6015.1
  BOTTOM w0.203: PR6015.1 157.16,29.55 157.07,29.46 PC6026.1 156.36,29.46 v1(155.59,28.69)
N31353058:
  vias: v1(29.92,27.8)
N31353100: length 1.4
  TOP w0.508: PC551.2 PR551.2
N31375926: length 6.1
  TOP w0.102: PR9272.1 PR9258.1 123.71,51.07 125.48,52.83 v1(125.48,52.86) 125.96,52.38 PQ7.2
N32194800: length 14.9
  TOP w0.102: v1(83,70.04) 83.17,70.21 R2170.2
  BOTTOM w0.102: v1(83,70.04) 84.1,70.04 84.69,69.45 90.54,69.45 90.87,69.11 90.87,64.97 90.98,64.86 U2030.K52
N33618596: length 2.8
  TOP w0.102: R653.2 13.35,3.56 v1(14.23,4.45) 14.23,4.88 Q34.3
N33652665: length 1
  BOTTOM w0.102: R655.2 EC12.1
N33761123: length 3.1
  TOP w0.102: R645.1 30.25,2.42 R2660.1 30.14,2.8 v1(30.6,3.26)
  BOTTOM w0.102: CN16.38 v1(30.6,3.26)
N33761125: length 2.1
  TOP w0.102: R648.1 27.8,3.08 v1(27.65,3.26)
  BOTTOM w0.102: v1(27.65,3.26) 27.6,3.19 CN16.50
N33761127: length 2.8
  TOP w0.102: TP81.1 24.47,2.98 v1(24.42,3.03)
  BOTTOM w0.102: CN16.68 23.1,2.7 23.28,2.88 24.27,2.88 v1(24.42,3.03)
N34044006: length 2
  BOTTOM w0.102: v1(126.25,77.34) 126.25,78.07 PR7109.2
  BOTTOM w0.254: PR7109.2 126.74,78.14 PU7003.5
N34044116: length 2.9
  TOP w0.508: v1(126.25,76.09) 126.59,76.43 PC7101.2
  BOTTOM w0.254: PU7003.4 127.25,76.07 127.11,75.93 126.4,75.93 v1(126.25,76.09)
N34044137: length 3.2
  BOTTOM w0.102: 126.44,74.98 127.1,74.32 v1(127.15,74.32)
  BOTTOM w0.254: PU7003.3 127.75,75.91 127.24,75.4
  BOTTOM w0.508: 127.24,75.4 126.87,75.4 126.44,74.98
N34045443: length 3.5
  BOTTOM w0.102: PR7113.2 v1(137.25,43.6)
  BOTTOM w0.152: PR7113.2 138.06,43.4 138.4,43.05 139.75,43.05 139.98,42.81 PU7004.5
N34045547: length 2.9
  TOP w0.102: v1(140.23,41.18) 140.24,41.17 PC7103.2
  TOP w0.508: PC7103.2 139.94,39.9 v1(139.94,39.34)
  BOTTOM w0.305: PU7004.4 139.98,39.38 v1(139.94,39.34)
N34045574: length 2
  TOP w0.508: v1(140.61,39.3) 140.61,39.11 140.03,38.53 PR7114.1
  BOTTOM w0.305: v1(140.61,39.3) 140.48,39.43 PU7004.3
N34047546: length 1.6
  TOP w0.508: PR7105.2 119.65,67.89 v1(120.1,67.89)
  BOTTOM w0.254: PU7002.5 119.99,68 v1(120.1,67.89)
N34047656: length 1.8
  TOP w0.508: PC7105.2 119.77,70.29 119.95,70.12 v1(120.17,70.12)
  BOTTOM w0.254: v1(120.17,70.12) 120.04,70.25 PU7002.4
N34047677: length 9
  IN3 w0.508: v1(119.14,71.12) 119.35,71.33 121.12,71.33 122.85,73.06 v1(125.36,73.06)
  BOTTOM w0.254: PU7002.3 118.96,70.92 119.14,71.11 v1(119.14,71.12)
  BOTTOM w0.508: PR7106.1 124.53,73.06 v1(125.36,73.06)
N36446693: length 2.6
  TOP w0.102: Y4.3 44.55,111.57 C639.2 44.88,110.81 44.92,110.76 R512.2
N36964592: length 4.5
  BOTTOM w0.102: v1(63.66,25.22) 63.66,24.36 63.94,24.08 Q32.2
  BOTTOM w0.254: R609.2 66,24.67 65.64,24.31
  BOTTOM w0.508: Q32.2 64.86,23.68 C750.2 65.64,24.31
N36964655: length 3.3
  TOP w0.102: R589.2 52.44,18.6 52.56,18.73 v1(53.16,18.73) 53.98,18.73 54.42,19.16 U32.7
N36977514: length 6.2
  BOTTOM w0.102: Q31.3 198.16,21.02 198.16,19.83 R579.2 198.01,19.73 197.09,18.81 197.09,17.31 196.81,17.03 Q30.2
N37139396: length 1
  TOP w0.102: R600.1 129.93,20.84 129.69,21.08 D22.2
N37139525: length 3.1
  TOP w0.102: U33.24 122.79,18.41 122.79,16.98 122.54,16.72 121.95,16.72 121.85,16.62 R598.2
N37139527: length 1.4
  TOP w0.102: R597.2 122.08,19.85 122.44,20.21 U33.21
N37139529: length 4.3
  TOP w0.102: U33.19 122.58,21.21 122.16,21.63 122.16,22.29 121.69,22.76 121.69,23.75 R596.2
N37139539: length 3.7
  TOP w0.102: U33.18 122.56,21.71 122.39,21.88 122.39,22.55 122.62,22.78 122.62,23.24 v1(122.34,23.52) 122.34,23.69 R593.2
N37139543: length 1.3
  TOP w0.102: U33.20 122.46,20.71 122.25,20.92 R599.2
N37139545: length 1.7
  TOP w0.102: U33.29 125.94,17.26 126.04,17.16 126.22,17.16 126.63,16.75 R592.2
N37165848: length 3.1
  TOP w0.381: R449.2 211.9,32.37 211.78,32.25 R448.2 v1(211.39,32.88)
  BOTTOM w0.381: v1(211.39,32.88) 211.23,33.04 L28.1
N37165855: length 1
  BOTTOM w0.102: R454.1 211.49,27.52 TP9023.1
N37165865: length 3
  BOTTOM w0.203: U20.16 200.92,31.63 200.33,31.04 199.94,31.04 199.84,31.14 199.13,31.14 C843.1
N37165875: length 1.6
  BOTTOM w0.102: R25371.2 196.56,33.42 R735.2
N37313384: length 4.6
  BOTTOM w0.254: R25519.1 102.85,123.46 102.6,123.46 102.26,123.12 C20005.2 102.21,122.8 101.42,122.8 R25520.1 101.09,123.13 101.09,123.87 101.27,124.05 U6504.5
N37316052: length 1.4
  BOTTOM w0.508: Q9.2 98.16,123.24 R25522.2
N37317583: length 1.3
  TOP w0.254: v2(98,102.48) 98,102.61 97.75,102.86 R329.1
  BOTTOM w0.254: v2(98,102.48) 98.37,102.84 U8.N6
N37318300: length 6.8
  BOTTOM w0.102: R25537.1 88.34,99.73 Q6551.2 87.35,101.33 87.92,101.9 C20017.1 88.81,102.26 88.81,103.31 89.26,103.76 v1(89.34,103.76) 89.76,103.76 Q6550.3
N37318343: length 2.2
  BOTTOM w0.102: Q6550.2 90.88,101.77 R25535.2 C20016.2
N37320415: length 2.4
  BOTTOM w0.102: R25553.2 93.13,88.67 R25551.2 R368.2 R367.2
N37320741: length 2.9
  BOTTOM w0.102: R364.2 94.41,88.63 R25552.2 95.09,88.91 95.18,89.01 95.56,89.01 R363.2 R366.2
N37360972: length 2.2
  BOTTOM w0.102: v1(132.33,64.13) 132.32,64.14 PR7072.1
  BOTTOM w0.508: PC7046.2 131.24,64.25 PR7072.1
N37360977: length 1.2
  BOTTOM w0.508: PR7081.1 PC7064.2
N37361974: length 2.3
  TOP w0.102: v1(75.28,117.36) 75.38,117.46 PC9012.1
  TOP w0.508: PC9012.1 75.43,118.22 PR9004.1
N37375256: length 9.2
  BOTTOM w0.102: R25570.1 90.1,90.18 v1(90.38,90.47) 91.14,90.47 91.98,91.31 94.06,91.31 94.38,91.63 95.3,91.63 96.39,92.71 96.39,93.49 U8.B4
N37375435: length 1.2
  TOP w0.102: R25571.1 98.66,96.84 v2(98.87,96.63)
  BOTTOM w0.102: v2(98.87,96.63) 99.23,96.27 U8.E7
N37375540: length 44
  TOP w0.102: R25560.1 102.02,123.86 102.02,125.82 v1(102.12,125.92)
  IN1 w0.089: v2(98.22,92.55) 98.27,92.6 98.27,94.36 99.25,95.34 99.25,99.88 99.9,100.53 99.9,101.72 99.99,101.81 99.99,103.24 99.79,103.44 99.79,107.95 101.68,109.84 101.68,112.88 102.55,113.75 103.26,113.75 103.64,114.13 103.64,114.92 105.9,117.17 105.9,119.74 105.61,120.02 105.61,122.1 105.86,122.34 105.86,122.66 105.98,122.79 105.98,123.95 105.68,124.25 105.21,124.25 104.99,124.04 104.99,124 104.78,123.8 103.53,123.8 102.12,125.21 v1(102.12,125.92)
  BOTTOM w0.102: v2(98.22,92.55) 98.33,92.55 98.43,92.66 U8.A6
N37377888: length 3
  TOP w0.102: R25575.2 110.49,84.05 109.79,83.35 R25574.2 108.97,82.8 Q6512.2
N37379368: length 8.9
  TOP w0.102: Q13.5 107.38,87.93 107.21,88.09 106.52,88.09 ; 106.52,88.09 106.1,88.51 R25580.1 ; 106.52,88.09 106.39,87.97 106.39,86.14 106.51,86.02 107.25,86.02 107.38,85.89 Q13.2 107.38,84.63 107.13,84.39 106.44,84.39 106.23,84.6 R25581.1
N37380003: length 7.4
  BOTTOM w0.254: R25579.2 88.59,98.55 87.81,97.77 R347.2 R346.2 R344.2 R345.2 R349.2 87.81,93.28 87.98,93.11 R348.2 87.93,92.59 87.07,92.59 R25588.2
N37380342: length 3.1
  TOP w0.254: R25577.1 R341.2 R343.2 112.26,80.25 R342.2
N37568058:
  vias: v1(123.96,122.65)
N37598035: length 2.4
  TOP w0.102: R507.1 21.01,83.29 U23.4
N37834251: length 15.6
  BOTTOM w0.102: R25587.2 92.32,106.78 93.58,105.52 93.58,99.77 94.11,99.23 97.63,99.23 97.94,98.93 97.94,97.62 U8.F6
N38517581: length 2.8
  TOP w0.102: R25339.1 16.37,10.21 16.33,10.18 D6542.1 16.62,9.22 R25338.2
N38517589: length 2.4
  TOP w0.102: v1(16.79,7.62) 16.79,8.37 R25338.1 17.3,8.44 17.81,8.94 Q6518.2
N38517597:
  vias: v1(18.27,11.47)
N38517605: length 3.5
  TOP w0.102: R25341.1 19.52,12.33 v1(20.2,11.64) 20.52,11.32 Q6519.3
N38517627: length 2.4
  TOP w0.102: R25342.2 v1(14.4,10.56) 13.91,10.08 Q6515.3
N38517632: length 5.9
  TOP w0.102: Q6519.5 23.4,11.97 23.2,12.18 23.2,12.41 23.42,12.62 Q6519.6 24.38,12.62 24.41,12.6 C6584.2 ; R6603.1 26.08,13.7 C6584.2 ; v1(24.11,13.27) 24.31,13.27 C6584.2
N38517638: length 5.1
  TOP w0.102: R25337.2 C6583.2 15.5,6.35 v1(14.7,6.35) 13.91,6.35 12.24,8.02 Q6515.2
N38521997: length 27.9
  TOP w0.102: R720.1 151.71,20.77 D33.2 152.48,20 153.39,20 v1(153.84,19.54)
  IN2 w0.089: v1(153.84,19.54) 153.91,19.54 154.31,19.94 155.87,19.94 156.63,20.71 158.39,20.71 159.02,21.34 162.66,21.34 162.79,21.47 163.41,21.47 164.35,22.41 167.37,22.41 167.98,23.02 169.07,23.02 169.49,22.6 174.01,22.6 v1(174.13,22.72)
  BOTTOM w0.102: CN18.1 175,21.49 174.13,22.36 v1(174.13,22.72)
N38674948: length 21.4
  IN1 w0.089: v1(140.38,47.49) 139.94,47.94 139.19,47.94 137.19,49.94 135.33,49.94 133.9,51.36 132.3,51.36 128.25,55.42 126.19,55.42 125.72,55.89 v1(125.41,55.89)
  BOTTOM w0.102: PR7082.2 126.96,55.89 v1(125.41,55.89)
  BOTTOM w0.203: PR7084.1 140.62,47.49 v1(140.38,47.49)
N38680042: length 3.7
  BOTTOM w0.102: D11.1 192.26,34.2 v1(192.9,34.83) 193.37,34.83 D6543.1 194,34.41 194.99,33.42 R25371.1
N38680880: length 3.7
  TOP w0.102: Q6523.2 177.57,31.14 177.99,30.72 178.81,30.72 179.31,30.22 R576.2
N38756671: length 12.3
  TOP w0.102: U37.66 198.11,16.18 197.97,16.04 197.97,15.24 198.49,14.72 198.68,14.72 198.93,14.48 198.93,13.96 v1(198.43,13.47) 198.43,13.09 196.8,11.46 196.8,10.22 196.7,10.12 196.22,10.12 195.99,10.36 195.99,10.79 195.62,11.16 C6568.2 194.84,11.59 193.74,11.59 R25318.1
N38756738: length 5.8
  TOP w0.102: C1208.2 201.42,22.59 201.14,22.59 200.89,22.84 v1(200.24,22.84) 199.94,22.84 199.67,22.58 U37.82 198.18,22.58 197.94,22.34 v2(197.65,22.34)
  BOTTOM w0.102: R960.1 198.21,22.69 197.86,22.34 v2(197.65,22.34)
N38756749: length 3
  TOP w0.102: TP9037.1 201.05,23.46 199.92,24.58 U37.87
N38756787: length 2.8
  TOP w0.102: U37.98 196.85,30.62 C6580.2 196.33,31.61 R895.1
N38756834: length 33.8
  TOP w0.102: Q81.3 23.8,41.48 v1(21.35,41.48)
  IN1 w0.089: v1(19.42,57.69) 19.42,57.09 18.46,56.13 18.46,55.39 16.94,53.87 16.94,52.98 16.52,52.56 16.52,51.98 17.23,51.27 17.23,50.35 16.77,49.9 16.77,45.6 19.54,42.83 20.88,42.83 21.61,42.1 21.61,41.75 v1(21.35,41.48)
  BOTTOM w0.102: SW2.4 SW2.3 16.95,58.79 17.11,58.63 17.86,58.63 18.8,57.69 v1(19.42,57.69) 19.42,57.82 20,58.41 21.16,58.41 R25321.1
N38757016: length 1.6
  TOP w0.102: TP9038.1 182.2,20.31 182.48,20.58 U37.20
N38757336: length 6.2
  TOP w0.102: R25308.1 181.85,31.02 182.49,31.02 C6563.1 183.27,31.48 184.19,30.56 v1(184.19,29.94) 184.23,29.89 184.23,29.24 184.36,29.11 184.72,29.11 184.85,29.23 U37.128
N38757406: length 145.5
  TOP w0.102: v2(30.92,34.76) 30.92,35.06 30.82,35.17 29.09,35.17 27.57,36.69 27.57,36.82 25.84,38.54 24.4,38.54 C1044.1 23.74,39.72 24,39.98 Q81.2
  IN2 w0.089: v1(66.86,106.18) 66.41,106.63 63.44,106.63 62.57,107.5 61.02,107.5 60.74,107.78 60.74,108.08 60.34,108.49 54.79,108.49 54.34,108.04 53.06,108.04 52.28,107.26 50.58,107.26 50.25,107.6 48.61,107.6 48.02,107.01 45.87,107.01 45.58,107.29 43.27,107.29 40.94,104.96 37.55,104.96 37.4,105.11 26.4,105.11 25.87,104.58 25.87,104.25 24.78,103.16 24.65,103.16 23.58,102.08 v1(23.58,101.89)
  BOTTOM w0.102: v2(30.92,34.76) 30.92,35.29 30.8,35.42 30.8,39.73 30.5,40.02 30.5,40.58 30.97,41.06 30.97,50.11 29.37,51.71 29.37,55.02 29.83,55.47 29.83,57.2 30.14,57.51 30.14,71.33 30.47,71.66 30.74,71.66 31.56,72.48 31.56,73.9 32.01,74.35 32.01,75.33 30.77,76.57 30.77,80.9 30.14,81.53 30.14,82.75 29.42,83.47 29.42,91.67 24.4,96.7 24.4,98.28 23.76,98.92 23.76,101.51 23.58,101.69 v1(23.58,101.89) ; v1(66.86,106.18) 66.86,106.08 65.75,104.96 65.52,104.96 65.34,104.79 R25310.2 65.57,104.23 66.47,104.23 SW3.3 66.26,104 65.67,103.41 65.67,102.25 66.28,101.64 67.67,101.64 67.93,101.37 67.93,100.27 66.7,99.03 SW3.4
N38758998: length 1
  TOP w0.102: R402.1 C6562.2
N38759178: length 4.1
  TOP w0.102: U37.12 181.25,23.78 181.09,23.93 179.61,23.93 179.47,24.08 C1190.1
N39168858: length 43.3
  TOP w0.203: v1(15.71,83.09) 15.37,83.09 14.57,82.3 R706.2 R707.2 14.57,80.45 R708.2 ; 14.06,77.33 v1(13.09,77.33) 12.63,76.87 12.63,74.03 13.14,73.52 14.29,73.52 14.57,73.8 R713.2 ; 14.06,77.33 R710.2 14.57,78.28 R709.2 ; 14.06,77.33 R711.2 R712.2
  IN2 w0.203: v1(13.09,77.33) 15,79.23 15,82.38 v1(15.71,83.09)
  IN3 w0.508: v1(22.44,86.04) 22.44,85 22.82,84.62 22.82,83.35 23.49,82.68 23.49,80.22 23.91,79.79 23.91,79.02 24.76,78.17 24.76,75.23 25.84,74.15
  BOTTOM w0.508: v1(22.44,86.04) 22.01,85.62 20.34,85.62 19.21,84.48 16.69,84.48 15.71,83.5 v1(15.71,83.09)
  vias: v1(27.21,73.29)
N39255818: length 4.7
  BOTTOM w0.102: CN29.24 55.35,106.24 55.94,105.65 57.08,105.65 57.34,105.4 57.34,103.98 R25598.2
N39255859: length 1.5
  BOTTOM w0.102: CN29.29 57.85,105.66 R25599.2
N39395217: length 4.7
  TOP w0.381: PD9002.3 130.87,35.29 128.29,32.71 PR16.2
N39687060:
  vias: v1(67.6,116.21)
N39687062: length 1.9
  TOP w0.381: PC301.1 65.27,116.08 66.19,115.16 PR262.2
N39687064:
  vias: v1(63.59,116.32)
N39687102: length 21.7
  TOP w0.178: PU26.30 66.41,121.3 66.53,121.42 66.53,121.65 66.35,121.84 v1(66.07,121.84)
  IN3 w0.254: v1(66.07,121.84) 66.07,123.18 65.47,123.79 62.8,123.79 61.12,125.46 52.11,125.46 51.36,124.71 51.36,122.59 51.62,122.32 v1(51.62,121.68)
  vias: v1(50.99,121.68) v1(50.99,121.04) v1(50.99,120.41) v1(51.62,121.04) v1(51.62,120.41) v1(52.16,119.65) v1(52.16,119.01) v1(52.79,119.65) v1(52.79,119.01) v1(53.43,119.65) v1(53.43,119.01) v1(54.06,119.65)
N39687293: length 1.7
  TOP w0.508: PC300.2 60.65,117.03 PR9264.1
N39687315: length 23.3
  TOP w0.203: v1(67.63,123.94) 67.63,123.28 68.44,122.46 PR263.2 68.8,121.95 68.96,122.12 69.12,122.12 PC267.2
  IN3 w0.254: v1(67.63,123.94) 67.43,124.14 62.95,124.14 61.27,125.82 51.55,125.82 v1(51.29,125.56)
  BOTTOM w0.152: PR9266.2 50.46,123.73 51.07,124.34 51.07,125.34 v1(51.29,125.56)
N39687335: length 5.5
  TOP w0.203: PR265.1 66.11,124.67 66.13,124.64 66.13,123.89 65.93,123.69 65.35,123.69 PC283.1 64.66,124.17 64.02,123.53 64.02,122.85 63.87,122.7 PU26.4
N39687341: length 3.7
  TOP w0.198: PU26.8 61.74,121.3 61.49,121.55 61.49,121.99
  TOP w0.203: PR261.2 61.32,124.25 61.49,124.08 61.49,123.67
  TOP w0.457: 61.49,121.99 61.49,123.67
N39687373: length 5.8
  TOP w0.203: PC276.1 63.61,123.88 63.61,122.97 v1(63.41,122.77) 63.47,122.71 PU26.5
  TOP w0.254: PC276.1 63.9,124.16 64.66,124.91 PR266.1
  BOTTOM w0.203: PR9273.1 65.14,122.9 64.86,122.62 63.56,122.62 v1(63.41,122.77)
N39687445: length 5.1
  TOP w0.203: PC267.1 69.12,121.34 68.6,121.34 PR263.1 68.09,121.5 PR253.2 66.9,122.69 66.49,122.69 66.14,122.35 65.67,122.35 65.47,122.15 PU26.1
N39687482:
  vias: v1(66.23,123.21)
N39687516: length 4.6
  TOP w0.203: v1(66.69,122.21) 66.97,121.93 66.97,121.27 66.59,120.9 PU26.29
  BOTTOM w0.203: v1(66.69,122.21) 66.69,122.94 PR254.1 PC298.1
N39688806: length 2.3
  TOP w0.203: v1(62.52,122.72) 62.75,122.72 63.07,122.4 PU26.6
  BOTTOM w0.203: v1(62.52,122.72) 62.34,122.9 PR267.1
N39785725: length 8
  TOP w0.102: v1(215.29,11.45) 214.5,11.45 R25485.1 R25483.1
  BOTTOM w0.102: HD1.1 214.92,16.32 215.26,15.98 215.26,11.91 215.29,11.89 v1(215.29,11.45)
N40437801: length 9.9
  BOTTOM w0.102: TP9033.1 90.92,108.55 92.04,108.55 93.91,106.67 98.79,106.67 U8.V7
N40437812: length 10
  BOTTOM w0.102: TP9032.1 92.53,110.81 95.04,108.29 98.73,108.29 U8.W7
N40437815: length 8.9
  BOTTOM w0.102: U8.W6 98,107.48 94.09,107.48 92.16,109.41 TP9031.1
N40437818: length 9.8
  BOTTOM w0.102: U8.Y6 97.98,109.08 97.98,109.71 97.75,109.94 94.19,109.94 91.93,112.2 TP9030.1
N40911013: length 4.8
  BOTTOM w0.127: R405.2 132.4,96.88 132.4,94.86 133.03,94.22 133.03,93.59 133.41,93.21 VRAM1.J13
N40911015: length 5.5
  BOTTOM w0.102: VRAM2.J13 133.01,106.2 133.01,105.17 133.18,105 133.18,103.64 132.9,103.36 v1(132.9,102.35) R406.2
N41141585: length 2.8
  TOP w0.102: TP9041.1 181.42,21.27 182.33,22.18 U37.16
N48650493: length 4.8
  TOP w0.102: R384.1 102.75,122.77 101.59,122.77 v1(101.33,123.02) 101.23,123.02 100.37,123.88 Q15.2 99.82,123.43 R382.1
N60242660: length 2.1
  TOP w0.508: C2103.2 64.45,81.19 v1(63.8,81.84) 63.32,81.36 R2142.1
N360811430: length 4.3
  TOP w0.102: TP9040.1 189.78,10.76 189.78,12.74 190.1,13.07 190.56,13.07 190.85,13.35 U37.48
N360811590: length 2
  TOP w0.102: TP9039.1 181.74,16.88 182.43,16.18 U37.31

## Copper pours and planes (outline as drawn)
1V8_AON_S on TOP (solid shape): 25.99,99.1 25.99,97.75 25.46,97.22 25.46,94.6 25.08,94.22 23.69,94.22 23.65,94.23 23.64,94.27 23.64,94.94 23.44,94.94 23.44,94.27 23.43,94.23 23.39,94.22 23.29,94.22 23.25,94.23 23.24,94.27 23.24,94.94 23.22,94.96 23.21,94.97 23.21,95 23.22,95.03 23.48,95.29 23.48,95.48 24,96 24,97.71 24.45,98.16 24.45,99.17 24.57,99.3 25.79,99.3
+1.2VSUS on TOP (solid shape): 45.99,36 45.99,34.94 46.19,34.73 46.72,34.73 46.75,34.71 46.75,33.87 46.65,33.77 45.17,33.77 45.1,33.84 45.1,36.03 45.25,36.18 45.81,36.18
+1.2VSUS on TOP (solid shape): 67.6,118.27 67.6,117.61 67.78,117.44 67.87,117.44 67.89,117.43 67.94,117.4 68,117.39 68.28,117.39 68.32,117.39 68.4,117.42 68.59,117.42 68.6,117.44 69.12,117.44 70.24,117.44 70.42,117.26 70.42,116.78 70.32,116.67 67.6,116.67 66.9,117.37 66.9,118.41 66.51,118.81 65.72,118.81 65.69,118.82 65.67,118.86 65.67,118.95 65.68,118.98 65.72,119 66.46,119 66.46,119.01 66.86,119.01
+1.2VSUS on TOP (solid shape): 43.67,61.77 43.67,59.96 44.94,58.69 44.94,57.86 44.93,57.83 44.91,57.83 44.76,57.69 44.7,57.48 44.7,57.46 44.69,57.45 44.6,57.36 44.56,57.35 44.51,57.32 44.06,57.32 43.7,57.68 43.7,58.2 43.73,58.28 43.74,58.36 43.73,58.45 43.7,58.53 43.7,58.77 42.61,59.86 40.75,59.86 39.61,58.72 38.98,58.72 38.85,58.85 38.85,59.73 38.89,59.76 38.89,61.49 39.43,62.04 39.43,62.34 39.54,62.45 42.99,62.45
+1.2VSUS on TOP (solid shape): 35.01,62.22 35.01,60.6 34.43,60.01 34.43,58.85 34.68,58.59 35.57,58.59 35.72,58.44 35.72,58.24 35.33,57.84 35.32,57.84 35.24,57.8 35.18,57.74 35.16,57.73 35.14,57.73 35.01,57.73 34.68,58.06 34.52,58.06 34.5,58.06 34.48,58.08 34.31,58.17 34.12,58.13 34.11,58.12 34.01,58.12 33.84,58.29 33.84,58.31 33.73,58.55 33.5,58.65 33.48,58.66 33.07,59.06 33.07,62.26 33.2,62.39 34.84,62.39
+1.2VSUS on TOP (solid shape): 35.24,96.91 35.24,95.86 35.19,95.81 35.19,95.68 35.15,95.61 35.07,95.58 35.03,95.59 35,95.59 34.64,95.23 35,94.88 35.03,94.88 35.07,94.89 35.15,94.86 35.19,94.79 35.19,93.75 35.17,93.74 35.17,92.92 35.28,92.81 35.28,92.43 35.19,92.34 35.09,92.35 34.71,92.73 34.62,92.73 34.05,93.3 34.01,93.35 33.96,93.39 33.74,93.61 33.74,94.16 34.02,94.44 34.02,95.21 34.4,95.59 34.4,95.83 34.67,96.1 34.67,96.93 34.78,97.04 35.11,97.04
+1.2VSUS on TOP (solid shape): 35.05,45.55 35.6,45.55 35.83,45.32 35.83,45 35.82,44.97 35.79,44.95 35.66,44.87 35.59,44.73 35.59,44.72 35.52,44.64 35.49,44.64 35.32,44.6 35.16,44.47 35.13,44.47 35.07,44.47 34.63,44.47 34.53,44.57 34.47,44.88 34.16,44.94 34.15,44.93 33.71,44.93 33.33,45.01 33.1,44.69 29.92,44.69 29.82,44.79 29.82,45.17 30.14,45.49 30.15,45.49 30.74,46.08 34.53,46.08
+1.2VSUS on TOP (solid shape): 40.39,73.69 40.39,73.67 40.42,73.56 40.51,73.46 40.51,73.44 40.51,73.15 40.51,73.13 40.42,73.02 40.39,72.9 40.42,72.78 40.51,72.66 40.51,72.64 40.51,72.36 41.68,71.19 42.04,70.83 42.48,70.39 42.48,69.3 42.02,68.84 42.02,68.49 41.95,68.41 38.19,68.41 38.03,68.57 38.03,73.01 38.14,73.11 38.37,73.11 38.39,73.1 38.41,73.09 38.47,73.04 38.55,73 38.56,73 38.95,72.6 39.16,72.6 39.2,72.65 39.21,72.65 39.35,72.88 39.24,73.12 39.23,73.13 39.22,73.16 39.22,73.41 39.43,73.62 39.43,73.85 39.44,73.85 39.5,73.91 40.17,73.91
+1.2VSUS on TOP (solid shape): 40.35,52.36 40.35,50.13 40.3,50.07 40.3,49.49 39.33,48.53 39.33,47.84 39.15,47.66 37.58,47.66 37.48,47.76 37.48,48.93 38.01,49.47 38.01,51.57 38.21,51.78 38.74,51.78 38.82,51.73 38.82,51.63 38.97,51.23 39.34,51.43 39.35,51.44 39.45,51.55 39.48,51.55 39.83,51.92 39.41,52.2 39.37,52.21 39.35,52.28 39.58,52.51 40.19,52.51
+1.2VSUS on TOP (solid shape): 54.85,46.26 54.85,45.58 54.7,45.43 54.7,38.67 55.13,38.24 55.13,37.43 55.66,36.89 55.66,35.65 55.46,35.44 55.46,35.06 55.31,34.91 55,34.91 53.81,36.1 53.81,38.7 53.15,39.36 53.15,39.79 53.3,39.94 53.3,40.7 53.29,40.71 53.29,41.02 53.15,41.16 49.74,41.16 47.74,43.17 47.26,43.17 47.23,43.19 47.04,43.19 46.95,43.24 46.95,43.34 46.95,43.64 46.7,43.82 46.69,43.82 46.53,43.98 46.53,43.99 46.27,44.16 46.01,43.99 45.94,43.93 45.85,43.96 45.6,44.21 45.6,44.36 46.11,44.87 48.65,44.87 51.24,42.28 51.28,42.23 51.34,42.18 51.45,42.07 53.73,42.07 54.02,42.37 54.02,46.23 54.14,46.34 54.77,46.34
+1.2VSUS on TOP (solid shape): 40.38,39.17 40.39,39.15 40.39,39.13 40.39,39.08 40.4,38.99 40.45,38.91 40.45,38.45 40.4,38.37 40.39,38.28 40.47,38.08 40.67,38 40.78,38.02 40.9,38.11 40.92,38.11 40.96,38.11 41.44,38.59 41.51,38.59 42.15,37.96 42.15,35.05 42.28,34.92 42.28,33.9 42.05,33.67 39.33,33.67 38.84,34.16 38.83,34.18 38.8,34.26 38.72,34.32 38.7,34.34 38.7,34.37 38.7,38.21 38.71,38.23 38.75,38.25 38.79,38.23 38.8,38.21 38.88,38.08 39.01,38.01 39.02,38 39.23,37.79 39.24,37.77 39.23,37.72 39.23,37.68 39.56,37.35 39.89,37.68 39.84,37.86 39.7,37.98 39.69,37.98 39.47,38.2 39.45,38.31 39.53,38.38 39.72,38.49 39.8,38.7 39.76,38.86 39.64,38.98 39.6,39.06 39.63,39.14 39.84,39.36 40.19,39.36
+1.2VSUS on TOP (solid shape): 40.31,87.18 40.39,87.14 40.41,87.05 40.45,86.78 40.7,86.68 40.74,86.66 40.75,86.62 40.75,86.59 40.57,86.42 40.56,86.42 40.47,85.96 40.93,86.05 40.93,86.06 41.11,86.24 41.13,86.24 41.32,86.34 41.41,86.54 41.41,86.56 41.42,86.57 41.46,86.59 41.49,86.57 41.54,86.53 41.54,86.51 41.64,86.31 41.85,86.23 41.86,86.23 41.97,86.12 41.97,86.11 42,86.02 42.05,85.94 42.15,85.84 42.15,85.41 40.73,83.98 40.73,82.59 40.55,82.41 39.13,82.41 39,82.54 39,83.98 37.98,85 37.98,86.37 38.14,86.52 38.52,86.52 38.79,86.25 38.8,86.23 38.8,86.21 38.97,85.89 39.31,86.02 39.33,86.03 39.36,86.04 39.38,86.04 39.59,86.25 39.6,86.25 39.8,86.53 39.64,86.84 39.62,86.86 39.61,86.89 39.61,87.03 39.67,87.1 39.7,87.12 39.76,87.18
+1.2VSUS on TOP (solid shape): outline of 156 points within 38.04,91.37 43.34,97.09
+1.2VSUS on TOP (solid shape): outline of 5367 points within 43.25,48.07 79.67,98.28
+1.2VSUS on BOTTOM (solid shape): outline of 185 points within 58.13,58.61 69.1,98.41
+1.2VSUS on BOTTOM (solid shape): outline of 276 points within 48.14,111.72 55.69,116.17
+1.2VSUS on BOTTOM (solid shape): outline of 9711 points within 31.86,31.79 48.96,94.15
+1.2VSUS on IN1 (solid shape): outline of 2428 points within 41.39,71.04 49.34,94.4
+1.2VSUS on SVCC (solid shape): 69.14,118.22 69.28,118.2 69.41,118.22 69.7,118.22 70.17,117.76 70.17,100.65 68.1,98.59 67.98,98.51 67.91,98.39 65.74,96.23 65.63,96.07 65.59,95.87 63.56,95.87 63.52,96.07 63.41,96.23 59.4,100.25 59.41,100.31 59.42,100.37 59.32,100.62 59.06,100.72 59,100.72 58.94,100.7 51.98,107.66 51.94,107.7 51.94,108.63 52.16,108.96 51.94,109.29 51.94,109.73 52.16,110.07 51.94,110.41 51.94,111.97 52.01,112.18 51.94,112.38 51.94,112.62 51.98,112.66 53.23,113.9 61.53,113.9 61.72,113.94 61.89,114.05 61.93,114.1 61.96,114.1 62.21,114.2 62.32,114.45 62.32,114.48 66.06,118.22
+1.5V on TOP (solid shape): 167.96,21.2 167.96,20.05 167.83,19.93 166.83,19.93 166.79,19.93 165.82,19.93 165.78,19.93 165.18,19.93 165.14,19.93 163.66,19.93 163.62,19.93 163,19.93 162.75,20.18 162.75,21.07 163,21.32 167.83,21.32
+1.05V_LAN on TOP (solid shape): 41.36,106.08 42.48,106.08 42.51,106.06 42.51,105.93 42.48,105.9 41.44,105.9 41.31,105.78 40.83,105.78 40.7,105.9 40.7,106.26 40.78,106.34 41.11,106.34
+1.05V_LAN on TOP (solid shape): 42.51,104.02 42.51,103.69 41.74,102.93 41.74,102.4 41.54,102.2 40.04,102.2 39.89,102.35 39.89,102.68 40.04,102.84 40.29,102.84 41.54,104.09 42.44,104.09
+1.05V_LAN on TOP (solid shape): 50.48,106.82 50.48,106.39 50.4,106.31 50.25,106.31 49.49,105.55 49.24,105.55 49.05,105.74 47.52,105.74 47.41,105.85 46.8,105.85 46.75,105.9 45.78,105.9 45.76,105.93 45.76,106.06 45.78,106.08 46.82,106.08 46.9,106.16 47.92,106.16 48.63,106.87 50.43,106.87
+1.05V_LAN on TOP (solid shape): 43.09,111.04 43.14,111.03 43.58,111.03 43.6,111.03 43.61,111.02 44,110.63 44,110.56 44,109.79 43.83,109.61 43.65,109.61 43.47,109.43 43.47,108.98 43.72,108.72 43.72,108.14 43.62,108.04 43.62,107.05 43.6,107.02 43.47,107.02 43.45,107.05 43.45,108.01 43.39,108.06 43.39,108.39 43.01,108.77 42.91,108.77 42.61,109.07 42.61,109.56 42.3,109.87 41.39,109.87 41.29,109.96 41.29,110.07 41.31,110.14 41.31,110.2 41.31,110.26 41.29,110.32 41.29,110.88 41.46,111.05 43.04,111.05
+1.05V_LAN on BOTTOM (solid shape): outline of 135 points within 40.36,102.78 44.08,110.88
+1.05V_LAN on IN3 (solid shape): 48.16,111.53 48.98,111.53 49.99,110.53 49.99,109.14 49.72,108.88 49.72,105.6 49.57,105.45 48.96,105.45 48.75,105.65 48.75,108.93 49.36,109.54 49.36,109.61 49.41,109.66 49.41,110.56 48.91,111.06 47.19,111.06 47.11,110.99 47.09,110.98 44.33,110.98 44.3,110.95 44.29,110.95 44.12,110.85 44.02,110.68 44,110.65 44,110.56 44,109.84 43.83,109.66 42.91,109.66 42.71,109.87 42.71,110.83 42.96,111.09 42.99,111.09 43.07,111.07 43.14,111.06 43.34,111.12 43.47,111.28 43.48,111.29 43.52,111.33 43.58,111.33 43.93,111.67 46.66,111.67 46.75,111.63 46.94,111.63 47.03,111.66 47.04,111.67 47.1,111.67 47.12,111.68 48.01,111.68
+1.05V_LAN_REGOUT on TOP (solid shape): 47.56,108.62 47.56,108.34 47.76,108.14 48.04,108.14 48.17,108.01 48.17,107.3 47.59,106.72 45.76,106.72 45.73,106.74 45.73,106.87 45.81,106.95 45.81,107.96 46.09,108.24 46.57,108.24 47.15,108.83 47.36,108.83
+1.05V_LAN_REGOUT on TOP (solid shape): 41.57,116.06 41.57,115.48 41.9,115.15 42.96,115.15 43.27,114.84 43.27,112.88 43.27,112.85 43.27,111.95 43.11,111.8 43.1,111.79 42.94,111.74 42.82,111.62 42.8,111.6 42.77,111.59 41.36,111.59 41.17,111.78 41.17,112.9 39.69,114.39 39.69,114.64 39.89,114.84 40.83,114.84 41.01,115.02 41.01,115.08 41.03,115.19 41.03,115.28 41.02,115.31 41.01,115.36 41.01,115.95 41.24,116.19 41.44,116.19
+1.05V_LAN_REGOUT on IN1 (solid shape): outline of 271 points within 39.66,107.58 47.78,115.07
+1.8V on IN1 (solid shape): 203.72,28.84 203.72,28.64 203.12,28.04 203.1,28.03 203.07,28.02 202.83,27.92 202.74,27.68 202.74,27.66 202.73,27.64 202.61,27.53 202.57,27.53 202.47,27.43 200.96,27.43 200.86,27.53 200.66,27.53 200.57,27.6 200.59,27.71 200.67,27.82 200.7,27.95 200.37,28.28 200.04,27.95 200.06,27.82 200.14,27.71 200.17,27.6 200.07,27.53 200.04,27.53 198.72,28.86 198.76,28.91 198.82,28.93 199.16,28.93 199.46,28.63 199.87,28.63 199.89,28.64 199.91,28.64 199.93,28.64 199.99,28.62 200.05,28.62 200.18,28.64 200.29,28.72 200.33,28.74 200.73,28.74 200.93,28.54 201,28.54 201.3,28.23 201.32,28.22 201.32,28.2 201.31,28.16 201.25,28.06 201.23,27.95 201.33,27.72 201.56,27.62 201.71,27.66 201.83,27.76 201.9,27.81 201.98,27.79 202.07,27.74 202.17,27.73 202.4,27.83 202.5,28.06 202.49,28.12 202.48,28.19 202.47,28.2 202.48,28.23 202.51,28.26 202.63,28.26 203.34,28.97 203.59,28.97
+1.8V_DEEP_SUS on TOP (solid shape): 148.88,23.46 148.88,22.39 149.16,22.11 150.02,22.11 150.53,21.6 150.53,19.95 150.52,19.91 150.25,19.77 150.15,19.52 150.18,19.37 150.27,19.23 150.28,19.21 150.28,18.38 151.14,17.51 155.03,17.51 155.38,17.87 155.38,19.28 155.49,19.54 155.38,19.81 155.38,20.1 155.15,20.33 153.27,20.33 152.84,20.77 152.84,20.78 152.8,20.85 152.73,20.89 152.71,20.89 152.23,21.37 152.23,21.7 152.33,21.8 152.67,21.8 152.9,21.56 152.91,21.55 152.92,21.53 153.03,21.26 153.3,21.14 153.38,21.15 153.4,21.14 153.73,20.81 156.02,20.81 156.09,20.74 156.09,20.38 155.94,20.23 155.94,19.66 155.94,19.65 155.92,19.54 155.94,19.44 155.94,19.43 155.94,17.61 155.41,17.08 153.38,17.08 153.26,17.07 153.15,17.03 150.94,17.03 149.59,18.38 149.59,19.41 149.59,19.41 149.62,19.52 149.61,19.63 149.61,19.65 149.62,19.68 149.99,20.04 150,20.04 150.04,20.07 150.07,20.12 150.07,20.13 150.13,20.18 150.13,21.45 149.97,21.6 148.96,21.6 148.82,21.74 148.82,21.74 148.27,22.29 148.27,23.46 148.37,23.56 148.78,23.56
+1.8V_S5 on TOP (solid shape): 20.15,90.59 20.15,89.71 19.49,89.05 18.35,89.05 18.14,89.26 18.14,90.33 18.51,90.7 20.05,90.7
+1.8V_S5 on TOP (solid shape): outline of 113 points within 27.53,30.21 32.95,33.87
+1.8V_S5 on IN1 (solid shape): outline of 630 points within 18.17,31.15 33.59,90.19
+1.8V_S5 on IN2 (solid shape): 102.28,29.57 102.28,28.89 102.26,28.85 102.23,28.84 101.97,28.84 101.56,29.25 101.56,29.25 101.42,29.43 101.2,29.49 101.15,29.49 101.04,29.45 100.94,29.38 100.69,29.14 99.62,29.14 99.49,29.11 99.37,29.04 99.19,29.04 99.03,29.2 99.03,29.62 99.17,29.75 99.63,29.75 99.66,29.74 99.67,29.74 99.91,29.64 100.15,29.74 100.17,29.75 100.19,29.75 100.49,30.06 101.79,30.06
+1.8V_S5 on IN2 (solid shape): 32.78,33.27 32.78,32.87 32.63,32.72 32.63,32.22 32.78,32.08 32.78,31.51 32.68,31.41 31.76,31.41 31.13,32.04 31.13,32.16 31.13,32.37 30.85,32.65 30.64,32.65 30.6,32.65 29.45,32.65 28.51,31.71 28.5,31.71 28.39,31.63 28.31,31.51 28.3,31.5 28.26,31.46 28.26,31.41 28.04,31.19 28.03,31.18 28,31.18 27.81,31.12 27.68,30.98 27.68,30.96 27.65,30.95 24.09,30.95 22.64,29.5 21.14,29.5 20.3,28.66 20.22,28.66 20.05,28.83 20.05,29.02 20.99,29.96 22.29,29.96 23.84,31.51 26.38,31.51 26.81,31.94 27.95,31.94 28.09,32.08 28.21,32.19 28.21,32.55 29.48,33.82 32.23,33.82
+1.8V_SW on BOTTOM (solid shape): 21.63,27.21 21.63,26.4 21.63,26.36 21.63,25.18 20.15,23.71 19.57,23.71 19.41,23.87 19.41,24.23 19.81,24.64 19.82,24.64 19.91,24.7 19.96,24.78 19.96,24.79 20.41,25.23 20.79,25.23 20.94,25.39 20.94,25.97 20.56,26.35 20.56,27.07 20.6,27.18 20.61,27.29 20.61,27.31 20.63,27.33 20.71,27.42 21.42,27.42
+1.8V_SW on BOTTOM (solid shape): 15.63,23.61 15.63,22.5 14.48,21.34 14.39,21.34 13.88,20.83 13.65,20.69 13.53,20.45 13.52,20.44 13.49,20.41 12.91,20.41 12.81,20.51 12.81,21.15 12.86,21.28 12.86,21.42 12.86,21.45 12.87,21.47 13.04,21.63 13.45,21.63 13.63,21.8 13.63,22.67 13.42,22.87 12.91,22.87 12.63,23.15 12.63,23.58 12.74,23.68 15.56,23.68
+1.35V_GFX on TOP (solid shape): 128.48,93.64 128.48,93.18 128.1,92.8 127.19,92.8 127.09,92.9 127.09,93.71 127.16,93.79 128.33,93.79
+1.35V_GFX on TOP (solid shape): 131.74,86.52 131.74,85.97 131.63,85.86 130.52,85.86 130.39,85.99 130.39,86.5 130.52,86.63 131.63,86.63
+1.35V_GFX on TOP (solid shape): 127.49,120 128.93,120 128.97,119.99 128.98,119.95 128.98,118.56 128.97,118.52 128.93,118.51 125.15,118.51 124.54,117.89 124.39,117.89 124.22,118.07 124.22,118.93 124.38,119.1 125.02,119.1 125.07,119.1 125.18,119.21 125.18,120.28 125.41,120.51 126.99,120.51
+1.35V_GFX on TOP (solid shape): outline of 272 points within 110.42,103.36 113.22,108.16
+1.35V_GFX on TOP (solid shape): outline of 1198 points within 108.39,96.32 132.57,106.41
+1.35V_GFX on TOP (solid shape): outline of 2565 points within 129.35,78.42 142.94,117.87
+1.35V_GFX on BOTTOM (solid shape): outline of 202 points within 103.39,96.91 111.95,108.12
+1.35V_GFX on BOTTOM (solid shape): outline of 7341 points within 118.73,79.04 142.94,120.48
+1.35V_GFX on IN1 (solid shape): outline of 1977 points within 124.52,80.38 142.97,88.12
+1.35V_GFX on IN2 (solid shape): outline of 15511 points within 103.06,80.2 142.81,120.38
+1.35V_GFX on IN3 (solid shape): outline of 324 points within 127.06,104.94 131.76,109.36
+1.35V_GFX on IN3 (solid shape): outline of 3907 points within 124.18,80.15 142.94,120.62
+1V_S5 on TOP (solid shape): outline of 1662 points within 81.88,36.27 109.82,48.69
+1V_S5 on BOTTOM (solid shape): 88.43,48.24 88.43,48.03 88.28,47.88 88.28,47.63 88.76,47.14 88.76,46.31 88.71,46.26 88.49,46.26 88.47,46.26 88.45,46.28 88.43,46.3 88.43,46.52 88.49,46.62 88.51,46.74 88.41,46.98 88.16,47.08 88,47.04 87.87,46.92 87.84,46.89 87.62,46.89 87.56,46.94 87.56,47.78 87.62,47.85 87.65,47.93 87.66,47.95 88.07,48.36 88.3,48.36
+1V_S5 on IN2 (solid shape): outline of 4394 points within 82.48,35.33 106.16,49
+1V_S5 on SVCC (solid shape): 83.06,48.63 83.25,48.44 83.5,48.37 87.3,48.37 87.62,48.21 87.93,48.37 90.15,48.37 94,44.52 93.98,44.48 93.93,44.39 94.02,44.04 94.26,43.94 94.36,43.96 94.46,44.01 94.49,44.03 94.7,43.82 94.86,43.71 95.06,43.67 97.39,43.67 97.93,43.13 97.96,43.09 98,43.06 100.54,40.52 100.71,40.41 100.9,40.37 104.67,40.37 104.68,40.34 105.01,40.09 105.35,40.34 105.36,40.37 109.33,40.37 109.79,39.91 109.79,36.77 109.33,36.31 84.09,36.31 82.87,37.53 82.87,42.37 82.9,42.77 82.54,42.96 82.49,42.96 82.48,43.09 82.44,43.13 82.23,43.35 82.23,44.38 82.28,44.43 82.3,44.43 82.65,44.64 82.59,45.05 82.55,45.08 82.87,45.4 82.87,45.45 82.87,46.49 82.92,46.74 82.87,46.99 82.87,47.03 82.82,47.08 82.74,47.17 82.64,47.26 81.97,47.93 81.98,47.99 81.98,48.39 82.17,48.59 82.21,48.57 82.3,48.52 82.41,48.5 82.55,48.54 82.67,48.63
+1V_SUS on TOP (solid shape): 139.89,60.57 139.89,59.82 139.87,59.78 139.56,59.47 138.97,59.47 138.95,59.5 138.95,60.11 139.53,60.69 139.76,60.69
+1V_VCCST on BOTTOM (solid shape): outline of 156 points within 100.52,64.95 110.94,76.44
+1V_VCCST on IN3 (solid shape): 110.15,45.78 110.15,44.92 109.64,44.41 109.23,44.41 109.06,44.37 108.93,44.26 108.77,44.11 108.47,44.11 108.41,44.16 108.4,44.18 108.4,44.2 108.4,44.43 108.85,44.88 108.85,45.05 108.85,45.07 108.86,45.09 109.02,45.25 109.05,45.25 109.07,45.25 109.14,45.23 109.21,45.22 109.48,45.33 109.59,45.6 109.58,45.67 109.56,45.74 109.56,45.76 109.56,45.79 109.68,45.91 110.02,45.91
+2.5V_SUS on TOP (solid shape): 48.14,34.23 48.14,31.28 47.69,30.82 46.49,30.82 46.37,30.95 46.37,31.86 46.87,32.37 46.87,34.15 47.13,34.4 47.97,34.4
+2.5V_SUS on TOP (solid shape): 50.25,80.42 50.25,79.21 47.09,79.21 46.52,79.78 46.2,79.78 45.52,79.1 45.38,79.1 45.26,79.22 45.26,80.9 45.84,81.48 49.19,81.48
+2.5V_SUS on TOP (solid shape): 50.96,46.54 50.96,44.92 50.68,44.63 50.15,44.63 49.66,45.12 46.14,45.12 45.53,44.51 45.38,44.51 45.22,44.66 45.22,46.32 45.63,46.73 50.78,46.73
+2.5V_SUS on TOP (solid shape): 72.34,119.3 72.34,118.77 71.55,117.98 70.2,117.98 70.18,117.99 70.16,118 69.86,118.3 69.86,119.04 70,119.18 70.19,119.18 70.33,119.04 70.52,119.04 71.49,120 71.64,120
+2.5V_SUS on TOP (solid shape): 35.53,72.77 35.53,72.19 34.08,70.73 32.43,70.73 32.05,70.34 32.05,70.32 30.51,68.79 29.95,68.79 29.88,68.85 29.88,70.97 30.82,71.91 32.47,71.91 32.47,71.9 33.3,71.9 33.49,71.72 34.12,71.72 34.72,72.31 34.72,72.87 34.87,73.02 35.28,73.02
+2.5V_SUS on TOP (solid shape): 30.38,53.07 30.5,53.07 31.11,52.46 31.11,51.62 32.03,50.69 32.28,50.69 32.29,50.69 33.41,50.69 33.57,50.53 34.23,50.53 34.6,50.91 34.6,51.45 34.79,51.65 35.24,51.65 35.35,51.54 35.35,51.12 34.53,50.3 30.79,50.3 29.86,51.23 29.86,52.94 30.01,53.08 30.37,53.08
+2.5V_SUS on TOP (solid shape): 45.32,96.91 45.32,93.89 45.73,93.48 45.73,92.49 45.72,92.48 45.64,92.43 45.58,92.36 45.56,92.34 45.54,92.34 45.4,92.34 45.38,92.34 45.36,92.36 45.29,92.43 45.2,92.49 45.2,92.49 45.2,92.72 43.65,94.27 43.65,96.85 43.78,96.98 45.26,96.98
+2.5V_SUS on TOP (solid shape): 47.41,62.06 47.41,60.54 45.85,58.99 45.85,57.97 45.67,57.78 45.61,57.74 45.57,57.68 45.55,57.67 45.53,57.66 45.41,57.66 45.38,57.67 45.36,57.68 45.3,57.76 45.21,57.82 45.19,57.84 45.18,57.87 45.18,59.16 44.03,60.31 44.03,62.26 44.17,62.39 47.08,62.39
+2.5V_SUS on TOP (solid shape): 35.48,86.14 35.48,85.54 35.14,85.2 35.13,85.2 34.98,85.11 34.89,84.96 34.89,84.95 33.41,83.47 29.93,83.47 29.83,83.57 29.83,84.9 30.01,85.07 30.25,85.07 30.68,84.64 32.04,84.64 32.33,84.94 33.07,84.94 33.57,85.44 33.68,85.44 33.69,85.43 33.96,85.43 34.15,85.61 34.16,85.62 34.39,85.85 34.88,86.34 35.28,86.34
+2.5V_SUS on TOP (solid shape): 35.58,38.36 35.59,38.34 35.6,38.21 35.65,38.11 35.65,35.93 35.37,35.65 35.37,34.1 35.19,33.92 35.19,33.1 35.14,33.01 35.04,33.01 34.96,33.04 34.88,33.06 34.81,33.09 34.78,33.15 34.67,33.41 34.4,33.51 34.13,33.4 34.02,33.13 34.13,32.87 34.38,32.75 34.45,32.72 34.48,32.66 34.6,32.4 34.86,32.29 34.95,32.31 35.04,32.34 35.14,32.34 35.19,32.25 35.19,31.89 34.94,31.63 34.25,31.63 34.12,31.76 34.12,32.24 33.51,32.85 33.51,33.64 33.56,33.69 33.56,36.38 33.79,36.61 33.87,36.63 33.95,36.58 33.95,36.57 34.08,36.43 34.25,36.38 34.48,36.48 34.58,36.71 34.56,36.83 34.5,36.93 34.49,36.94 34.48,36.97 34.48,37.3 34.63,37.45 34.63,38.19 34.85,38.4 34.9,38.45 34.95,38.5 34.96,38.52 35.42,38.52
+2.5V_SUS on BOTTOM (solid shape): 35.23,33.93 35.23,33.53 35.06,33.36 34.73,33.36 34.71,33.37 34.56,33.48 34.4,33.51 34.34,33.51 34.26,33.49 34,33.49 31.86,35.62 31.86,35.98 32.12,36.23 32.93,36.23
+2.5V_SUS on BOTTOM (solid shape): 57.31,30.39 57.52,30.39 57.56,30.37 57.57,30.34 57.57,30.33 58.79,30.33 58.82,30.32 58.84,30.28 58.84,30.13 58.82,30.09 58.79,30.08 57.57,30.08 57.57,29.83 58.79,29.83 58.82,29.82 58.84,29.78 58.84,29.23 58.48,28.87 56.45,28.87 55.79,29.53 55.79,30.26 56.07,30.55 56.09,30.55 56.27,30.65 56.37,30.83 56.37,30.84 56.48,30.95 56.75,30.95
+2.5V_SUS on BOTTOM (solid shape): 25.94,103.64 25.94,99.89 26.44,99.39 28.83,99.39 30.03,98.19 30.03,98.18 30.12,98.04 30.26,97.95 30.27,97.95 30.97,97.24 30.97,96.44 30.97,96.42 30.95,96.4 30.8,96.27 30.68,96.1 30.66,96.08 30.63,96.07 29.73,96.07 27.74,98.07 26.01,98.07 25.31,98.77 25.31,98.84 24.75,99.4 24.75,100.65 24.98,100.88 24.98,102.45 24.93,102.5 24.92,102.52 24.79,102.74 24.55,102.83 24.45,102.82 24.37,102.79 24.27,102.79 24.22,102.88 24.22,103.85 24.75,104.38 25.21,104.38
+2.5V_SUS on BOTTOM (solid shape): outline of 613 points within 30.24,41.57 33.64,84.7
+2.5V_SUS on IN1 (solid shape): 47.76,60.67 47.76,59 47.64,58.87 46.34,58.87 45.95,59.26 45.95,60.95 46.05,61.05 47.38,61.05
+2.5V_SUS on IN1 (solid shape): 27.7,105.78 27.7,105.14 27.29,104.74 27.14,104.74 27.07,104.76 27.01,104.76 26.95,104.76 26.88,104.74 26.55,104.74 26.45,104.79 26.33,104.81 26.21,104.79 26.11,104.74 26.1,104.74 26.07,104.74 25.94,104.61 25.94,104.36 25.93,104.32 25.89,104.3 25.85,104.3 25.08,103.53 23.95,103.53 23.93,103.56 23.93,104.37 25.46,105.9 27.57,105.9
+2.5V_SUS on IN1 (solid shape): outline of 160 points within 66.41,116.6 70.57,119.75
+2.5V_SUS on IN1 (solid shape): outline of 915 points within 34.28,28.1 57.62,54.37
+2.5V_SUS on IN3 (solid shape): 30.94,97.2 30.99,97.21 31.02,97.17 31.02,96.02 30.62,95.62 30.62,94.64 30.61,94.62 30.6,94.6 30.46,94.33 30.6,94.06 30.61,94.05 30.62,94.02 30.62,89.87 30.6,89.83 30.6,89.83 30.5,89.59 30.6,89.36 30.6,89.35 30.62,89.31 30.62,87.04 30.61,87.03 30.58,86.89 30.61,86.75 30.62,86.73 30.62,85.93 30.62,85.92 30.62,85.89 30.61,85.88 30.57,85.79 30.56,85.69 30.58,85.56 30.65,85.45 30.68,85.38 30.65,85.31 30.56,85.18 30.54,85.04 30.65,84.77 30.92,84.66 30.97,84.66 31.02,84.67 31.06,84.63 31.08,84.58 31.08,83.55 30.85,83.32 29.86,83.32 28.89,84.29 28.89,88.13 29.18,88.41 29.18,96.44 29.91,97.17 29.99,97.17 30.03,97.17 30.9,97.17
+3V on TOP (solid shape): 180.15,29.58 180.15,28.82 179.64,28.31 179.64,28.08 179.64,28.05 179.64,27.04 179.39,26.78 178.75,26.78 178.62,26.91 178.62,28.94 178.75,29.07 179,29.07 179.64,29.7 180.02,29.7
+3V on TOP (solid shape): 51.4,105.96 51.4,105.74 51.4,105.73 51.4,105.43 51.54,105.29 51.54,103.74 51.44,103.64 50.02,103.64 49.95,103.72 49.95,104.25 50.1,104.41 50.58,104.41 50.94,104.76 50.94,105.9 51.07,106.03 51.32,106.03
+3V on TOP (solid shape): 50.1,51.6 50.1,51.01 50.61,50.51 51.47,50.51 51.57,50.41 51.57,50.02 51.45,49.9 51.12,49.9 50.99,49.77 50.99,48.75 50.94,48.7 48.75,48.7 48.47,48.98 48.47,51.27 48.63,51.42 49.41,51.42 49.67,51.68 50.02,51.68
+3V on TOP (solid shape): 59.22,104.2 59.22,103.73 59.32,103.63 59.67,103.63 59.73,103.57 59.73,103.21 59.32,102.81 59.32,102.37 59.24,102.3 58.81,102.3 58.8,102.31 58.11,102.31 57.26,103.16 57.26,104.22 57.38,104.33 59.09,104.33
+3V on TOP (solid shape): 75.07,106.59 75.07,106.49 76.62,104.94 76.62,103.86 76.39,103.62 76.07,103.62 75.93,103.76 75.93,105.05 75.33,105.65 74.46,105.65 74.38,105.73 74.38,105.9 74.48,106.01 74.59,106.01 74.79,106.21 74.79,106.56 74.86,106.64 75.02,106.64
+3V on TOP (solid shape): 58.08,112.53 58.08,111.9 58.3,111.67 58.58,111.67 58.66,111.59 58.66,111.01 58.84,110.83 58.84,110.63 58.76,110.55 58.05,110.55 57.95,110.65 57.95,110.83 57.52,111.26 57.52,111.29 57.38,111.43 57.38,112.19 57.26,112.31 57.26,112.91 57.34,112.99 57.62,112.99
+3V on TOP (solid shape): 79.23,23.63 79.82,23.63 79.83,23.62 80.75,23.62 80.88,23.48 81.6,23.48 81.75,23.33 81.75,23.07 81.32,22.64 79.87,22.64 79.08,21.86 76.54,21.86 76.49,21.91 76.49,22.31 76.54,22.36 78.47,22.36 78.48,22.38 78.84,22.38 78.98,22.52 78.98,23.15 78.6,23.53 78.6,23.94 78.61,23.97 78.65,23.99 78.88,23.99
+3V on TOP (solid shape): 20.13,87.23 20.13,85.86 19.98,85.71 19.89,85.57 19.86,85.41 19.86,84.48 19.87,84.47 19.87,83.98 19.86,83.95 19.82,83.93 17.53,83.93 17.41,84.05 17.41,84.27 17.38,84.3 17.38,84.62 17.59,84.82 18.73,84.82 19.19,85.28 19.19,86.23 19.34,86.38 19.34,87.31 19.49,87.46 19.9,87.46
+3V on TOP (solid shape): 25.3,86.98 25.33,86.97 25.35,86.93 25.35,82.47 25.11,82.23 24.65,82.23 23.72,81.3 23.72,81.28 23.71,81.27 23.71,80.83 23.53,80.65 23.31,80.65 23.17,80.63 23.04,80.55 22.44,80.55 22.37,80.62 22.37,81.44 22.36,81.44 22.36,83.44 22.73,83.81 23.28,83.81 23.4,83.93 23.4,84.54 23.75,84.89 23.75,85.36 24.06,85.67 24.06,86.63 24.42,86.98
+3V on TOP (solid shape): 19.65,76.29 19.65,74.61 19.28,74.24 19.27,74.24 19.16,74.16 19.08,74.05 19.08,74.05 18.88,73.85 18.5,73.85 18.4,73.95 18.4,74.54 18.57,74.71 18.6,74.72 18.68,74.7 18.76,74.69 19.05,74.84 19.09,75.18 19.08,75.2 19.09,75.22 19.37,75.5 19.39,75.53 19.39,76.26 19.44,76.31 19.62,76.31
+3V on TOP (solid shape): 151.85,30.02 151.85,27.94 151.85,27.93 151.85,27.55 151.36,27.05 151.36,25.12 151.17,24.92 150,24.92 149.4,25.53 149.4,26.18 149.45,26.29 149.47,26.41 149.27,26.74 148.88,26.73 148.85,26.72 148.82,26.73 148.55,27 148.55,29.18 148.55,29.18 148.57,29.3 148.55,29.41 148.55,29.42 148.55,30.01 148.78,30.24 151.62,30.24
+3V on TOP (solid shape): 27.85,11.06 27.85,9.46 27.62,9.23 27.04,9.23 26.99,9.18 26.99,8.92 26.99,8.83 26.99,8.36 26.98,8.32 26.97,8.27 26.97,8.21 26.98,8.16 26.99,8.13 26.99,7.12 26.86,7 26.1,7 25.94,7.15 23.58,7.15 23.3,7.43 23.3,8.19 23.31,8.24 25.66,8.24 25.67,8.19 25.68,8.13 25.7,8.08 25.73,8.03 25.76,7.99 25.8,7.95 25.85,7.91 25.9,7.89 25.95,7.87 26,7.86 26.06,7.86 26.12,7.87 26.17,7.88 26.22,7.9 26.27,7.93 26.31,7.97 26.35,8.01 26.38,8.05 26.4,8.1 26.42,8.16 26.43,8.21 26.43,8.27 26.42,8.32 26.4,8.38 26.38,8.43 26.35,8.47 26.31,8.52 26.27,8.55 26.22,8.58 26.17,8.6 26.12,8.62 26.06,8.62 26,8.62 25.95,8.61 25.9,8.59 25.85,8.57 25.8,8.53 25.76,8.5 25.73,8.45 25.7,8.4 25.68,8.35 25.67,8.3 25.66,8.24 23.31,8.24 23.3,8.3 23.3,8.7 24.31,9.7 24.68,9.7 25.04,10.05 25.66,10.05 26.09,10.48 26.09,10.98 26.33,11.21 27.7,11.21
+3V on TOP (solid shape): 21.6,76.41 21.64,76.4 21.65,76.36 21.65,75.5 21.73,75.5 21.76,75.49 21.8,75.43 21.83,75.41 21.87,75.4 22.15,75.4 22.18,75.41 22.21,75.42 22.26,75.43 22.32,75.42 22.34,75.41 22.37,75.4 22.59,75.4 22.61,75.39 22.63,75.38 22.66,75.33 22.7,75.28 23.56,74.43 23.56,74.38 23.61,74.33 23.66,74.33 24.32,73.67 24.98,73.67 25.01,73.66 25.03,73.62 25.03,72.32 24.81,72.11 24.08,72.11 23.61,72.58 23.23,72.58 23.05,72.76 23.05,73.01 22.52,73.54 22.11,73.54 21.6,74.05 21.09,74.05 20.94,74.2 20.94,74.61 20.95,74.65 21.23,74.77 21.32,75.02 21.31,75.11 21.27,75.2 21.27,75.45 21.29,75.49 21.32,75.5 21.37,75.5 21.37,76.36 21.39,76.4 21.42,76.41
+3V on BOTTOM (solid shape): 63.52,125.14 63.52,124.48 63.41,124.37 63.13,124.37 62.57,124.93 62.57,125.41 62.7,125.54 63.13,125.54
+3V on BOTTOM (solid shape): 59.85,104.51 59.85,103.08 59.73,102.96 58.91,102.96 58.76,103.11 58.76,104.66 58.81,104.71 59.65,104.71
+3V on BOTTOM (solid shape): 209.56,27.95 209.56,27.8 209.92,27.44 209.92,26.12 209.76,25.97 209.33,25.97 209.13,26.17 209.13,26.94 209,27.06 208.67,27.06 208.6,27.14 208.6,28.03 208.67,28.1 209.41,28.1
+3V on BOTTOM (solid shape): 85.96,98.23 86.32,98.23 86.42,98.13 86.42,97.09 86.68,96.84 86.68,96.61 86.47,96.4 86.09,96.4 85.91,96.23 85.91,95.52 85.66,95.26 84.85,95.26 83.32,96.79 83.32,97.8 83.32,98.25 83.81,98.74 85.46,98.74
+3V on BOTTOM (solid shape): 60.72,109.23 60.72,108.7 60.67,108.65 60.67,107.86 60.51,107.71 60.16,107.71 59.96,107.91 59.96,108.04 59.97,108.09 59.96,108.13 59.96,108.18 59.96,108.9 58.23,110.63 58.23,110.88 58.46,111.11 58.84,111.11
+3V on BOTTOM (solid shape): 205.97,11.26 205.97,11 205.22,10.25 203.62,10.25 202.84,11.03 202.84,11.19 203.05,11.4 203.25,11.4 203.82,10.83 204.76,10.83 204.81,10.82 204.86,10.82 205.11,10.92 205.22,11.17 205.22,11.18 205.47,11.44 205.8,11.44
+3V on BOTTOM (solid shape): 195.72,28.48 195.72,28.23 195.72,27.66 195.61,27.55 195.31,27.55 195.08,27.32 195.08,27.14 194.19,27.14 194.02,27.32 194.02,28.23 194.15,28.36 194.2,28.36 194.27,28.34 194.35,28.33 194.42,28.34 194.5,28.36 194.86,28.36 194.93,28.34 195.01,28.33 195.08,28.34 195.16,28.36 195.27,28.44 195.34,28.56 195.64,28.56
+3V on BOTTOM (solid shape): 216.17,33.49 216.17,31.79 216.06,31.69 215.91,31.69 215.33,31.1 214.95,31.1 214.86,31.14 214.85,31.24 214.87,31.29 214.87,31.36 214.84,31.51 214.72,31.65 214.72,31.67 214.72,32.22 214.28,32.65 214.15,32.65 214.11,32.67 214.1,32.71 214.1,32.75 212.81,32.75 212.78,32.76 212.76,32.8 212.76,33 212.78,33.04 212.81,33.05 214.1,33.05 214.1,33.25 212.81,33.25 212.78,33.26 212.76,33.3 212.76,33.5 212.78,33.54 212.81,33.55 214.1,33.55 214.1,33.75 212.81,33.75 212.78,33.76 212.76,33.8 212.76,34 212.78,34.04 212.81,34.05 214.1,34.05 214.1,34.07 214.11,34.11 214.15,34.12 215.53,34.12
+3V on BOTTOM (solid shape): outline of 1005 points within 19.81,28.94 29.68,75.27
+3V on IN1 (solid shape): outline of 202 points within 50.96,104.17 60.78,108.34
+3V on IN1 (solid shape): outline of 2120 points within 23.35,7.78 37.1,31.94
+3V on IN2 (solid shape): outline of 3701 points within 18.97,73.29 86.42,107.6
+3V on SVCC (solid shape): outline of 499 points within 27.75,23.86 127.35,40.37
+3V on SVCC (solid shape): outline of 1490 points within 40.58,23.88 219.29,125.97
+3V3_TPM on TOP (solid shape): 125.11,26.4 125.14,26.39 125.16,26.35 125.16,25.67 125.11,25.61 124.15,25.61 123.94,25.41 123.38,25.41 123.33,25.46 123.33,26.28 123.45,26.4
+3V3_TPM on TOP (solid shape): 132.15,24.23 132.15,20.93 132.09,20.86 131.3,20.86 131.1,21.07 131.1,21.6 130.95,21.75 130.47,21.75 130.44,21.73 129.17,21.73 128.84,22.06 127.77,22.06 127.7,22.13 127.7,22.34 127.75,22.39 129.07,22.39 129.17,22.29 130.01,22.29 130.64,22.92 130.64,23.3 130.44,23.51 130.01,23.51 129.78,23.74 129.78,24.7 129.98,24.9 131.48,24.9
+3V3_TPM_VSB on TOP (solid shape): 129.68,18.48 132.55,18.48 132.92,18.11 132.92,16.31 132.85,16.24 132.19,16.24 132.01,16.42 132.01,17.05 131.66,17.41 129.6,17.41 129.58,17.44 129.23,17.44 129.2,17.45 129.18,17.49 129.18,17.54 129.15,17.63 129.06,17.67 128.67,17.67 128.63,17.66 128.61,17.67 127.75,18.53 127.75,18.81 127.8,18.86 129.3,18.86
+3V3AUX on IN1 (solid shape): outline of 402 points within 101.53,92.96 103.57,98.28
+3V_CCD_PWR1_C on BOTTOM (solid shape): 59.45,107.53 59.49,107.51 59.5,107.48 59.5,106.71 59.7,106.71 59.7,107.48 59.71,107.51 59.75,107.53 59.96,107.53 59.98,107.5 59.98,106.49 59.85,106.36 59.85,105.05 58.89,105.05 58.89,106.04 59.09,106.24 59.09,106.51 59.22,106.64 59.22,107.48 59.23,107.51 59.27,107.53
+3V_GFX_+1V8_GFX_MAIN on TOP (solid shape): 82,96.71 82,95.29 81.75,95.03 81.29,95.03 80.68,95.64 80.68,96.05 80.99,96.35 80.99,96.86 81.85,96.86
+3V_GFX_+1V8_GFX_MAIN on TOP (solid shape): 96.86,125.79 96.86,125.23 96.79,125.16 96.3,125.16 96.02,124.88 95.46,124.88 95.32,125.01 95.32,125.51 95.7,125.89 96.76,125.89
+3V_GFX_+1V8_GFX_MAIN on TOP (solid shape): 23.8,100.47 23.8,100.06 23.47,99.73 22.57,99.73 22.28,99.45 21.94,99.45 21.83,99.56 21.83,100.53 21.94,100.64 23.63,100.64
+3V_GFX_+1V8_GFX_MAIN on TOP (solid shape): 123.25,121 123.29,121 123.47,120.82 123.54,120.82 123.83,120.53 124.65,120.53 124.93,120.26 124.93,119.35 124.28,119.35 124.24,119.32 123.61,119.32 123.07,118.78 122.16,118.78 122.06,118.88 122.06,121.14 122.16,121.25 123,121.25
+3V_GFX_+1V8_GFX_MAIN on TOP (solid shape): 87.9,109.76 87.9,108.55 87.77,108.42 87.77,107.71 87.9,107.58 87.9,104.79 88.05,104.63 88.4,104.63 88.91,104.13 89.32,104.13 89.57,103.87 89.57,103.52 89.06,103.52 88.81,103.77 88.15,103.77 87.9,103.52 87.9,103.06 87.84,103.01 87.23,103.01 87.03,103.21 86.37,103.21 86.37,104.13 86.8,104.56 86.8,109.54 87.08,109.82 87.84,109.82
+3V_GFX_+1V8_GFX_MAIN on IN1 (solid shape): 81.95,96.38 81.95,95.08 81.85,94.98 81.14,94.98 80.63,95.49 79.88,96.24 79.88,96.54 80.49,97.15 81.18,97.15
+3V_GFX_+1V8_GFX_MAIN on IN1 (solid shape): 24.01,99.99 24.01,99.48 23.79,99.25 22.08,99.25 21.87,99.47 21.87,99.48 21.85,99.5 21.85,99.61 21.83,99.73 21.78,99.84 21.78,100.43 21.95,100.6 23.4,100.6
+3V_GFX_+1V8_GFX_MAIN on IN1 (solid shape): 58.96,101.97 60.18,101.97 60.44,101.71 63.82,101.71 64.54,101 64.79,101 64.98,100.8 64.98,99.76 63.62,99.76 63.11,100.27 62.32,100.27 61.74,100.85 61.05,100.85 60.97,100.77 57.47,100.77 57.44,100.75 55.45,100.75 55.32,100.87 55.32,101.77 57.72,101.77 57.72,101.72 57.73,101.67 57.74,101.62 57.77,101.57 57.8,101.52 57.83,101.48 57.87,101.45 57.92,101.42 57.97,101.41 58.02,101.39 58.07,101.39 58.13,101.39 58.18,101.41 58.23,101.42 58.28,101.45 58.32,101.48 58.35,101.52 58.38,101.57 58.41,101.62 58.42,101.67 58.43,101.72 58.43,101.77 58.42,101.83 58.41,101.88 58.38,101.92 58.35,101.97 58.32,102.01 58.28,102.04 58.23,102.07 58.18,102.09 58.13,102.1 58.07,102.1 58.02,102.1 57.97,102.09 57.92,102.07 57.87,102.04 57.83,102.01 57.8,101.97 57.77,101.92 57.74,101.88 57.73,101.83 57.72,101.77 55.32,101.77 55.32,101.84 55.4,101.92 56.95,101.92 57.05,102.02 57.14,102.02 57.67,102.55 58.38,102.55
