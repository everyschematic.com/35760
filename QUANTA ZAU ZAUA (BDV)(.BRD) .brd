# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0P85A_VID0: length 17.6
  TOP w0.102: TP2044.1 65.23,37.91 65.53,37.6 66.95,37.6 67.46,38.11 71.52,38.11 73.39,39.98 75.44,39.98 76.23,40.77 77.68,40.77 77.97,41.06 79.65,41.06 v4(80.14,41.55)
  BOTTOM w0.127: v4(80.14,41.55) 80.14,41.55 80.46,41.87 U2030.AN11
V3A_BOOT: length 3
  BOTTOM w0.508: PU6000.1 147.05,32.33 147.05,34.64 PR6000.2
V3A_BOOT_R: length 1.4
  BOTTOM w0.508: PR6000.1 147.37,35.53 PC6001.1
V3A_EN: length 3.9
  TOP w0.102: v1(145.34,31.84) 145.29,31.8 PC6007.2
  TOP w0.203: PC6007.2 PR6006.2 143.33,31.8 v1(142.98,32.15) 142.89,32.24 PR6002.1
  BOTTOM w0.102: PU6000.6 143.08,32.05 v1(142.98,32.15)
V3A_PWRGD: length 1.5
  BOTTOM w0.203: PR6005.1 143.4,33.06 143.7,33.36 143.95,33.36 144.15,33.16 PU6000.7
V3A_VBYP: length 5.5
  TOP w0.203: PR6009.2 144.95,34.73 v1(145.35,34.73)
  BOTTOM w0.203: PC6023.1 144.49,35.34 144.83,35.68 PR6017.1 145.45,35.24 145.35,35.13 v1(145.35,34.73) 145.88,34.19 145.88,33.51 145.95,33.45 PU6000.11
V3A_VOUT: length 21.4
  TOP w0.203: PR6011.2 145.96,34.05 145.83,33.92 145.83,33.57 PR6010.2 145.39,33.12 PC6017.2 144.76,33.46 v1(145.34,34.04)
  BOTTOM w0.127: PR6008.2 154.56,36.43 154.51,36.38 152.61,35.9 151.18,35.83 149.76,36.04 149.56,36.11 149.33,36.19 148.4,36.52 148.26,36.6 147.17,37.26 146.18,38.15 145.72,38.15 145.36,37.79 145.36,37.75 145.1,37.49 145.06,37.49 145.06,37.48 144.71,37.48 144.38,37.16 144.38,36.89 144.08,36.59 143.8,36.59 143.6,36.38 143.6,35.04 143.72,34.91 144.71,34.91 144.83,34.79 144.83,34.56 v1(145.34,34.04)
  BOTTOM w0.203: PU6000.10 145.5,33.89 v1(145.34,34.04)
V5P5A_BOOT: length 2.6
  TOP w0.508: PC6035.1 41.77,17.2 v1(41.77,17.36)
  BOTTOM w0.229: v1(41.77,17.36) 41.77,17.76 42.22,18.21 PU6003.1
V5P5A_BOOT_R: length 2.3
  TOP w0.102: v1(39.34,16.3) 39.42,16.37 PC6035.2
  TOP w0.508: PR6018.2 40.79,17.28 40.17,16.65 PC6035.2
V5P5A_EN: length 7.9
  BOTTOM w0.102: PU6003.6 45.75,18.21 45.81,18.14 45.81,17.79 46.36,17.24 47.99,17.24 48.52,16.71 48.69,16.71 PR6020.1
  BOTTOM w0.203: PR6021.2 48.78,14.37 PC6039.2 49.8,15.39 v1(49.8,15.95) 49.28,16.47 PR6020.1
V5P5A_PWRGD: length 3.7
  BOTTOM w0.229: PR6022.1 47.8,16.86 46.6,16.86 46.53,16.94 v1(46.05,16.94) 45.68,16.94 45.6,16.86 45.22,16.86 45.12,16.96 PU6003.7
V5P5A_VOUT: length 6.4
  BOTTOM w0.152: PR6029.2 45.54,15.51 45.04,15.01 45.04,13.99 44.81,13.75 PR6026.1
  BOTTOM w0.203: PC6055.2 45.45,15.62 PR6029.2 46.03,15.51 46.09,15.45 PR6030.2
  BOTTOM w0.229: PU6003.10 43.77,16.42 44.58,15.62 PC6055.2
VCC1_CORE:
  vias: v1(115.36,66.87)
VCC2_CORE: length 3.1
  BOTTOM w0.305: PR7080.2 135.09,49.68 134.69,50.07 134.69,50.23 PC7063.1 134.2,50.19 134.2,50.18 133.86,49.84 PU7001.8
VCC_GT:
  vias: v1(128.78,79.72)
VCC_SA: length 2.7
  BOTTOM w0.305: PR7116.2 142.45,42.5 PU7004.8
  BOTTOM w0.381: PC7104.1 143.19,41.76 PR7116.2
VCCGT_SENSE: length 10.6
  TOP w0.254: PR7051.1 95.21,79.99 94.93,79.71 PR7050.1 94.94,79.22 95.36,78.8 95.36,78.79 95.78,78.37 v1(95.87,78.37)
  BOTTOM w0.102: 92.39,77.13 92.21,76.95 92.21,75.94 U2030.J70
  BOTTOM w0.254: 92.39,77.13 92.72,77.46 94.5,77.46 94.75,77.71 94.75,79.09 R2456.2 95.17,78.56 95.36,78.37 v1(95.87,78.37)
VCCSA_SENSE: length 28.3
  TOP w0.254: v4(93.02,47.04) 93.02,47.19 93.31,47.47 96.29,47.47 97.74,48.92 98.44,48.92 98.84,48.52 102.19,48.52 102.83,49.16 103.69,49.16 103.81,49.05 105.28,49.05 105.65,48.68 106.29,48.68 106.92,48.05 106.92,47.54 107.78,46.67 109.41,46.67 109.84,46.24 v1(112.26,46.24) 112.64,46.24 114.24,44.64 115.63,44.64 115.79,44.48 PR7057.1 PR7058.1
  BOTTOM w0.254: U2030.H20 92.7,46.72 v4(93.02,47.04)
VCCST_PWRGD: length 9
  BOTTOM w0.102: U2030.B65 97.02,72.85 97.99,72.85 98.27,73.13 98.27,73.56 99.15,74.44 99.15,75.56 100.61,77.02 C2312.2 C2542.2 100.64,78.09 R2228.1
VCCST_PWRGD_EN: length 4.5
  TOP w0.102: U2014.2 108.98,31.48 108.88,31.38 108.88,30.67 109.21,30.34 109.61,30.34 109.76,30.19 R2252.2 109.97,29.65 R2256.1 R2257.1
VCCST_PWRGD_EN_L: length 14.6
  TOP w0.102: U2014.4 108.39,32.13 108.65,31.88 108.65,30.52 R2252.1 108.86,29.41 108.86,28.97 108.25,28.36 108.25,27.99 108.38,27.86 108.38,27.43 107.74,26.79 107.51,26.79 106.36,25.64 106.36,25.01 106.19,24.83 C2337.1 C2336.1 104.84,24.83 104.74,24.73 104.74,24.19 104.13,23.59 v1(103.58,23.59) 103.57,23.6 U2015.2
VCCST_PWRGD_R: length 86.7
  TOP w0.102: v1(108.05,28.78) 107.94,28.78 v1(106.99,27.82) 105.11,27.82 104.83,27.54 104.31,27.54 104.22,27.45 U2015.4
  IN1 w0.089: v1(107.15,73.47) 106.97,73.65 104.61,73.65 102.32,71.36 99.2,71.36 98.18,72.38 97.75,72.38 97.14,72.99 97.14,76.06 v1(99.08,78)
  IN3 w0.089: v1(108.05,28.78) 113.6,34.33 117,34.33 119.68,37 119.68,39.96 119.19,40.45 119.19,41.16 117.97,42.38 116.67,42.38 116.27,42.79 116.27,45.33 114.57,47.03 114.57,52.6 114.04,53.12 114.04,61.19 113.67,61.56 113.67,67.7 112.45,68.92 108.79,68.92 107.42,70.28 107.42,73.19 v1(107.15,73.47)
  BOTTOM w0.102: R2228.2 R2229.1 100.83,79.79 100.34,79.79 99.73,79.18 99.73,78.65 v1(99.08,78)
VSSGT_SENSE: length 10.6
  TOP w0.254: v1(95.85,79.01) 95.86,78.99 PR7052.1 96.66,79.79 96.58,79.87 PR7053.1
  BOTTOM w0.102: U2030.J69 92.8,75.32 92.8,76.82 92.94,76.96
  BOTTOM w0.254: v1(95.85,79.01) 96.3,79.46 R2455.2 96.48,79.32 96.48,78.24 95.44,77.2 95.09,77.2 94.98,77.1 93.08,77.1 92.94,76.96
VSSSA_SENSE: length 27.9
  TOP w0.254: v4(93.04,47.91) 93.04,48.14 93.32,48.41 96.38,48.41 97.25,49.28 98.58,49.28 98.99,48.88 102.04,48.88 102.75,49.58 104.94,49.58 R2194.1 105.17,49.66 105.77,49.06 106.63,49.06 107.43,48.26 107.43,47.79 108.06,47.15 109.66,47.15 110.08,46.74 v1(110.95,46.74) 112.64,46.74 114.23,45.15 115.38,45.15 115.64,45.41 PR7061.1 PR7062.1
  BOTTOM w0.254: v4(93.04,47.91) 92.7,47.56 U2030.H21
1.03_GFX_PGD: length 96
  IN1 w0.089: v1(95.67,85.05) 96.02,85.05 96.45,84.61 97.66,84.61 101.11,81.17 107.46,81.17 109.08,82.79 113.98,82.79 114.27,83.08 115.27,83.08 117.94,80.41 121.63,80.41 122.58,81.36 125.7,81.36 126.35,80.71 127.18,80.71 127.97,79.91 139.78,79.91 142.47,77.22 142.47,71.41 141.84,70.78 140.75,70.78 140.46,70.49 140.46,69.32 141.03,68.75 141.03,67.39 141.29,67.14 141.29,66.12 v1(142.47,64.93) ; v1(85.11,89.84) 84.92,89.84 84.67,90.09 84.67,91.55 83.49,92.73 83.49,93.95 82.87,94.58 80.12,94.58 79.84,94.3 v1(78.7,94.3)
  IN2 w0.089: v1(95.67,85.05) 94.84,85.05 92.29,87.6 88.4,87.6 86.35,89.65 85.3,89.65 v1(85.11,89.84)
  BOTTOM w0.102: v1(78.7,94.3) 78.91,94.51 78.91,97.03 PR9078.2 ; PR9096.1 142.11,65.3 v1(142.47,64.93) ; v1(85.11,89.84) 85.3,89.65 85.71,89.65 PR9076.1
2ND_MBCLK: length 228.1
  TOP w0.102: U37.115 190.05,30.93 189.95,31.02 189.95,31.5 190.52,32.07 R383.1 190.82,32.07 191.03,32.28 191.03,32.68 190.38,33.34 190.38,33.71 v2(190.49,33.83) ; Q13.3 108.03,85.57 108.24,85.79 v2(109.28,85.79)
  IN2 w0.089: v1(158.14,33.6) 158.03,33.71 155.99,33.71 155.08,32.8 146.99,32.8 146.77,32.57 144.33,32.57 143.93,32.97 143.16,32.97 140.19,30.01 139.57,30.01 138.73,29.16 138.54,29.16 138.26,28.89 138.26,28.72 138.08,28.54 137.67,28.54 136.61,29.6 136.61,32.52 135.81,33.32 135.04,33.32 130.13,38.24 128.61,38.24 126.96,39.89 126.96,40.48 125.64,41.8 125.64,43.62 124.34,44.92 124.34,49.6 122.56,51.37 122.56,51.73 122.15,52.14 119.92,52.14 118.93,53.13 117.39,53.13 115.41,55.11 v1(115.41,55.99) 115.85,56.43 115.85,58.4 116.84,59.4 116.84,61.94 117.14,62.24 117.14,65.52 116.61,66.06 115.94,66.73 115.94,68.71 116.23,69 116.23,73.25 113.43,76.05 108.4,76.05 107.42,77.02 107.42,81.64 110.23,84.45 110.23,85.7 109.94,85.99 109.49,85.99 v2(109.28,85.79) ; v2(88.3,31.51) 88.3,31.55 88.73,31.98 89.04,31.98 89.35,31.68 91.38,31.68 92.4,32.69 93.79,32.69 94.18,33.09 99.06,33.09 99.21,33.23 100.09,33.23 101.25,32.08 103.25,32.08 103.53,31.8 103.9,31.8 104.28,31.43 104.28,30.87 105.17,29.98 105.17,28.97 106.02,28.13 v1(108.72,28.13)
  IN3 w0.089: v2(200.05,28.95) 200.05,28.71 199.48,28.14 198.85,28.14 197.99,29 197.99,31.21 197.29,31.91 197.29,32.63 195.73,34.18 194.38,34.18 193.85,34.71 192.3,34.71 191.92,34.34 191.04,34.34 190.53,33.83 v2(190.49,33.83) 189.72,33.83 189.26,33.37 188.45,33.37 188.29,33.53 185.22,33.53 185,33.31 166.38,33.31 165.22,34.47 164.54,34.47 164.07,34.94 162.57,34.94 162.17,35.34 161.74,35.34 161.62,35.46 159.01,35.46 158.28,34.73 158.28,33.75 v1(158.14,33.6) ; v1(108.72,28.13) 108.85,28.13 112.37,31.65 113.52,31.65 114.56,32.68 117.15,32.68 120.36,35.9 120.96,35.9 121.48,36.42 121.48,37.57 120.16,38.89 120.16,43.11 119.27,43.99 118.44,43.99 117.32,45.11 117.32,46.05 117.75,46.48 117.75,49 115.24,51.51 115.24,55.82 v1(115.41,55.99)
  BOTTOM w0.102: v2(88.3,31.51) 88.3,31.53 88.25,31.58 R2538.1 ; v2(200.05,28.95) 200.05,28.49 199.48,27.92 199.22,27.92 199.07,27.77 199.07,26.47 R740.2
2ND_MBDATA: length 226.9
  TOP w0.102: v2(189.17,33.8) 189.24,33.72 189.24,32.88 189.53,32.59 189.53,32.39 189.85,32.07 R25304.1 189.98,31.99 189.52,31.53 189.52,30.87 189.65,30.75 U37.116 ; v2(109.28,86.42) 106.89,86.42 106.73,86.59 Q13.6
  IN2 w0.089: v1(157.86,34.18) 156.15,34.18 154.99,33.02 146.91,33.02 146.68,32.79 144.42,32.79 144.02,33.19 143.07,33.19 140.11,30.22 139.48,30.22 138.68,29.42 137.68,29.42 136.96,30.15 136.96,32.49 135.9,33.54 135.13,33.54 130.22,38.45 128.7,38.45 127.17,39.98 127.17,40.57 125.86,41.89 125.86,43.71 124.55,45.01 124.55,49.69 122.78,51.46 122.78,51.82 122.24,52.36 120.01,52.36 119.02,53.35 117.48,53.35 116.06,54.77 v1(116.06,55.96) 116.06,58.31 117.06,59.31 117.06,61.85 117.36,62.15 117.36,65.61 116.15,66.82 116.15,68.62 116.45,68.91 116.45,73.34 113.52,76.27 108.49,76.27 107.64,77.11 107.64,81.56 110.45,84.36 110.45,85.79 110.03,86.21 109.5,86.21 v2(109.28,86.42) ; v1(107.95,27.61) 106.23,27.61 104.95,28.88 104.95,29.89 104.06,30.78 104.06,31.34 103.81,31.59 103.44,31.59 103.16,31.86 101.16,31.86 100,33.02 99.3,33.02 99.15,32.88 94.27,32.88 93.88,32.48 92.49,32.48 91.47,31.46 89.03,31.46 v2(88.89,31.61)
  IN3 w0.089: v1(107.95,27.61) 108.81,27.61 112.63,31.43 113.61,31.43 114.65,32.46 117.24,32.46 120.45,35.68 121.05,35.68 121.7,36.33 121.7,37.66 120.38,38.98 120.38,43.2 119.36,44.21 118.53,44.21 117.54,45.2 117.54,45.96 117.97,46.39 117.97,49.09 115.45,51.6 115.45,55.35 v1(116.06,55.96) ; v1(157.86,34.18) 157.86,34.61 158.92,35.67 161.71,35.67 161.83,35.55 162.26,35.55 162.66,35.15 164.16,35.15 164.63,34.68 165.31,34.68 166.47,33.53 184.91,33.53 185.13,33.74 189.11,33.74 v2(189.17,33.8) 189.22,33.8 189.62,34.2 190.6,34.2 190.95,34.56 191.83,34.56 192.21,34.93 193.94,34.93 194.47,34.4 195.83,34.4 197.5,32.72 197.5,32 198.21,31.3 198.21,29.69 198.79,29.11 v2(199.48,29.11)
  BOTTOM w0.102: v2(88.89,31.61) 88.96,31.69 R2539.1 ; R739.2 198.84,25.22 198.84,27.83 199.14,28.12 199.39,28.12 199.64,28.37 199.64,28.94 v2(199.48,29.11)
27M_XTAL_IN: length 9.2
  BOTTOM w0.102: Y3.3 101.08,87.43 101.08,88.77 C463.1 101.68,91.23 102.26,91.8 102.26,93.65 102.17,93.74 102.17,94.25 U8.C11
27M_XTAL_OUT: length 6.7
  BOTTOM w0.102: Y3.1 100.68,89.04 C464.1 100.68,90.51 102.05,91.89 102.05,93.49 U8.B10
3602_ALERT#: length 2.8
  BOTTOM w0.102: PU7000.33 139.75,58.36 v1(140.13,58.75) 140.23,58.75 141.09,59.6 PR7020.1
3602_CLK: length 3.2
  BOTTOM w0.102: PU7000.34 140.15,58.11 140.88,58.84 141.47,58.84 PR7015.2
3602_DRON: length 115.7
  TOP w0.152: v1(135.98,44.46) 135.98,46.42 135.44,46.95 135.44,47.53 135.7,47.79 136.2,47.79 137.17,46.81 137.17,44.7 138.01,43.86 138.86,43.86 139.75,42.97 140.51,42.97 141.31,43.77 141.31,44.18 141.51,44.39 142.39,44.39 142.56,44.21 v1(143.65,44.21)
  IN2 w0.203: 131.28,79.03 128.02,79.03 126.29,80.76 125.16,80.76 124.78,80.38 124.78,80.01 126.3,78.49 127.15,78.49 129.84,75.8 129.84,71.19 129.04,70.39 123.61,70.39 121.63,72.38 117.69,72.38 116.97,71.66 v1(116.97,70.92) ; 131.28,79.03 131.53,79.28 140.09,79.28 142.2,77.18 142.2,70.9 141.93,70.63 140.9,70.63 139.9,69.63 139.9,66.04 141.18,64.76 141.18,63.42 141.86,62.75 141.86,58.52 v1(141.67,58.33) 142.35,57.64 142.35,55.33 142.61,55.08 143.71,55.08 144.16,54.63 144.36,54.63 144.77,54.23 144.77,53.45 145.01,53.21 145.01,52.28 144.74,52.01 144.74,51.31 142.94,49.52 142.94,44.92 v1(143.65,44.21) ; 131.28,79.03 131.28,75.58 v1(131.61,75.25)
  BOTTOM w0.203: v1(131.61,75.25) 131.61,75.6 130.97,76.24 PR7111.1 ; PU7000.35 140.55,58.15 140.75,58.36 141.64,58.36 v1(141.67,58.33) ; PR7107.1 116.18,70.56 116.53,70.92 v1(116.97,70.92) ; v1(135.98,44.46) 136.08,44.56 136.08,45.59 PR7079.1 ; v1(143.65,44.21) 143.76,44.1 143.76,40.04 PR7115.1
3602_PSYS: length 5.4
  TOP w0.203: v1(143.01,52.64) 142.85,52.64 142.56,52.94 142.56,53.58 142.3,53.83 PC7006.1 142.02,53.33 142.06,53.29 PR7042.2 142.06,52.83 141.38,52.15 PR7039.2
  BOTTOM w0.203: PU7000.46 142.41,53.07 142.84,52.64 v1(143.01,52.64)
3602_SET1: length 3.8
  TOP w0.203: PR7035.2 140.7,51.12 140.81,51.12 v1(140.83,51.1) 140.83,50.65 v1(140.65,50.47) 140.84,50.28 PR7027.2
  BOTTOM w0.203: PU7000.2 140.55,50.59 140.65,50.49 v1(140.65,50.47)
3602_SET2: length 5
  TOP w0.203: PR7028.2 141,49.92 140.5,49.92 140.14,50.28 140.14,50.51 PR7036.1 139.86,50.58 139.46,50.19 v1(139.46,49.97)
  BOTTOM w0.203: v1(139.46,49.97) 139.35,50.09 PU7000.5
3602_SET3: length 3.7
  TOP w0.203: PR7037.1 137.6,49.52 137.86,49.26 PR7029.2 138.84,50 v1(138.84,50.15)
  BOTTOM w0.203: PU7000.6 138.95,50.26 v1(138.84,50.15)
3602_TSENSE_CORE: length 65
  IN3 w0.102: v1(136.09,48.89) 135.67,48.89 134.31,47.53 134.31,47.02 134.72,46.62 135,46.62 135.76,45.86 135.76,45.19 134.79,44.22 132.97,44.22 132.46,43.72 130.58,43.72 129.59,42.73 129.59,41.67 129.34,41.43 126.41,41.43 125.75,42.09 125.75,42.29 124.33,43.71 124.33,50.17 120.62,53.88 120.62,62.48 117.61,65.49 117.61,71.63 118.08,72.1 121.18,72.1 122.85,73.77 125.26,73.77 v1(126.06,72.97)
  BOTTOM w0.203: v1(136.09,48.89) PR7026.2 136.71,49.15 136.34,49.52 136.34,50.23 136.95,50.83 PU7000.11 ; v1(126.06,72.97) 126.39,72.65 PR7032.1
3602_TSENSE_GT: length 31.2
  TOP w0.203: v1(134.68,56.25) 134.93,56.25 PR7018.2
  IN2 w0.089: v1(134.68,56.25) 133.5,56.25 132.95,56.8 132.95,57.21 133.09,57.34 133.09,60.24 132.48,60.84 132.48,63.52 133.09,64.12 133.09,67.34 130.3,70.13 130.3,75.99 127.35,78.94 126.57,78.94 126.11,79.41 v1(126.11,79.64)
  BOTTOM w0.203: v1(134.68,56.25) 134.7,56.27 PU7000.23 ; v1(126.11,79.64) 125.41,79.64 PR7021.1
3602_VCC: length 4.5
  TOP w0.381: v1(134.65,51.29) 135.16,51.8 135.24,51.8 ; 135.24,51.8 PC7026.1 ; 135.24,51.8 135.07,51.97 134.44,51.97 133.67,51.2 PR7064.2
  BOTTOM w0.203: v1(134.65,51.29) 134.65,51.64 135.28,52.27 PU7000.13
3602_VDIO: length 2.6
  BOTTOM w0.102: PU7000.32 139.35,58.62 140.28,59.55 PR7019.2
3602_VIN: length 5.3
  TOP w0.203: PR7000.1 134.01,48.87 v1(134.34,48.55) 134.78,48.55 135.32,49.08 PC7000.2 135.98,50.29 v1(135.98,50.71)
  BOTTOM w0.203: PU7000.12 136.55,51 136.26,50.71 v1(135.98,50.71)
3602_VREF: length 60
  TOP w0.203: 144.36,48.14 142.01,48.14 141.05,49.1 140.71,49.44 PR7024.2 ; 144.36,48.14 144.66,47.84 144.66,47.26 142.23,44.82 140.07,44.82 139.47,44.22 v1(139.47,44.06) ; 144.36,48.14 144.85,48.63 ; PR7022.2 144.22,50.11 144.22,49.79 144.05,49.62 PR7023.2 144.22,49.26 144.85,48.63 ; v1(142.81,54.61) 142.42,54.61 PR7008.1 142.18,55.7 PR7005.1 ; v1(146.66,49.25) 146.04,48.63 144.85,48.63 ; PR7010.1 134.44,54.49 v1(134.53,54.4)
  IN1 w0.254: v1(146.66,49.25) 146.66,49.22 146.71,49.17 146.84,49.17 147.13,49.47 147.13,50.77 146.48,51.42 146.42,51.42 146.11,51.73 146.11,53.63 144.97,54.77 143.47,54.77 143.31,54.61 v1(142.81,54.61)
  IN3 w0.254: v1(142.81,54.61) 142.33,55.09 142.33,61.03 140.56,62.8 139.56,62.8 138.87,62.11 137.7,62.11 137.22,61.63 v1(137.22,61.2) 137.15,61.12 137.15,60.08 137.65,59.57 138.49,59.57 139.18,58.89 139.18,58.2 138.74,57.77 138.42,57.77 137.78,57.13 136.67,57.13 136.21,56.67 136.21,55.23 135.38,54.4 v1(134.53,54.4)
  BOTTOM w0.203: v1(139.47,44.06) 138.23,44.06 137.73,44.55 PR7009.1 ; v1(142.81,54.61) 142.75,54.67 PU7000.42 ; v1(137.22,61.2) 137.09,61.07 PR7004.1 ; PR7013.1 145.74,49.9 145.58,49.74 PR7006.2 145.83,49.01 146.5,49.01 146.66,49.17 v1(146.66,49.25)
3602_VRHOT: length 2.8
  BOTTOM w0.102: PU7000.31 138.95,58.13 139.1,58.28 139.1,58.94 138.72,59.32 PR7011.1 PR7012.1
5213EN_1.8V: length 3.1
  TOP w0.254: PU3004.7 39.72,29.45 39.56,29.3 39.56,28.47 39.41,28.31 PC581.1 PR566.1
5213FB_1.8V: length 4.2
  TOP w0.102: PC574.2 40.3,27.86 v1(40.18,27.74)
  TOP w0.254: PU3004.1 42.7,28.95 42.95,28.7 PR567.2 42.51,27.85 42.51,27.86 PR568.2 PC574.2
5213FB_1.8V_S: length 5.1
  TOP w0.102: PR568.1 PC574.1 41.01,26.91 40.47,26.38 38.96,26.38 v1(38.85,26.49) 38.46,26.88 38.46,27.01 38,27.47 PR569.1
5213LX_1.8V: length 0.8
  TOP w0.254: PU3004.6 39.43,29.95
  vias: v1(41.05,31.89)
5213PG_1.8V: length 1.4
  TOP w0.102: PU3004.2 42.96,29.45 43.45,28.97 PR9256.2
5416_VCC: length 5.5
  TOP w0.198: 62.29,121.91 62.3,121.9 PU26.7
  TOP w0.254: 62.29,121.91 62.01,122.19 62.01,124.56 PR256.1 62.43,125.46 PC268.2
5447_CC1_CON: length 24
  TOP w0.178: v1(22.6,13.85) 22.74,13.85 23.18,14.29 23.18,15.5 22.92,15.75 22.92,16.62 21.98,17.56 17.82,17.56 16.73,18.65 15.47,18.65 15.33,18.5 13.45,18.5 13.08,18.87 C691.2
  TOP w0.508: v1(10.53,17.72) 10.8,17.72 11.96,18.87 D16.2 C691.2
  IN3 w0.508: v1(9.03,14.86) 9.53,14.86 10.53,15.86 v1(10.53,17.72)
  BOTTOM w0.178: U6503.11 23.17,14.36 22.67,13.85 v1(22.6,13.85)
  BOTTOM w0.203: v1(9.03,14.86) 8.81,14.86 8.31,15.36 7.71,15.36 7.51,15.15 CN10.A5
5447_CC2_CON: length 25
  TOP w0.178: v1(10.76,14.46) 10.76,14.14 C692.2 D17.2
  IN1 w0.178: v1(22.6,15.18) 22.57,15.15 20.56,15.15 17.36,11.95 14.93,11.95 14.25,12.64 12.41,12.64 10.76,14.29 v1(10.76,14.46)
  IN3 w0.127: 5.85,14.16 5.7,14.36 5.66,14.54 5.66,14.79 5.69,14.86 5.7,15.25 CN10.B5
  IN3 w0.178: 5.85,14.16 5.93,14.08 8.47,14.08 8.82,13.73 10.02,13.73 v1(10.76,14.46)
  BOTTOM w0.203: v1(22.6,15.18) 22.77,15.36 U6503.13
8813BOOT1:
  vias: v1(76.14,113.36)
8813BOOT2:
  vias: v1(76.09,108.15)
8813EN: length 7.7
  TOP w0.254: PR9278.2 75.58,115.8 74.86,115.09 PR9012.1 v1(73.9,115.06) ; v1(73.9,115.06) 73.21,115.76 PC9013.1 72.11,116.54 PR25542.2 ; v1(73.9,115.06) 73.9,113.77 74.23,113.45 PU9000.3
8813ILIM: length 5.5
  TOP w0.254: PU9000.12 71.73,109.53 71.4,109.2 71.4,108.86 71.45,108.81 v1(71.45,108.26)
  BOTTOM w0.254: v1(71.45,108.26) 71.45,108 71.74,107.71 73.17,107.71 PC9030.1 PR9032.2
8813ISEN1: length 3.1
  TOP w0.203: PC9014.2 PR9013.2 72.92,107.06 73.73,107.86 PU9000.15
8813ISEN2: length 6.9
  TOP w0.203: PR9025.2 73.45,105.1 v1(72.43,105.1) 71.86,105.1 71.46,105.5 71.46,107.53 71.67,107.73 72.81,107.73 73.23,108.15 PU9000.14
8813LGAT1:
  vias: v1(77.15,115.16) v3(78.22,115.22)
8813LGAT2: length 6.5
  TOP w0.508: v3(83.68,109.97) 80.61,109.97 80.5,109.87 77.73,109.87 77.68,109.82 77.2,109.82
  vias: v1(84.79,108.04)
8813PG: length 3.2
  TOP w0.203: PR9283.2 74.29,106.64 PR9009.2 73.85,107.12 74.03,107.3 PR9008.2 74.26,107.7 74.23,107.74 PU9000.16
8813PHASE1: length 2.2
  TOP w0.508: PR9004.2 78.05,118.16 78.05,117.44 77.81,117.2 v3(77.81,116.2)
  vias: v1(77.3,115.54)
8813PHASE2: length 10.4
  TOP w0.508: 78.24,108.77 78.53,109.06 PR9019.2 v3(84.62,109.06)
  BOTTOM w0.508: v3(84.62,109.06) 84.62,110.13 83.64,111.11 82.14,111.11
  vias: v1(79.46,114.05)
8813PSI: length 7.2
  TOP w0.254: PU9000.4 73.73,113.34 73.47,113.6 73.47,114.26 73.19,114.54 72.7,114.54 71.97,115.28 71.84,115.28 71.09,116.02 PR9022.2 PR9016.2 PR9018.2
8813PVCC: length 4.6
  TOP w0.254: v1(77.51,110.49) 77,110.49 76.94,110.55 76.65,110.55 76.62,110.53 PU9000.21
  TOP w0.381: v1(77.51,110.49) 78.37,110.49 PC9000.1
  BOTTOM w0.305: PR9001.2 77,110.49 v1(77.51,110.49)
8813REFADJ: length 1.7
  TOP w0.254: v1(72.17,112.8) 72.21,112.76 72.72,112.76 PU9000.6
  BOTTOM w0.254: v1(72.17,112.8) 72.39,112.8 72.89,113.3 PR9023.2
8813REFIN: length 5.1
  TOP w0.203: v1(71.28,112.58) 71.23,112.64 70.71,112.64 70.43,112.92 70.43,114.14 PC9026.1
  TOP w0.254: v1(71.28,112.58) 71.84,112.03 PU9000.7
  BOTTOM w0.254: PR9024.2 71.38,112.48 v1(71.28,112.58) 71.2,112.67 70.33,112.67 PR9027.1
8813RGN: length 4.3
  TOP w0.254: PU9000.10 71.14,110.53 70.88,110.27 v1(70.72,110.27)
  BOTTOM w0.254: PR9029.1 69.9,111.94 PC9029.1 69.9,110.7 PC9028.2 70.31,110.69 v1(70.72,110.27)
8813TON: length 1.6
  TOP w0.254: PU9000.9 70.85,111.03 70.7,110.88 PR9002.2
8813UGATE1:
  vias: v1(73.99,114.14) v3(74.75,114.28)
8813UGATE1_1:
  vias: v1(72.03,115.87)
8813UGATE2:
  vias: v1(75.9,106.78)
8813UGATE2_1: length 7.7
  TOP w0.508: PR9014.2 78.97,106.11 v1(79.17,105.9) 83.17,105.9 83.78,105.29 83.78,104.29 84.03,104.04 v3(84.44,104.04)
9336ADJ:
  vias: v1(73.7,95.31)
9336DRV: length 11.2
  BOTTOM w0.508: PU9003.6 76.58,94.62 76.22,94.25 PR9080.1 75.63,94.85 PD9001.1 74.73,95.36 v1(72.87,93.5) PQ9008.4
24780_ACDET: length 9.7
  TOP w0.203: PQ17.3 139.6,32.54 138.87,33.26 138.56,33.26 138.18,33.64 137.48,33.64 136.97,34.15 v1(136.97,34.89)
  BOTTOM w0.178: PU1.6 135.28,32.43
  BOTTOM w0.203: 135.28,32.43 135.8,32.96 PR31.2 PR211.2 137.25,33.96 137.25,34.61 v1(136.97,34.89)
24780_ACDRV: length 2
  BOTTOM w0.178: PU1.4 134.48,32.47 134.35,32.6
  BOTTOM w0.203: 134.35,32.6 134.29,32.66 134.29,33.12 134.65,33.48 PR29.2
24780_ACN: length 147.7
  TOP w0.198: PR2.2 55.02,113.96 55.38,113.96 55.99,113.35 55.99,112.51 v1(56.17,112.33)
  TOP w0.203: v1(132.44,32.63) 132.72,32.92 PC35.1
  IN2 w0.198: v1(56.17,112.33) 56.85,113.01 59.34,113.01 59.83,113.49 61.6,113.49 62.96,112.14 64.62,112.14 71.59,105.17 73.84,105.17 76.52,102.49 77.3,102.49 78.84,100.95 82.02,100.95 82.21,100.76 85.32,100.76 85.58,101.03 86.28,101.03 86.49,100.81 87.1,100.81 88.7,102.41 90.01,102.41 91.74,100.68 91.74,92.6 92.55,91.79 94.1,91.79 96.4,89.49 97.9,89.49 98.54,90.13 100.65,90.13 101.31,89.48 102.77,89.48 103.19,89.06 103.19,87.45 103.46,87.18 103.46,85.89 104,85.35 104,78.9 103.93,78.82 103.93,77.5 104.3,77.12 104.3,76.66 105.26,75.7 105.26,70.55 107.46,68.35 113.23,68.35 114.96,66.63 114.96,62.13 114.6,61.77 114.6,54.92 116.62,52.89 116.62,51.45 117.65,50.42 121.71,50.42 123.26,48.87 123.26,42.85 126.08,40.03 126.08,37.54 126.7,36.92 126.7,35.23 128.1,33.83 132.4,33.83 132.73,33.5 132.73,32.93 v1(132.44,32.63)
  BOTTOM w0.178: PU1.1 133.28,32.25 133.15,32.38
  BOTTOM w0.203: 133.15,32.38 132.89,32.63 v1(132.44,32.63) 132.9,33.1 PC25.2
24780_ACP: length 150
  TOP w0.198: PR1.2 54.98,113.68 55.2,113.68 55.67,113.21 55.67,112.49 v1(55.41,112.23)
  TOP w0.203: v1(132.27,33.31) 132.76,33.31 132.86,33.42 133.57,33.42 134.08,32.92 PC36.2
  IN2 w0.198: v1(132.27,33.31) 132.05,33.53 127.98,33.53 126.4,35.11 126.4,36.79 125.78,37.41 125.78,39.91 122.96,42.73 122.96,48.75 121.58,50.12 117.53,50.12 116.32,51.33 116.32,52.77 114.3,54.79 114.3,61.89 114.66,62.25 114.66,66.5 113.11,68.05 107.34,68.05 104.74,70.65 104.61,70.65 104,71.25 104,77 103.63,77.37 103.63,78.95 103.7,79.02 103.7,85.23 103.16,85.77 103.16,87.05 102.89,87.33 102.89,88.94 102.65,89.18 101.07,89.18 100.41,89.83 98.66,89.83 98.02,89.19 96.28,89.19 93.98,91.49 92.43,91.49 91.44,92.48 91.44,100.56 89.89,102.11 88.83,102.11 87.23,100.52 86.46,100.52 86.11,100.17 85.48,100.17 85.18,100.46 82.08,100.46 81.89,100.65 78.72,100.65 77.18,102.19 76.4,102.19 73.71,104.87 71.47,104.87 64.5,111.84 62.83,111.84 61.48,113.19 59.96,113.19 59.47,112.71 57.33,112.71 56.5,111.88 55.76,111.88 v1(55.41,112.23)
  BOTTOM w0.178: PU1.2 133.68,32.36 133.55,32.49
  BOTTOM w0.203: v1(132.27,33.31) 132.27,34.13 132.43,34.28 PC25.1 133.39,33.8 133.39,32.65 133.55,32.49
24780_BATDRV: length 11.4
  TOP w0.381: v1(134,26.66) 133.68,26.34 128.46,26.34 v1(127.86,26.94) 127.46,27.34 127.24,27.34 126.85,27.73 125.58,27.73 125.51,27.8 PR4.2
  BOTTOM w0.198: v1(134,26.66) 134,26.68 134.48,27.16 PU1.18
24780_BATSRC: length 14.6
  TOP w0.381: PR7.2 124.05,27.13 124.1,27.07 126.65,27.07 127.89,25.84 130.14,25.84 130.21,25.77 v1(130.66,25.77) 131.74,25.77 131.81,25.84 133.98,25.84 134.67,26.52 v1(134.67,26.67)
  BOTTOM w0.198: v1(134.67,26.67) 134.67,26.86 134.88,27.08 PU1.17
24780_BM#: length 2.6
  BOTTOM w0.178: PU1.16 135.28,27.3 135.33,27.25 v1(135.33,26.84) 135.51,26.84 135.76,27.09 136.43,27.09 PR9.1
24780_BST: length 3.3
  BOTTOM w0.102: v1(130.18,28.65) 130.18,29.48 PR11.1
  BOTTOM w0.198: PU1.25 131.51,29.91 131.36,29.76 130.45,29.76 PR11.1
24780_CMPIN: length 3.1
  TOP w0.198: v1(137.83,28.94) 138.29,29.4 v1(138.29,29.62) 137.52,29.62 PR207.1
  BOTTOM w0.178: v1(137.83,28.94) 137.09,28.94 136.93,29.11 PU1.13
24780_CMPOUT: length 1.5
  BOTTOM w0.178: PU1.14 136.87,28.71 136.99,28.59 137.37,28.59 PR15.1
24780_CMSRC: length 1.7
  BOTTOM w0.178: 133.98,32.52 134.08,32.42 PU1.3
  BOTTOM w0.203: PR28.2 133.87,32.63 133.98,32.52
24780_DH: length 11.5
  IN3 w0.508: v1(131.16,30.24) 130.82,30.24 129.09,28.51 125.92,28.51 123.37,31.06 v1(122.76,31.06)
  BOTTOM w0.198: v1(131.16,30.24) 131.23,30.31 PU1.26
24780_DL: length 6.4
  BOTTOM w0.198: PU1.23 131.86,29.11
  BOTTOM w0.381: PQ29.4 127.62,27.92 v1(127.71,28.01) 128.42,28.01 128.77,27.66 130.03,27.66 130.84,28.47 131.22,28.47 131.86,29.11
24780_ILIM: length 5.4
  TOP w0.102: PR206.1 130.96,27.05 v1(130.93,27.02)
  TOP w0.203: PR204.1 133.46,27.36 PC8.2 132.77,26.9 132.4,27.28 ; 132.4,27.28 v1(132.4,28.18) ; 132.4,27.28 132.17,27.05 PR206.1
  BOTTOM w0.198: v1(132.4,28.18) 133.01,28.18 PU1.21
24780_LX: length 8.7
  TOP w0.508: PC15.1 130.3,30.1 v1(129.95,30.46) 129.2,31.21 v1(129.16,31.21) 129.16,31.2 126.74,31.2 126.22,30.69 v1(126.22,30.62) 126.26,30.58 PR33.1
  BOTTOM w0.198: v1(129.95,30.46) 130.69,30.46 130.94,30.71 130.95,30.71 130.96,30.72 131.36,30.72 131.37,30.71 PU1.27
24780_SRN: length 12.3
  BOTTOM w0.102: PC3.1 130.15,26.3 128.67,26.3 v1(128.32,26.64) 128.26,26.71 126.13,26.71 125.81,26.39 124.95,26.39 124.35,25.79 PC4.2 123.99,25.78 123.67,25.46 122.55,25.46 122.09,25 PR208.1
  BOTTOM w0.198: PR6.2 132.86,26.49 130.92,26.49 PC3.1
24780_SRP: length 10.2
  BOTTOM w0.102: PR210.1 124.16,26.78 v1(124.26,26.78) 124.42,26.94 127.04,26.94 127.27,27.17 129.46,27.17 PC3.2 130.28,27.21 131.31,27.21 131.57,26.95 PC6.2
  BOTTOM w0.198: PC6.2 131.64,26.89 PR5.2
24780_VCC: length 1.6
  TOP w0.559: v1(131.22,31.31) 130.72,31.82 PR16.1
25810_AUO#: length 3.2
  BOTTOM w0.102: R6508.2 23.01,18.86 v1(23.1,18.77) 22.88,18.55 22.88,17.95 23.02,17.81 23.9,17.81 24,17.71 U6503.17
25810_DBG#: length 2.3
  BOTTOM w0.102: U6503.16 22.74,16.86 22.21,17.39 22.03,17.39 21.52,17.89 R6510.2
25810_FAULT#: length 1.3
  BOTTOM w0.102: R6504.2 27.1,16.86 U6503.1
25810_LD_DET#: length 3.9
  BOTTOM w0.102: U6503.20 25.5,17.79 25.6,17.89 26.58,17.89 27.04,18.35 27.04,18.97 R6505.2 27.1,19.41 v1(27.62,19.93)
25810_POL#: length 16.1
  TOP w0.102: v1(25.31,20.23) 25.68,20.23 26.01,20.56 26.91,20.56 27.24,20.89 27.24,21.77 R9041.2 26.82,21.58 R25590.2 23.3,21.58 R6507.2
  BOTTOM w0.102: v1(24.42,18.68) 23.96,18.68 23.11,19.54 21.46,19.54 20.51,18.59 20.51,18.24 20.21,17.93 R25280.1 ; v1(24.42,18.68) 24.5,18.6 U6503.18 ; v1(24.42,18.68) 24.75,18.68 25.31,19.24 v1(25.31,20.23)
25810_REF: length 3.4
  BOTTOM w0.102: v1(21.52,12.18) R6517.1 22.84,12.64 23.46,12.64 24,13.18 U6503.10
25810_REF_RTN: length 2.2
  BOTTOM w0.102: R6517.2 23.43,12.18 24.5,13.25 U6503.9
25810_UFP#: length 50.8
  TOP w0.102: v1(20.56,12.71) 20.56,12.33 20.92,11.97 Q6519.2 22.79,11.97 22.97,12.15 22.97,12.81 23.05,12.89 23.05,13.7 23.58,14.24 23.58,16.27 23.49,16.36 v1(23.49,17.37) ; v1(15.66,4.41) 16.35,5.1 R25337.1
  IN1 w0.089: v1(20.56,12.71) 16.19,8.34 16.19,4.94 v1(15.66,4.41)
  IN2 w0.089: v1(26.53,18.55) 26.53,18.24 25.65,17.37 v1(23.49,17.37) 23.46,17.37 22.63,18.19 21.57,18.19 21.15,18.61 20.27,18.61 19.86,18.2 17.06,18.2 16.75,18.5 14.03,18.5 13.5,19.04 13.5,19.4 11.26,21.63 8.18,21.63 7.4,22.41 7.4,23.89 v1(6.79,24.5)
  BOTTOM w0.102: R6506.2 26.21,20.12 26.21,18.87 v1(26.53,18.55) 26.1,18.12 25.18,18.12 25,17.94 U6503.19 ; Q6505.3 7.01,24.28 v1(6.79,24.5)
+1.03_GFX:
  vias: v1(73.04,103.49) v1(73.67,103.49) v1(89.18,110.7) v1(89.16,110.05) v1(95.71,114.93) v1(96.39,115.21) v1(106.8,121.44) v1(107.44,121.43) v1(118.13,115.29) v1(118.81,115.31) v1(118.93,120.85) v1(120.51,121.54) v2(88.91,104.74) v2(110.88,108.52)
+601_VCC:
  vias: v1(204.94,14.07) v1(208.55,12.38) v1(216.34,13.07)
+AZA_VDD: length 13.2
  IN2 w0.508: v2(206.69,27.93) v2(206.69,28.56) 206.69,30.16 207.45,30.92 207.45,32.63 206.67,33.42 206.67,34.88 v1(207.71,35.92)
  BOTTOM w0.203: U20.36 206.86,36.1 207.06,36.31 207.3,36.31 207.97,36.98 C565.1
  BOTTOM w0.381: C565.1 208.72,36.93 v1(207.71,35.92)
+FB_PLLAVDD: length 36.8
  TOP w0.127: v1(119.14,114.54) 119.3,114.7 L5.2 121.06,114.7 v1(121.1,114.75)
  TOP w0.305: v2(112.11,98.37) 110.6,98.37 C455.2
  TOP w0.381: C453.2 106.87,97.18 107.28,97.59 v2(107.31,97.59) ; C454.2 111.58,103.1 v2(111.26,103.41)
  IN1 w0.127: v2(111.26,103.41) 110.25,104.43 110.25,108.98 109.87,109.36 108.42,109.36 108.06,109.71 108.06,110.1 108.9,110.93 108.9,112.89 110.86,114.84 114.41,114.84 114.95,115.39 115.76,115.39 116.61,114.54 v1(119.14,114.54)
  IN3 w0.127: 109.66,98.77 109.66,100.85 111.26,102.45 v2(111.26,103.41)
  BOTTOM w0.127: C456.1 v1(119.14,114.54)
  BOTTOM w0.305: v2(112.11,98.37) 111.71,98.77 U8.H22 ; U8.P22 111.58,103.73 v2(111.26,103.41)
  BOTTOM w0.381: U8.F16 106.76,97.07 107.23,97.54 107.26,97.54 v2(107.31,97.59)
+G_SEN_PW: length 18.9
  TOP w0.254: 54.06,17.92 50.89,17.92 50.81,17.99 50.18,17.99 ; 54.06,17.92 54.81,18.66 U32.8 ; 54.06,17.92 54.65,17.33 54.65,16.65
  TOP w0.508: 49.57,19.49 49.21,19.14 49.21,18.35 49.57,17.99 50.18,17.99 ; v1(54.65,15.05) 54.65,16.65
  IN1 w0.508: v1(62.24,15.05) 62.06,15.05 61.43,15.68 55.46,15.68 54.82,15.05 v1(54.65,15.05)
+PEX_IOVDDQ: length 2.6
  BOTTOM w0.381: U8.AA13 U8.AA12 v2(102.96,110.02) ; v2(101.31,109.99) U8.AA10 v2(102.09,110.02)
  vias: v2(108.75,109.94) v2(109.61,109.89) v2(110.4,109.89) v2(111.26,109.96) v2(112.14,110.72) v2(112.88,111.63) v2(113.73,112.43) v2(114.54,113.22) v2(115.34,114.06)
+PEX_PLL_HVDD: length 16
  TOP w0.152: R299.1 88.34,108.8 v1(88.44,108.91) 89,108.91 C429.2 90.03,109.01 92.76,109.01 93.43,108.34 96.71,108.34 96.97,108.61 R25562.1 98.95,108.61 99.4,109.06 C431.2 100.4,109.06 C425.2 100.56,109.93 v2(100.51,109.97)
  BOTTOM w0.381: U8.AA8 v2(100.51,109.97) U8.AA9
+PEX_SVDD_3V3: length 2.6
  TOP w0.152: v2(99.63,109.97) 99.49,110.11 v1(98.84,110.11) 98.15,110.11 R25562.2
  BOTTOM w0.152: v2(99.63,109.97) 100.05,110.39 U8.AB8
+SMDDR_VREF_DQ1_M1: length 163.5
  TOP w0.254: 37.12,45.19 37.12,45.03 U2012.M1 ; U2010.M1 37.21,79.55 37.21,80.23
  TOP w0.33: 37.64,93.18 37.64,92.73 U2009.M1 ; U2011.M1 37.79,58.21 37.79,58.65
  TOP w0.508: 37.12,45.19 37.12,46.61 35.45,48.28 C2236.2 30.05,48.28 C2247.2 30.05,46.82 29.7,46.46 28.67,46.46 28.18,46.95 v2(28.18,47.73) ; v1(27.85,80.55) C2105.1 29.31,80.12 C2104.2 29.31,80.6 30.14,81.42 36.29,81.42 37.21,80.5 37.21,80.23 ; v1(64.25,97.49) 64.25,98.08 64.96,98.79 65.72,98.79 66.48,98.03 66.48,96.76 66.7,96.54 66.7,93.64 65.21,92.15 65.21,86.13 64.68,85.6 64.68,85.11 R2135.2 64.04,85.1 63.32,84.38 R2140.2 R2132.1 63.4,82.9 64.26,83.75 R2136.2 ; v2(36.64,95.39) 36.64,95.48 36.03,96.09 C2086.2 C2085.1 37.44,95.45 37.71,95.18 37.71,93.25 37.64,93.18 ; v1(27.82,65.52) 29.27,65.52 29.6,65.19 34.94,65.19 35.52,64.6 35.52,62.53 35.89,62.16 C2165.2 C2164.2 C2163.2 37.79,61.39 37.79,58.65
  IN1 w0.508: v1(27.82,65.52) 27.82,64.6 27.39,64.17 27.39,56.36 27.6,56.16 27.6,48.14 28,47.73 v2(28.18,47.73) ; v1(64.25,97.49) 63.6,97.49 62.44,98.66 53.76,98.66 53.27,98.17 49.88,98.17 49.21,97.5 47.35,97.5 46.21,96.36 46.21,95.79 45.68,95.26 36.76,95.26 v2(36.64,95.39) ; v1(31.46,95.67) 30.8,95.67 29.4,94.27 29.4,89.52 27.31,87.43 27.31,82.85 27.62,82.54 27.62,82.03 27.87,81.77 27.87,80.57 v1(27.85,80.55)
  BOTTOM w0.508: v1(27.82,65.52) 27.82,67.19 27.54,67.48 27.54,70.18 27.87,70.51 27.87,77.63 28.31,78.07 28.31,80.1 27.86,80.55 v1(27.85,80.55) ; v2(36.64,95.39) 35.65,96.38 32.8,96.38 32.09,95.67 v1(31.46,95.67)
+TP_PWR_C: length 7.9
  TOP w0.635: R25462.2 63.3,102.1 62.71,102.69 C6625.2 C6624.2 v1(61.28,104.18) 60.76,104.69 60.38,104.69 59.34,105.73 R25465.2 59.27,105.98 58.76,105.98 v1(58.49,106.25)
+TYPEC_VBUS: length 2.2
  BOTTOM w0.254: CN10.B4 6.17,17.15 CN10.A9 ; CN10.B9 6.17,14.65 CN10.A4
  vias: v1(9,21.02) v1(9.05,20.33) v1(9.69,20.33) v1(15.43,14.47) v1(15.43,13.83) v1(15.43,13.2) v1(15.73,12.64) v1(16.06,14.47) v1(16.06,13.83) v1(16.06,13.2) v1(16.39,12.64) v1(16.7,14.47) v1(16.7,13.83) v1(16.7,13.2)
+TYPEC_VBUS_C:
  vias: v1(19.54,16.93) v1(19.54,16.3) v1(20.18,16.93) v1(20.18,16.3) v1(20.81,16.93) v1(20.81,16.3) v1(21.45,16.93) v1(21.45,16.3) v1(22.08,16.3)
+USBPWR0: length 0.7
  TOP w0.203: v1(20.85,54.16) 20.78,54.23 U16.2
  vias: v1(17.95,50.64) v1(18.2,50) v1(18.54,50.89) v1(18.79,50.29)
+USBPWR1: length 0.8
  TOP w0.203: U17.2 20.4,33.78 20.61,34 v1(20.64,34)
+VGPU_CORE: length 49.6
  BOTTOM w0.254: U8.K18 108.82,99.73 v2(108.39,99.3)
  BOTTOM w0.381: U8.M18 108.86,101.73 108.4,101.27 v2(108.4,101.27) 108.39,101.26 108.39,101.09 U8.L17 107.5,100.2 107.5,100.16 v2(107.5,100.15) 107.07,99.73 U8.K16 ; U8.K14 105.03,99.91 v2(105.35,100.23) 105.85,100.73 U8.L15 106.03,100.81 v2(106.56,101.33) 106.95,101.73 U8.M16 107.03,101.9 v2(107.5,102.37) 107.67,102.37 U8.N17 108.03,102.77 v2(108.52,103.26) 108.56,103.26 U8.P18 ; v2(100.65,105.36) U8.T10 U8.U11 102.5,107.2 102.52,107.2 v2(102.65,107.33) 103.03,107.71 U8.V12 ; v2(100.65,107.36) 100.66,107.36 U8.V10 ; U8.K10 U8.L11 102.24,100.94 102.31,100.94 v2(102.47,101.11) 103.03,101.66 U8.M12 103.03,101.86 v2(103.35,102.18) 103.9,102.73 U8.N13 v2(104.53,103.23) U8.P14 U8.R15 v2(106.53,105.23) U8.T16 v2(107.43,106.13) U8.U17 108.3,107 v2(108.49,107) 108.65,107.15 108.65,107.35 U8.V18 v2(109.46,108.16) ; U8.K12 103.49,100.19 v2(103.57,100.19) 103.82,100.44 103.82,100.52 U8.L13 104.03,100.83 v2(104.45,101.26) 104.93,101.73 U8.M14 U8.N15 106.59,103.29 v2(106.59,103.39) 106.93,103.73 U8.P16 107.38,104.08 v2(107.38,104.28) 107.83,104.73 U8.R17 U8.T18 ; U8.M10 101.03,102.02 v2(101.26,102.25) 101.74,102.73 U8.N11 U8.P12 103.48,104.18 v2(103.49,104.18) 103.49,104.19 U8.R13 v2(104.53,105.23) U8.T14 105.52,106.22 v2(105.59,106.22) 105.59,106.29 U8.U15 v2(106.6,107.3) U8.V16 107.36,108.06 v2(107.45,108.06) ; U8.P10 101.03,103.95 v2(101.28,104.2) 101.81,104.73 U8.R11 v2(102.58,105.28) U8.T12 U8.U13 v2(104.53,107.23) U8.V14
  vias: v1(107.63,116.32) v1(109.03,120.89) v1(109.03,120.26) v1(109.03,119.49) v1(109.03,118.86) v1(109.03,118.22) v1(109.03,117.59) v1(109.28,116.32) v1(111.06,116.32) v1(111.69,121.53) v1(112.46,121.53) v1(112.71,116.3) v1(113.15,121.53) v1(113.8,121.53) v1(114.11,119.54) v1(114.46,121.59) v1(114.76,121.01) v1(114.77,119.54) v1(115.07,123.76) v1(115.07,123.1) v1(115.07,122.46) v1(115.09,121.75) v1(115.4,120.88) v1(115.38,120.23) v2(112.06,111.6) v2(112.91,112.45) v2(113.75,113.21) v3(81.93,118.71) v3(81.93,117.82) v3(81.93,117.08) v3(81.93,116.34) v3(82.66,118.71) v3(82.66,117.82) v3(82.66,117.08) v3(82.66,116.34) v3(82.66,115.61) v3(83.42,118.71) v3(83.42,117.82) v3(83.42,117.08) v3(83.42,116.34) v3(83.42,115.61) v3(83.42,114.87) v3(83.42,114.13) v3(83.42,113.4) v3(83.39,112.6) v3(84.08,118.17) v3(84.09,111.9) v3(84.16,117.08) v3(84.16,116.34) v3(84.16,115.61) v3(84.16,114.87) v3(84.16,114.13) v3(84.16,113.4) v3(84.16,112.66) v3(84.74,117.8) v3(84.9,117.08) v3(84.9,116.34) v3(84.9,115.61) v3(84.9,114.87) v3(84.9,114.13) v3(84.9,113.4) v3(84.9,112.66) v3(84.9,111.92) v3(84.9,111.11) v3(85.63,117.08) v3(85.63,116.34) v3(85.63,115.61) v3(85.63,114.87) v3(85.63,114.13) v3(85.63,113.4) v3(85.63,112.66) v3(85.63,111.92) v3(85.66,111.16) v3(85.66,110.35) v3(86.37,116.34) v3(86.37,115.61) v3(86.37,114.87) v3(86.37,114.13) v3(86.37,113.4) v3(86.37,112.66) v3(86.37,111.92) v3(86.4,111.16) v3(86.4,110.43) v3(87.11,115.87) v3(89.35,114.07) v3(89.34,113.32) v3(89.33,112.57)
+VREF_CA_CPU: length 48.9
  TOP w0.508: R2195.1 54.15,55.72 53.78,56.09 C2250.1 54.12,56.92 54.57,56.48 56.53,56.48 56.68,56.63 v2(60.01,56.63) ; v4(76.92,73.55) 75.37,73.55 74.67,74.25 74.67,75.34 73.24,76.77 v1(73.24,77.25)
  BOTTOM w0.254: U2030.AY67 76.24,73.9 76.35,73.79 76.59,73.55 v4(76.92,73.55)
  BOTTOM w0.508: v2(60.01,56.63) 63.69,56.63 65.28,58.22 65.28,59.68 66.1,60.5 66.1,63.74 67.13,64.77 v1(67.13,68.6) 67.09,68.64 67.09,77.46 68.24,78.6 72.5,78.6 73.24,77.86 v1(73.24,77.25)
+VREF_CA_DIMM0: length 1.7
  BOTTOM w0.254: JDIM2000.164 51.67,53.46 51.76,53.54 v2(51.88,53.54)
+VREFDQ_SA_M3: length 18.1
  TOP w0.508: TP2022.1 69.3,82.38 71.61,80.07 76.72,80.07 77.48,79.31 77.48,76.29 76.36,75.17 v4(75.85,75.17)
  BOTTOM w0.254: v4(75.85,75.17) 75.85,74.59 U2030.AY68
+VREFDQ_SB_M3: length 17.6
  TOP w0.508: v4(75.28,74.5) 75.25,74.53 75.25,75.42 75.63,75.79 75.63,78.06 74.76,78.93 70.43,78.93 68.36,80.99 v1(66.37,80.99) C2103.1 65.31,81.08 65.31,82.46 R2136.1
  BOTTOM w0.305: U2030.BA67 75.4,74.38 v4(75.28,74.5)
A3_A5: length 5.1
  TOP w0.102: U37.83 198.18,22.98 197.97,22.77 197.24,22.77 v2(197.06,22.95)
  BOTTOM w0.102: v2(197.06,22.95) 197.17,22.85 197.17,22.19 197.42,21.93 198.03,21.93 198.08,21.99 R25505.1 R25506.2
AC_PRESENT_EC: length 186.3
  TOP w0.102: v2(67.19,41.08) 66.53,41.08 65.03,39.58 64.69,39.58 64.59,39.48 63.14,39.48 62.41,38.76 61.01,38.76 60.34,38.09 60.34,32.9 59.04,31.61 59.04,29.25 59.98,28.31 61.12,28.31 61.38,28.05 61.38,27.11 61.23,26.96 61.23,24.8 v2(61.58,24.45) ; U37.84 197.88,23.38 v2(197.68,23.18)
  IN2 w0.089: v2(61.58,24.45) 61.23,24.8 61.23,25.31 61.86,25.94 65.49,25.94 69.66,30.11 69.67,30.11 69.73,30.17 69.73,30.17 69.81,30.25 70.24,30.54 70.7,31 73.29,31 75.73,28.56 75.73,27.27 76.67,26.33 77.02,26.33 81.38,26.33 81.81,26.76 86.78,26.76 87.44,27.42 92.68,27.42 92.86,27.24 94.76,27.24 95.43,26.56 98.72,26.56 98.98,26.82 100.67,26.82 101.23,26.26 102.85,26.26 104.47,24.64 105.7,24.64 108.54,21.8 120.18,21.8 121.88,23.5 127.35,23.5 127.92,24.07 130.92,24.07 132.34,22.65 136.31,22.65 137.37,21.58 143.6,21.58 145.53,23.51 148.95,23.51 149.58,22.87 151.41,22.87 151.64,23.11 153.97,23.11 154.17,23.31 155.36,23.31 155.47,23.42 156.99,23.42 158.25,24.68 159.1,24.68 159.56,25.14 159.56,25.37 160.47,26.28 169.18,26.28 170.01,27.11 172.5,27.11 173.53,26.07 175.2,26.07 175.5,25.77 176.48,25.77 177.25,25.01 177.67,25.01 178.13,25.47 179.75,25.47 180.42,24.8 183.99,24.8 184.59,25.4 187.26,25.4 187.64,25.02 188.54,25.02 188.61,25.08 191.53,25.08 192.57,24.04 192.57,23.63 192.37,23.43 191.55,23.43 191.4,23.28 191.4,22.72 191.86,22.26 192.37,22.26 192.9,21.73 193.69,21.73 194.09,21.32 195.54,21.32 196.45,20.41 197.8,20.41 198.1,20.71 198.1,22.76 v2(197.68,23.18)
  BOTTOM w0.102: R2515.2 66.99,40.88 v2(67.19,41.08)
ACCEL_INT2: length 180.5
  TOP w0.102: R25483.2 212.81,10.07 204.12,10.07 203.71,9.66 195.84,9.66 v2(195,10.51) ; v1(49.85,20.56) 49.82,20.53 49.82,20.43 49.52,20.13 49.39,20.13 48.65,19.39 48.65,18.04 D21.1
  IN2 w0.089: v2(195,10.51) 194.53,10.04 188.07,10.04 187.61,10.5 187.61,10.87 187.02,11.47 187.02,11.98 186.51,12.49 185.44,12.49 184.97,12.03 183.83,12.03 182.52,13.33 181.73,13.33 180.92,14.14 153.53,14.14 150.76,16.91 147.31,16.91 147.05,16.64 147.05,15.91 145.6,14.46 120.08,14.46 118.88,15.66 112.14,15.66 111.32,14.84 102,14.84 99.3,17.54 99.3,17.54 98.52,18.32 98.52,18.99 97.57,19.94 96.44,19.94 95.15,21.23 92.7,21.23 92.16,21.77 90.04,21.77 89.32,22.49 83.42,22.49 80.02,19.09 53.43,19.09 51.98,20.53 49.87,20.53 v1(49.85,20.56)
ACCEL_INT2_R: length 8.1
  TOP w0.102: U32.9 55.58,17.07 55.33,16.83 55.33,15.3 55.21,15.18 55.21,14.79 54.9,14.49 54.39,14.49 54.09,14.79 54.09,15.61 53.55,16.14 v1(52.87,16.14) 52.85,16.14 D21.2
ACCEL_INTA: length 67.2
  TOP w0.102: D20.1 49.52,15.3 48.73,16.09 C6606.2 48.57,17.06 48.4,17.23 48.4,19.65 49.21,20.46 v1(49.21,20.56) ; v1(85.93,35.13) 85.93,34.32 87.12,33.13 R25474.2 87.12,32.08 88.12,31.08 88.12,27.7 87.23,26.81 87.23,25.74 88.22,24.75 88.81,24.75 90.58,22.98 90.58,22.83 v1(90.97,22.44)
  IN2 w0.089: v1(49.21,20.56) 49.21,20.59 49.61,20.99 51.8,20.99 53.5,19.29 79.95,19.29 83.35,22.69 90.71,22.69 v1(90.97,22.44)
  BOTTOM w0.102: U2030.AB1 85.91,35.15 v1(85.93,35.13)
ACCEL_INTA_R: length 8.6
  TOP w0.102: U32.11 56.58,14.28 56.38,14.08 55.43,14.08 55.26,14.26 53.9,14.26 53.82,14.35 v1(52.82,14.35) 52.63,14.35 52.29,14.69 D20.2
ACIN: length 98.4
  TOP w0.102: U37.72 198.09,18.58 197.66,18.15 v1(197.64,18.15)
  TOP w0.203: v1(132.26,32.02) 132.26,31.44 PR39.2 131.55,31.93 131.55,33.27 132.08,33.81 PR30.1 135.35,33.81 135.76,33.39 PR40.1
  IN2 w0.089: v1(132.26,32.02) 135.31,32.02 136.14,31.18 136.14,28.5 135.86,28.21 135.86,27.6 136.64,26.81 137.56,26.81 139.01,28.25 140.09,28.25 140.64,28.8 144.08,28.8 146.4,31.12 154.06,31.12 155.44,32.5 164.73,32.5 165.38,31.84 169.84,31.84 170.54,31.15 172.39,31.15 173,30.54 176.5,30.54 177.95,31.99 180.68,31.99 181.28,31.39 181.4,31.39 181.4,31.39 183.35,31.39 184.44,30.29 190.84,30.29 192.77,28.37 192.77,26.85 193.97,25.64 194.92,25.64 195.21,25.92 196.44,25.92 196.91,25.45 197.47,25.45 197.86,25.06 197.86,23.96 198.48,23.34 198.48,20.2 199.42,19.26 200.19,19.26 200.44,19.01 200.44,18.7 200.17,18.44 199.24,18.44 198.89,18.09 197.7,18.09 v1(197.64,18.15)
ACZ_SPKR: length 152.5
  IN2 w0.089: v1(75.4,31.02) 75.4,29.73 76.31,28.82 76.31,27.37 76.92,26.76 81.27,26.76 81.67,27.16 86.62,27.16 87.29,27.82 92.82,27.82 93.02,27.62 95.77,27.62 96.06,27.91 96.06,28.62 96.46,29.02 98.96,29.02 99.17,28.82 99.17,28.6 99.45,28.33 99.53,28.33 99.81,28.05 99.81,27.49 100.02,27.29 100.74,27.29 101.38,26.65 103,26.65 104.63,25.02 105.86,25.02 108.7,22.18 113.75,22.18 115.45,23.89 127.2,23.89 127.76,24.45 131.08,24.45 132.49,23.03 144.5,23.03 145.35,23.89 149.1,23.89 149.71,23.28 151.28,23.28 151.48,23.49 153.81,23.49 154.01,23.69 155.21,23.69 155.31,23.8 156.83,23.8 157.59,24.56 157.59,25.77 158.16,26.34 160,26.34 160.34,26.68 165.41,26.68 166.65,27.91 169.84,27.91 170.27,27.49 172.65,27.49 173.18,26.96 174.7,26.96 175.46,26.19 180.08,26.19 180.23,26.34 184.54,26.34 184.92,25.96 187.04,25.96 v2(187.43,26.35)
  BOTTOM w0.102: U2030.AW5 76.9,37.97 76.28,37.97 76.15,38.1 75.78,38.1 75.6,37.92 74.78,37.92 74.42,37.56 74.42,37.24 74.18,36.99 74.18,35.44 74.74,34.89 74.74,34.88 75.09,34.52 75.24,34.52 75.53,34.24 75.53,34.23 75.6,34.16 75.6,32.32 76.11,31.81 R2541.1 75.77,31.58 75.67,31.68 R2555.2 75.34,31.08 v1(75.4,31.02) ; D11.2 192.26,33.22 191.6,33.88 191.6,34.28 191.35,34.53 190.89,34.53 190.6,34.24 190.28,34.24 190.08,34.04 190.08,33.5 190.14,33.44 190.14,33.1 189.89,32.85 189.52,32.85 189.29,33.08 188.15,33.08 187.6,32.54 187.6,32.38 187.59,32.36 187.57,32.31 187.21,31.95 187.21,26.57 v2(187.43,26.35)
ADOGND: length 14.6
  TOP w0.381: v1(214.66,47.56) C593.1
  BOTTOM w0.203: U20.38 208.3,34.43 208.45,34.58 v2(208.7,34.58) ; U20.25 202.46,36.09 202.12,36.44 201.52,36.44 v1(201.14,36.05)
  BOTTOM w0.254: v1(214.5,44.88) 214.39,44.99 214.39,45.73 214.22,45.9 CN35.5
  BOTTOM w0.305: v1(212.25,47.94) 212.29,47.9 CN35.1 ; v1(214.62,42.56) 214.46,42.4 CN35.12 ; CN35.3 212.69,46.9 v1(212.33,47.26)
  BOTTOM w0.381: C845.2 210.03,35.81 v1(209.46,35.24) ; v1(200.21,38.09) 199.83,37.71 C568.2 ; v1(200.89,38.48) 200.89,37.93 C569.2 ; C573.2 198.58,32.06 v1(198.51,31.99) ; C599.2 197.9,36.59 v1(197.5,36.18) 197.23,35.91 C598.1 ; C572.1 v1(210.12,38.34)
  vias: v1(201.41,38.85) v1(202.35,39.51) v1(212.25,48.6) v1(214.69,41.77) v1(215.33,42.53) v1(215.4,41.85)
ADP_ID: length 197.3
  TOP w0.254: PQ17.2 141.12,34.24 140.45,34.91 140.02,34.91 139.42,35.51 PR230.1 136.84,35.51 PR235.2 135.82,36.54 132.58,36.54 132.25,36.2 131.07,36.2 129.81,34.94 v1(129.37,34.94)
  IN1 w0.254: v1(121.91,51.46) 121.91,51.6 121.28,52.23 121.28,57.05 121.91,57.68 121.91,58.89 120.85,59.95 120.85,62.43 118.49,64.78 115.79,64.78 113.5,67.07 107.51,67.07 v1(107.43,66.99)
  IN2 w0.254: v1(121.91,51.46) 121.91,50.95 123.78,49.08 123.78,44.7 125.09,43.39 125.09,41.48 126.4,40.17 126.4,37.68 127.03,37.05 127.03,35.37 127.46,34.94 v1(129.37,34.94) ; v1(60.39,110.73) 60.44,110.73 61.49,109.68 65.19,109.68 72.1,102.77 74.1,102.77 78.26,98.62 84.82,98.62 85.04,98.4 86.12,98.4 86.6,98.89 88.12,98.89 88.65,98.36 89.37,98.36 90.35,97.38 90.35,93.7 89.84,93.19 89.84,92.25 90.18,91.9 90.42,91.9 91.73,90.59 93.61,90.59 95.96,88.23 96.61,88.23 98.38,86.47 98.38,85.48 98.96,84.9 99.53,84.9 102.8,81.63 102.8,79.4 102.73,79.32 102.73,77 103.1,76.62 103.1,69.61 104.53,68.18 104.93,68.18 106.09,67.02 107.4,67.02 v1(107.43,66.99)
  IN3 w0.254: v1(42.16,117.01) 41.54,117.64 38.68,117.64 35.6,114.57 25.72,114.57 24.98,113.83 21.09,113.83 20.64,114.29 17.44,114.29 17.13,114.59 11.62,114.59 11.48,114.45 PJ2.3
  BOTTOM w0.254: v1(42.16,117.01) 42.16,115.62 43.01,114.77 47.25,114.77 48.07,113.96 48.07,111.92 48.65,111.34 52.29,111.34 52.92,110.7 54.62,110.7 55.33,111.42 57.72,111.42 57.92,111.62 59.75,111.62 60.26,111.11 60.26,110.95 60.39,110.81 v1(60.39,110.73)
ALERT: length 17.8
  TOP w0.102: v2(99.62,97.52) 99.27,97.17 99.27,93.94 99.1,93.76 99.1,92.68 98.43,92.02 94.94,92.02 93.89,93.07 91.32,93.07 90.81,93.59 89.19,93.59 88.46,94.31 R397.1
  BOTTOM w0.102: U8.F8 v2(99.62,97.52)
AMP_MUTE#: length 22.9
  TOP w0.102: U37.108 192.85,30.55 193.1,30.8 193.1,31.51 192.97,31.63 192.97,33.31 193.64,33.97 194.28,33.97 194.64,34.34 196.09,34.34 197.55,32.88 197.55,31.74 198.13,31.15 v1(198.13,29.63) 198.48,29.27 199.07,29.27 199.31,29.51 200.06,29.51 200.57,29.01 200.57,28.33 200.77,28.12 200.77,27.88 201.11,27.54 201.53,27.54 201.73,27.34 201.73,27.09 202.27,26.55 202.27,25.79 203.13,24.93 203.13,24.57 203.87,23.84 203.87,23.77 D13.1
AP_EQ: length 5.6
  BOTTOM w0.102: R25273.1 17.12,18.6 16.5,18.6 16.32,18.78 16.32,19.54 16.58,19.81 R25279.2 16.85,20.54 v1(16.93,20.62) 17.45,20.62 17.63,20.43 17.84,20.43 17.9,20.49 U6502.9
BAT-V: length 56.2
  TOP w0.254: PD9002.2 130.86,34.64 129.67,33.45 129.67,31.91 129.69,31.89 v2(129.69,31.86)
  IN3 w0.254: v2(129.69,31.86) 128.59,31.86 125.54,34.91 121.85,34.91 118.81,31.86 115.25,31.86 113.98,30.59 113.98,29.58 111.95,27.55 109.54,27.55 108.93,26.94 108.49,26.94 108.23,26.67 107.9,26.67 107.35,26.12 107.35,25.66 v1(107.91,25.1)
  IN3 w0.381: v1(107.91,25.1) 107.91,23.63 105.11,20.84 104.11,20.84 103.19,19.91 v1(101.42,19.91)
  BOTTOM w0.152: PR209.2 112.45,28.24 112.61,28.08 112.61,26.43 112.61,26.43 112.61,26.37 113.36,25.62 120.92,25.62 PR208.2
BATLED0#: length 70
  TOP w0.102: v2(184.44,16.34) 184.1,16.69 184.1,16.81 183.93,16.98 U37.29
  IN2 w0.089: v2(184.44,16.34) 184.49,16.34 185.63,15.21 192.43,15.21 194.4,13.25 196.63,13.25 197.58,12.29 197.79,12.29 199.17,10.91 202.39,10.91 203.05,11.57 204.46,11.57 v2(204.86,11.17)
  IN3 w0.089: v2(204.86,11.17) 205.29,10.74 205.9,10.74 206.1,10.94 207.67,10.94 208.35,10.26 215.61,10.26 217.13,11.78 217.13,16.69 216.35,17.47 214.57,17.47 212.69,19.36 212.69,24.04 212.89,24.24 212.89,24.55 215.21,26.87 215.21,27.27 216.15,28.21 216.15,32.69 213.32,35.53 v1(212.35,35.53)
  BOTTOM w0.102: CN35.24 212.84,36.4 212.63,36.19 212.63,35.81 v1(212.35,35.53)
BATLED1#: length 74.9
  TOP w0.102: U37.25 183.92,18.58 184.11,18.39 184.11,18.03 185,17.14 v2(185,17.12)
  IN2 w0.089: v2(185,17.12) 185.16,17.12 186.5,15.78 192.67,15.78 194.63,13.82 196.86,13.82 197.82,12.87 198.02,12.87 199.41,11.48 202.16,11.48 202.82,12.14 204,12.14 204.57,12.71 205.11,12.71 205.17,12.77 205.47,12.77 205.69,12.55 205.69,12.02 v2(205.47,11.8)
  IN3 w0.089: v2(205.47,11.8) 205.26,11.58 204.68,11.58 204.41,11.31 204.41,10.82 205.16,10.07 215.69,10.07 217.32,11.7 217.32,16.77 216.43,17.66 215.64,17.66 212.88,20.42 212.88,23.96 213.08,24.16 213.08,24.47 215.4,26.79 215.4,27.2 216.34,28.13 216.34,32.77 212.96,36.15 v1(212.15,36.15)
  BOTTOM w0.102: v1(212.15,36.15) 212.15,36.15 212.54,36.54 212.54,36.66 212.78,36.9 CN35.23
BI: length 203.9
  TOP w0.102: v1(112.83,23.39) 112.1,22.67 112.1,16.27 109.92,14.08 99.88,14.08 v1(99.66,14.31)
  IN1 w0.089: v1(20.1,57.82) 20.1,57.44 18.65,55.98 18.65,55.31 17.13,53.79 17.13,52.9 16.71,52.48 16.71,52.06 17.42,51.35 17.42,50.27 16.96,49.82 16.96,45.68 19.62,43.02 20.96,43.02 21.21,42.77 21.21,42.77 21.8,42.18 21.8,38.45 21.98,38.27 21.98,36.89 21.75,36.66 21.75,35.68 22.72,34.71 22.72,33.41 25.28,30.85 25.28,26.54 25.01,26.27 25.01,22.53 23.45,20.97 23.45,19.13 25.72,16.86 25.72,14.41 22.77,11.47 20,11.47 19.54,11.01 19.54,7.95 20.28,7.21 v1(20.28,6.49)
  IN2 w0.089: v1(99.66,14.31) 99.63,14.31 99.17,14.77 93.62,14.77 93.46,14.93 93.46,15.05 88.25,20.26 84.2,20.26 78.49,14.55 52.74,14.55 52.37,14.91 49.05,14.91 44.29,10.15 41.48,10.15 37.73,6.4 23.21,6.4 22.57,5.75 21.02,5.75 v1(20.28,6.49) ; v1(112.83,23.39) 112.41,23.81 109.74,23.81 v1(109.46,23.53)
  BOTTOM w0.102: SW2.2 SW2.1 22.58,58.1 R25321.2 22.58,57.48 22.41,57.31 21.48,57.31 20.97,57.82 v1(20.1,57.82) ; PR10.1 109.19,23.26 v1(109.46,23.53)
  BOTTOM w0.127: PR10.1 109.19,22.51 109.06,22.37 106.61,22.37 106.05,21.81 106.05,17.65 105.2,16.8 103.4,16.8 102.69,17.51 102.69,20.12 102.37,20.44 101.22,20.44 100.8,20.86 99.57,20.86 99.45,20.99 PJ1.6
BL#: length 2.7
  TOP w0.102: Q6521.3 55.81,108.89 R25368.1 55.57,109.39 55.71,109.54 Q6521.2
BL_ON: length 13.2
  TOP w0.102: Q6521.6 57.62,110.19 57.42,110.39 v1(57.42,110.73) 56.96,110.73 56.84,110.85 D3.2 56.84,112.1 56.7,112.24 R25367.1 56.7,113.08 56.91,113.3 57.74,113.3 58.34,112.7 59.69,112.7 59.97,112.42 59.97,111.91 60.13,111.75 Q6522.3
  IN1 w0.089: v1(57.42,110.73) 57.42,109.39 56.35,108.32 v1(56.35,107.96)
  BOTTOM w0.102: CN29.26 v1(56.35,107.96)
BOARD_ID0: length 30.7
  IN1 w0.089: v4(85.69,41.3) 85.12,41.88 85.09,41.91 85.09,41.98 84.77,42.29 84.39,42.29 83.81,41.72 83.81,41.37
  IN1 w0.102: 83.81,41.37 83.81,36.21 83.86,36.16 84.59,35.43 84.59,31.81 85,31.41 85.66,31.41 86.32,32.06 87.34,32.06 88.03,32.75 93.81,32.75 94.15,32.41 v1(94.37,32.41)
  BOTTOM w0.102: R2601.1 93.64,26.68 94.05,27.1 R2582.2 94.05,28.16 94.22,28.33 94.22,29.68 94.78,30.24 94.78,32.01 v1(94.37,32.41) ; v4(85.69,41.3) 86.06,41.67 U2030.AB11
BOARD_ID1: length 31.5
  IN1 w0.102: v1(93.97,33.43) 93.78,33.62 88.61,33.62 87.26,32.27 86.22,32.27 85.56,31.61 85.1,31.61 84.8,31.91 84.8,35.55 84.04,36.3 84.04,41.4 v4(84.55,41.91)
  BOTTOM w0.102: R2600.1 95.37,26.66 v1(95.27,26.76) 95.27,27.39 R2581.2 94.55,28.12 94.55,29.72 94.98,30.16 94.98,32.41 v1(93.97,33.43) ; v4(84.55,41.91) 84.55,42.25 84.96,42.66 85.64,42.66 85.94,42.97 U2030.AB13
