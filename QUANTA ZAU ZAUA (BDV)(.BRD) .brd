# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SUSCLK_32K: length 185.2
  IN1 w0.089: v2(193.2,22.21) 193.72,21.69 195,21.69 195.55,21.14 195.55,20.78 196.2,20.13 196.2,19.25 196.82,18.63 197.92,18.63 199.19,17.35 199.19,14.41 198.46,13.68 196.73,13.68 196.66,13.75 190.7,13.75 189.69,14.76 186.51,14.76 185.51,15.76 183.58,15.76 182.1,17.24 180.61,17.24 180.49,17.36 174.43,17.36 173.09,16.02 151.69,16.02 150.85,16.86 146.94,16.86 146.09,16.02 127.44,16.02 126.76,16.7 119.58,16.7 118.88,17.4 109.59,17.4 109.16,17.83 96.86,17.83 95.89,18.8 93.29,18.8 89.73,22.36 89.17,22.92 83.22,22.92 81.77,21.47 70.67,21.47 66.3,25.85 66.3,27.58 64.81,29.07 63.38,29.07 63.08,29.37 63.08,29.83 63.36,30.11 63.43,30.11 v1(63.61,30.29)
  BOTTOM w0.102: R670.2 193.7,21.92 193.41,22.21 v2(193.2,22.21) ; U2030.BA17 75.19,45.43 74.91,45.15 73.12,45.15 72.87,44.89 70.62,44.89 68.19,42.45 67.17,42.45 66.69,41.97 65.59,41.97 65.31,41.69 65.31,40.52 64.7,39.91 64.17,39.91 63.13,38.87 63.13,32.98 63.61,32.5 v1(63.61,30.29)
SUSCLK_32KHZ: length 4.3
  BOTTOM w0.102: CN17.50 191.55,18.88 191.73,19.06 191.73,20.81 192.13,21.22 192.52,21.22 192.87,21.58 R670.1
SUSD: length 15.9
  TOP w0.102: PQ11.2 122.59,63.19 122.59,58.45 v1(123.14,57.9) 123.86,57.18 PC152.1 125.06,57.39 PR191.2 124.88,56.21 124.88,54.29 123.46,52.87 PQ25.3
SUSLED#: length 75.9
  TOP w0.102: U37.28 184.16,17.38 v2(184.42,17.12)
  IN2 w0.089: v2(205.32,12.4) 205.28,12.36 204.49,12.36 204.08,11.95 202.9,11.95 202.23,11.29 199.33,11.29 197.94,12.68 197.74,12.68 196.79,13.63 194.56,13.63 192.59,15.59 186.21,15.59 185.5,16.3 185.5,16.51 185.27,16.74 184.8,16.74 v2(184.42,17.12)
  IN3 w0.089: v2(205.32,12.4) 205.28,12.36 204.6,12.36 204.03,11.79 204.03,10.66 205,9.69 215.85,9.69 217.7,11.54 217.7,16.93 216.59,18.04 215.79,18.04 213.26,20.58 213.26,23.8 213.46,24.01 213.46,24.31 215.78,26.64 215.78,27.04 216.72,27.98 216.72,32.93 212.22,37.43 v1(212.1,37.43)
  BOTTOM w0.102: CN35.21 212.8,37.9 212.34,37.43 212.11,37.43 v1(212.1,37.43)
SUSON: length 383.2
  TOP w0.102: R25320.1 183.5,32.7 184.05,32.7 184.63,33.29 186.81,33.29 187.39,32.71 187.39,32.39 187.3,32.31 187.3,31.38 188.05,30.64 U37.120 188.05,28.89 188.38,28.56 188.38,28.36 188.86,27.88 189.39,27.88 189.85,27.42 189.85,25.39 v2(190.77,24.47) ; v1(104.2,22.49) 104.3,22.59 104.3,23.02 105.55,24.27 106.64,24.27 106.87,24.5 106.87,25.5 107.7,26.33 108.06,26.33 108.52,25.87 109.15,25.87 110.63,27.34 110.63,29.5 110.91,29.78 110.91,31.39 111.86,32.35 116.13,32.35 120.15,36.36 121.12,36.36 121.58,36.82 121.58,37.53 121.29,37.81 120.79,37.81 119.29,36.31 118.43,36.31 118.07,36.66 118.07,38.59 118.71,39.23 119.75,39.23 119.89,39.1 121.37,39.1 121.37,39.1 122.69,39.1 122.79,39.2 122.79,45.28 123.35,45.83 123.35,48.63 PR9258.2
  TOP w0.254: PR266.2 65.11,125.36 65.04,125.44 v1(65.04,125.59)
  IN1 w0.089: v1(23.17,102.97) 23.43,103.24 25.2,103.24 25.97,104.01 38.64,104.01 40.29,105.66 41.01,105.66 43.06,107.71 45.55,107.71 46.23,107.03 48.13,107.03 49.71,108.62 49.71,109.91 50.58,110.78 54.24,110.78 55.1,111.64 55.41,111.64 55.7,111.93 58.66,111.93 58.97,111.63 62.87,111.63 63.73,112.48 65.04,112.48 68.76,116.2 70.15,116.2 70.87,116.93 70.87,119.24 70.06,120.05 69.42,120.05 65.04,124.43 v1(65.04,125.59)
  IN2 w0.089: v1(35.67,26) 35.88,25.79 48.5,25.79 49.9,24.4 52.49,24.4 54.44,22.44 62.29,22.44 63.99,24.14 64.43,24.14 64.43,24.14 74.11,24.14 75.47,25.51 81.65,25.51 82.13,26 90.67,26 91.28,26.61 92.41,26.61 92.55,26.48 93.49,26.48 94.2,25.77 98.81,25.77 100.52,24.06 102.57,24.06 104.13,22.49 v1(104.2,22.49) 104.2,22.19 106.16,20.22 119.18,20.22 120.04,19.36 124.6,19.36 125.05,18.92 142.14,18.92 146.16,22.93 148.71,22.93 149.36,22.29 151.63,22.29 151.88,22.53 153.7,22.53 154.17,22.06 154.93,22.06 155.71,22.85 157.23,22.85 158.49,24.11 159.34,24.11 160.13,24.9 160.13,25.13 160.69,25.68 169.4,25.68 170.25,26.54 172.26,26.54 172.59,26.21 172.59,25.67 173.64,24.62 177.82,24.62 178.04,24.41 184.14,24.41 184.72,24.99 187.13,24.99 187.48,24.64 190.6,24.64 v2(190.77,24.47)
  BOTTOM w0.102: v1(35.67,26) 35.67,26.53 31.41,30.8 31.41,33.18 30.52,34.07 30.52,38.54 29.93,39.12 29.93,42 30.54,42.61 30.54,50.22 29.14,51.61 29.14,55.11 29.6,55.57 29.6,57.3 29.91,57.6 29.91,71.43 30.37,71.89 30.64,71.89 31.33,72.58 31.33,73.52 30.9,73.95 30.9,75.09 30.44,75.55 30.44,76.31 30.54,76.41 30.54,80.81 29.91,81.44 29.91,82.66 29.2,83.37 29.2,91.57 24.17,96.6 24.17,98.06 23.53,98.69 23.53,101.12 23.14,101.51 23.14,102.07 23.17,102.09 v1(23.17,102.97)
SYS_HWPG: length 219.9
  TOP w0.102: D60.1 170.77,32.15 v1(170.88,32.26) ; v2(186.05,31.28) 186.05,31.01 186.45,30.62 U37.124
  IN2 w0.089: v2(186.19,10.55) 184.92,10.55 184.64,10.83 184.21,10.83 182.28,12.76 181.49,12.76 180.69,13.57 119.16,13.57 118.03,14.71 115.41,14.71 114.78,14.08 100.46,14.08 99.55,14.99 93.85,14.99 88.38,20.46 84.14,20.46 78.43,14.75 64.47,14.75 63.5,15.72 48.89,15.72 48.86,15.76 48.5,15.76 48.46,15.72 48.43,15.72 v1(48.04,15.33) ; v2(186.05,31.28) 185.43,31.28 183.95,32.76 176.45,32.76 176.16,32.47 174.13,32.47 173.56,31.91 171.23,31.91 v1(170.88,32.26) 170.53,32.61 165.7,32.61 165.04,33.26 161.16,33.26 159.07,35.35 155.85,35.35 155.66,35.16 149.29,35.16 149.23,35.22 147.43,35.22 145.4,37.25 145.4,38.21 145.1,38.52 v1(144.26,38.52)
  BOTTOM w0.102: v2(186.19,10.55) 186.19,11.01 186.24,11.06 186.24,12.08 185.58,12.74 185.58,20.81 184.82,21.58 184.82,22.31 185.01,22.5 185.01,22.86 185.81,23.66 186.88,23.66 187.31,24.09 187.31,24.65 186.75,25.21 186.75,30.58 v2(186.05,31.28) ; v1(48.04,15.33) 48.04,15.56 48.19,15.72 PR6022.2
  BOTTOM w0.203: v1(144.26,38.52) 144.26,38.9 144.1,39.06 PR6004.2
SYS_PEX_RST: length 3
  TOP w0.102: v1(103.82,125.92) 103.77,125.87 R25521.2
  BOTTOM w0.102: v1(103.82,125.92) 103.43,125.53 R25517.2 103.42,125.35 U6504.4
SYS_PEX_RST_MON#: length 47.6
  TOP w0.102: v1(106.82,125.94) 115.52,125.94 U6505.1
  IN1 w0.089: v1(106.82,125.94) 106.76,125.89 106.76,122.47 106.63,122.34 106.63,122.02 106.39,121.77 106.39,120.34 106.67,120.06 106.67,116.85 105.88,116.06 105.88,112.8 105.81,112.73 105.81,112.16 105.6,111.95 105.6,110.17 105.01,109.59 105.01,108.85 104.71,108.55 102.32,108.55 102.02,108.24 102.02,102.46 101.94,102.38 101.94,98.76 100.85,97.67 100.85,96.29 v2(101.31,95.83)
  BOTTOM w0.102: v1(106.82,125.94) 106.82,125.75 R25511.2 R25564.1 105.35,125.44 104.31,125.44 R25517.1 ; U8.E9 v2(101.31,95.83)
SYS_PWROK_R: length 8.6
  BOTTOM w0.102: R2511.2 R2524.1 102.5,36.03 102.27,35.8 100.95,35.8 100.2,36.55 100.2,36.92 98.19,38.93 96.79,38.93 U2030.B6
SYS_RESET#: length 9.5
  BOTTOM w0.102: U2030.B5 97,38.23 97.18,38.23 97.63,38.68 97.95,38.68 98.19,38.44 98.19,38.01 97.7,37.53 97.7,36.51 97.24,36.05 97.24,35.13 98.4,33.97 99.16,33.97 99.4,33.73 99.4,32.92 99.55,32.77 R2533.1
SYS_SHDN#: length 306.5
  TOP w0.102: v1(203.66,12.54) 203.66,12.55 203.66,18.15 204.44,18.93 204.44,19.83 203.39,20.88 203.39,23.74 203.16,23.97 202.24,23.97 201.86,23.6 201.86,23.23 201.69,23.05 201.2,23.05 200.75,23.51 199.91,23.51 199.64,23.78 U37.85 ; PR6009.1 142.89,33.45 PR6002.2 143.23,33.1 143.6,32.73 v1(143.6,32.57)
  IN1 w0.089: v1(110.96,42.54) 112.05,42.54 113.12,41.46 114.62,41.46 115.89,40.19 119.72,40.19 120.79,39.13 120.79,37.67 v1(121.08,37.38) 121.32,37.38 122.34,38.39 123.3,38.39 123.57,38.12 123.57,35.95 125.23,34.28 130.89,34.28 131.51,34.91 133.33,34.91 133.88,34.35 137.86,34.35 140.91,31.3 142.77,31.3 143.6,32.13 v1(143.6,32.57) ; v1(45.76,24.17) 45.76,24.37 46.64,25.26 48.45,25.26 50.48,23.23 50.48,17.13 48.86,15.51 48.84,15.51 v1(48.68,15.35)
  IN2 w0.089: v1(203.66,12.54) 203.66,12.54 202.65,12.54 201.99,11.87 200.37,11.87 199.21,13.03 199.21,15.33 197.51,17.04 196.63,17.04 195.16,18.5 193.41,18.5 188.93,22.98 184.7,22.98 184.52,23.17 176.53,23.17 176.03,22.66 174.75,22.66 174.21,23.2 173.87,23.2 173.66,22.99 169.65,22.99 169.23,23.41 167.81,23.41 167.2,22.8 164.19,22.8 163.25,21.86 162.62,21.86 162.49,21.73 158.86,21.73 158.22,21.1 156.47,21.1 155.71,20.34 154.15,20.34 153.86,20.05 147.2,20.05 144.82,17.66 144.82,16.45 144.49,16.12 139.04,16.12 138.26,16.9 131.94,16.9 131.67,17.18 124.1,17.18 123.64,17.63 119.26,17.63 118.4,18.5 101.74,18.5 100.57,19.67 100.57,20.34 v1(100.62,20.38) 100.57,20.43 100.57,21.13 99.96,21.75 98.2,21.75 97.05,22.9 95.7,22.9 94.52,24.08 93.68,24.08 93.66,24.09 93.66,24.09 93.46,24.29 91.52,24.29 91.43,24.38 82.69,24.38 81.28,22.97 77.89,22.97 77.2,23.66 v1(76.69,23.66) 75.5,22.47 66.28,22.47 64.58,20.76 53.88,20.76 52.17,22.48 49.28,22.48 48.36,23.4 46.52,23.4 v1(45.76,24.17)
  IN3 w0.089: v1(110.96,42.54) 110.84,42.66 110.84,48.8 108.44,51.2 108.44,54.29 111.14,56.99 111.14,60.75 v1(111.49,61.1) ; v1(100.62,20.38) 100.88,20.64 103.04,20.64 103.77,21.38 104.51,21.38 105.17,22.04 105.17,23.87 106.61,25.32 106.61,26.15 107.07,26.61 107.07,27.82 107.6,28.35 108.19,28.35 113.3,33.46 116.89,33.46 120.8,37.38 v1(121.08,37.38)
  BOTTOM w0.102: v1(48.68,15.35) 48.68,15.52 48.93,15.77 PR6020.2 ; Q2025.3 111.52,61.12 v1(111.49,61.1) ; v1(76.69,23.66) 77.15,24.12 PR3022.2
TEMP_MBAT#: length 126.2
  TOP w0.102: v1(147.05,28.26) 146.91,28.12 146.91,27.13 147.19,26.85 147.19,25.58 147.74,25.03 147.74,21.78 v1(147.97,21.55) ; U37.73 197.57,18.98 v2(196.57,19.98) ; PR18.1 100.57,21.7 PR14.2 100.61,21.73 v1(100.61,22.49)
  TOP w0.203: v1(138.75,28.76) 138.31,28.33 PR8.1
  IN2 w0.089: v1(100.61,22.49) 100.63,22.49 103.85,19.27 118.78,19.27 119.64,18.41 124.16,18.41 124.6,17.96 142.54,17.96 146.12,21.55 v1(147.97,21.55) 148.69,20.83 153.54,20.83 153.83,21.11 155.39,21.11 156.15,21.87 157.63,21.87 158.91,23.15 160.9,23.15 161.73,23.99 164.03,23.99 164.26,24.22 170.54,24.22 170.72,24.05 177.59,24.05 177.8,23.84 184.67,23.84 184.94,23.56 189.17,23.56 193.65,19.09 195.68,19.09 v2(196.57,19.98)
  IN3 w0.089: v1(147.05,28.26) 146.24,29.07 143.18,29.07 142.16,30.09 139.41,30.09 139.18,29.85 139.18,29.49 138.75,29.06 v1(138.75,28.76)
TESTMODE: length 7.3
  BOTTOM w0.102: R311.1 102.8,116.69 102.8,114.57 102.17,113.93 102.17,112.64 101.94,112.41 101.29,112.41 U8.AD9
THERM+: length 1.5
  TOP w0.102: TP68.1 102.95,96.68 v2(102.95,96.71)
  BOTTOM w0.102: v2(102.95,96.71) 103.31,97.07 U8.F12
THERM-: length 21.2
  TOP w0.102: TP69.1 113.85,82.41 113.85,82.89 113.73,83.02 113.73,86.82 113.16,87.39 111.1,87.39 108.52,89.97 107.81,89.97 107.39,90.39 105.52,90.39 104.61,91.3 104.61,92.49 104.24,92.86 104.24,93.7 103.82,94.12 v2(103.82,95.01)
  BOTTOM w0.102: v2(103.82,95.01) 103.82,95.8 U8.E12
THRMTRIP#: length 20.2
  IN3 w0.089: v1(108.39,64.63) 108.39,66.85 106.77,68.47 106.45,68.47 104.16,70.76 104.16,72.38 v1(104.54,72.76)
  BOTTOM w0.102: R2478.1 v1(104.54,72.76) R2475.1 ; v1(108.39,64.63) 108.27,64.5 108.27,63.74 110.36,61.64 112.98,61.64 Q2025.1
TP_I2C_CLK: length 15.2
  TOP w0.102: R558.1 94.96,29.53 95.51,30.09 R25415.2 95.01,31.1 95.01,32.42 94.58,32.85 93.92,32.85 93.8,32.74 93.28,32.74 v1(93.05,32.96) 92.53,33.48 91.99,33.48 90.78,34.69 89.91,34.69 89.73,34.87 88.89,34.87 87.84,35.92 87.84,37.82 v4(87.79,37.88)
  BOTTOM w0.102: v4(87.79,37.88) U2030.U6
TP_I2C_DATA: length 13.6
  TOP w0.102: R560.1 v1(93.67,30.58) 93.67,30.99 93.46,31.2 93.11,31.2 92.87,31.44 92.87,31.61 91.96,32.52 R25413.2 91.88,33.18 90.56,34.51 89.77,34.51 89.59,34.69 88.82,34.69 88.8,34.71 88.78,34.71 87.51,35.98 87.51,37.52 87.39,37.65 87.39,38.04 87.76,38.41 v4(87.76,38.5)
  BOTTOM w0.102: U2030.U7 v4(87.76,38.5)
TP_INTH#_L: length 8
  TOP w0.102: v1(70.4,20.13) 70.4,19.73 R25472.1 70.28,19.4 70.65,19.04 70.65,18.46 R25471.2 67.26,17.67 66.6,18.34 Q29.1
  BOTTOM w0.102: CN33.7 70.32,20.2 v1(70.4,20.13)
TP_SMB_CLK: length 37
  TOP w0.102: R559.1 C699.1 71.18,18.66 71.81,19.28 v1(71.81,20.13) ; v1(94.75,22.99) 94.64,23.1 94.01,23.1 93.36,23.74 93.36,23.75 92.62,24.5 92.62,25.95 92.52,26.05 Q27.3
  IN3 w0.089: v1(92.58,20.17) 94.75,22.33 v1(94.75,22.99)
  BOTTOM w0.102: v1(71.81,20.13) 71.32,20.62 CN33.6 71.32,21.97 71.61,22.26 77.05,22.26 77.79,21.53 82.04,21.53 83.21,22.69 89.2,22.69 89.93,21.96 91.66,21.96 92.58,21.04 v1(92.58,20.17)
TP_SMB_DATA: length 34.8
  TOP w0.102: v1(94.19,23.53) 93.91,23.81 93.91,23.88 93.05,24.74 93.05,27.15 93.24,27.35 Q27.6 ; v1(72.45,20.13) 72.45,19.43 C698.1 71.97,18.94 71.97,18.13 R562.1
  IN3 w0.089: v1(94.19,23.53) 94.2,23.52 94.2,22.75 v1(92.11,20.66)
  BOTTOM w0.102: v1(92.11,20.66) 92.11,20.89 91.27,21.73 89.84,21.73 89.11,22.47 83.31,22.47 82.14,21.3 77.58,21.3 76.85,22.03 72.55,22.03 72.32,21.8 CN33.5 72.32,20.51 72.5,20.32 72.5,20.18 v1(72.45,20.13)
TPCLK: length 140
  TOP w0.102: U37.89 198.18,25.38 197.73,24.94 197.73,24.58 197.46,24.31 v2(197.29,24.31) ; v1(75.98,17.58) 75.98,17.37 R566.2 75.29,17.65 L23.1
  IN3 w0.089: v2(197.29,24.31) 197.05,24.31 196.55,23.81 196.1,23.81 195.29,24.62 194.67,24.62 193.85,25.44 193.23,25.44 192.98,25.7 188.57,25.7 188.51,25.77 187.78,25.77 187.41,25.4 183.87,25.4 181.96,23.48 179.14,23.48 177.03,21.38 162.88,21.38 162.71,21.21 159.45,21.21 158.78,20.54 139.15,20.54 137.88,19.27 127.36,19.27 126.99,18.9 124.18,18.9 123.7,19.38 119.93,19.38 118.82,18.27 111.71,18.27 109.43,15.98 102.15,15.98 100.63,17.5 98.07,17.5 96.64,16.07 95.81,16.07 94.58,14.84 94.58,14.41 v1(94.52,14.36)
  BOTTOM w0.102: v1(75.98,17.58) 76.52,17.58 77.33,16.78 79.74,16.78 80.83,17.87 80.83,18.32 83.81,21.3 88.62,21.3 92.03,17.89 93.16,17.89 94.52,16.53 v1(94.52,14.36)
TPCLK-1: length 3
  TOP w0.102: v1(75.04,20.13) 75.29,19.88 C696.1 75.29,18.93 75.3,18.93 L23.2
  BOTTOM w0.102: CN33.2 75.32,20.41 v1(75.04,20.13)
TPD_EN: length 153.3
  TOP w0.102: R895.2 196.96,30.9 197.12,30.74 197.4,30.74 197.5,30.64 197.5,28.33 197.39,28.23 197.39,27.35 195.61,25.56 195.29,25.56 194.87,25.14 194.87,24.23 v2(195.05,24.06)
  IN3 w0.089: v1(96.81,14.31) 96.81,14.79 98.55,16.53 100.79,16.53 101.91,15.41 109.66,15.41 111.95,17.7 119.06,17.7 120.17,18.81 123.46,18.81 123.94,18.33 127.22,18.33 127.59,18.7 138.12,18.7 139.39,19.97 162.28,19.97 163.11,20.81 177.27,20.81 179.37,22.91 182.19,22.91 184.11,24.83 188.81,24.83 189.3,25.32 192.82,25.32 193.08,25.06 193.69,25.06 194.7,24.06 v2(195.05,24.06)
  BOTTOM w0.102: v1(96.81,14.31) 96.81,15.3 93.54,18.58 92.31,18.58 88.91,21.98 83.51,21.98 79.94,18.42 79.94,17.97 79.44,17.46 77.62,17.46 76.53,18.55 70.7,18.55 69.86,19.39 69.86,22.06 70.23,22.42 R572.2 70.23,23.09 69.67,23.64 R574.1
TPD_INT#: length 39.3
  TOP w0.102: R573.1 v1(72.53,15.61) 73.05,15.61 73.49,15.17 75.9,15.17 77.32,16.58 77.32,19.58 80.07,22.34 81.44,22.34 82.74,23.63 86.58,23.63 87.01,24.06 87.01,26.94 87.9,27.82 87.9,30.8 87.51,31.18 87.23,31.18 v2(87.18,31.23)
  BOTTOM w0.102: U2030.W4 86.95,37.35 86.95,35.53 87.97,34.51 87.97,33.41 87.44,32.88 87.44,31.48 v2(87.18,31.23) 87.18,29.15 86.88,28.84 R25477.2
TPD_INT#_EC: length 146.2
  TOP w0.102: R25323.1 180.43,32.16 180.94,31.66 R25308.2 180.94,31.2 181.07,31.07 181.26,31.07 181.54,30.8 183.58,30.8 183.75,30.62 183.75,29.32 184.2,28.87 186.01,28.87 186.36,28.51 186.36,27.99 187.83,26.52 187.83,25.91 188.35,25.4 v2(188.35,25.39) ; v1(70.5,17.58) 70.5,16.61 R25473.1
  IN3 w0.089: v2(188.35,25.39) 188.17,25.21 183.95,25.21 182.04,23.29 179.21,23.29 177.11,21.19 162.96,21.19 162.79,21.02 159.53,21.02 158.86,20.35 139.23,20.35 137.96,19.08 127.43,19.08 127.07,18.71 124.1,18.71 123.62,19.19 120.01,19.19 118.9,18.08 111.79,18.08 109.5,15.79 102.07,15.79 100.55,17.31 98.15,17.31 96.72,15.88 96.13,15.88 95.21,14.95 95.21,14.39 v1(95.18,14.36)
  BOTTOM w0.102: v1(70.5,17.58) 70.5,17.58 71.02,18.1 76.34,18.1 77.43,17 79.63,17 80.61,17.98 80.61,18.42 83.71,21.53 88.72,21.53 92.12,18.12 93.25,18.12 95.18,16.19 v1(95.18,14.36)
TPDAT-1: length 2.8
  TOP w0.102: v1(74.4,20.13) 74.32,20.05 C697.1 74.32,19 74.33,18.99 L24.2
  BOTTOM w0.102: v1(74.4,20.13) 74.32,20.2 CN33.3
TPDATA: length 140.7
  TOP w0.102: v2(197.14,24.88) 197.27,24.88 198.18,25.78 U37.90 ; v1(73.56,17.58) 73.56,17.45 R567.2 74.34,17.25 74.33,17.26 L24.1
  IN3 w0.089: v2(197.14,24.88) 197.14,25.02 196.53,25.63 193.31,25.63 193.06,25.89 188.65,25.89 188.58,25.96 187.7,25.96 187.34,25.59 183.8,25.59 181.88,23.67 179.06,23.67 176.95,21.57 162.77,21.57 162.6,21.4 159.37,21.4 158.7,20.73 139.07,20.73 137.8,19.46 127.28,19.46 126.91,19.09 124.26,19.09 123.78,19.57 119.85,19.57 118.74,18.46 104.13,18.46 103.37,17.69 97.99,17.69 96.56,16.26 95.41,16.26 93.89,14.74 v1(93.89,14.36)
  BOTTOM w0.102: v1(73.56,17.58) 75.25,17.58 76.29,16.55 79.84,16.55 81.06,17.77 81.06,18.23 83.9,21.07 88.53,21.07 91.93,17.66 93.07,17.66 93.89,16.84 v1(93.89,14.36)
TPM_LRESET#: length 3.8
  TOP w0.102: v1(124.5,24.35) 124.5,24.35 R601.2 123.33,23.94 123.33,23.2 122.59,22.47 122.59,22.31 122.69,22.21 U33.17
TRA_V_DAC: length 8.8
  BOTTOM w0.508: U25.10 28.9,103.88 29.16,104.14 v1(29.16,104.46) ; U25.7 31.9,104.19 32.19,104.48 v1(34.71,104.48) 34.71,104.15 34.9,103.96 U25.4 ; U25.1 37.9,104.19 v1(37.53,104.56)
TS_EN: length 263.1
  TOP w0.102: v2(202.96,23.59) 202.96,22.28 203.13,22.11 R956.1 ; v1(51.8,108.96) 51.85,108.91 51.85,106.74 51.7,106.59 51.7,105.86 51.85,105.71 51.85,102.88 52.14,102.6 52.14,102.25 52.62,101.77 54.32,101.77 54.98,102.43 54.98,104.02 55.49,104.53 56.8,104.53 57.62,105.35 R436.2
  IN3 w0.089: v2(202.96,23.59) 202.35,24.19 202.02,24.19 201.71,24.5 201.71,24.92 201.33,25.3 197.13,25.3 196.73,25.7 196.73,27.69 196.17,28.25 196.17,29.63 195.69,30.11 195.69,30.9 195.1,31.49 191.95,31.49 191.19,30.73 189.45,30.73 189.12,30.39 187.61,30.39 187.58,30.42 187.34,30.42 187.23,30.52 185.23,30.52 184.67,29.96 178.96,29.96 178.6,29.6 169.83,29.6 169.54,29.32 166.66,29.32 164.07,31.91 163.22,31.91 162.85,32.28 160.09,32.28 159.6,31.79 157.66,31.79 157.06,31.19 157.06,29.95 156.73,29.63 152.27,29.63 151.56,28.92 149.32,28.92 148.48,29.77 145.87,29.77 145.41,29.3 143.22,29.3 142.2,30.32 139.38,30.32 138.99,29.93 138.99,29.57 138.29,28.87 138.29,28.83 138,28.54 137.67,28.54 137.34,28.87 137.08,28.87 136.03,29.93 136.03,31.01 135.71,31.33 131.84,31.33 130.24,32.93 128.16,32.93 125.85,35.24 124.33,35.24 122.17,37.4 122.17,37.85 120.85,39.18 120.85,43.39 119.73,44.51 119.73,47.99 115.92,51.8 115.92,55.16 116.57,55.81 116.57,56.12 116.26,56.43 115.93,56.43 114.43,57.93 114.43,61.35 114.06,61.72 114.06,67.87 112.6,69.33 112.6,74.78 112.48,74.91 107.1,74.91 105.85,76.16 105.85,79.99 105.27,80.58 105.27,84.8 106.8,86.33 106.8,89.03 104.86,90.97 104.86,92.44 104.35,92.95 103.54,92.95 102.3,94.19 102.3,95.82 101.92,96.2 101.26,96.2 100.32,97.14 99.43,97.14 96.21,100.35 96.21,100.95 95.68,101.47 95.68,112.13 91.22,116.59 90.14,116.59 84.34,122.39 77.31,122.39 77.2,122.49 70.06,122.49 67.59,120.03 67.59,119.33 67.08,118.81 67.08,116.89 65.74,115.54 61.65,115.54 58.08,111.97 56.92,111.97 56.75,111.8 55.34,111.8 54.13,110.59 53.55,110.59 51.92,108.96 v1(51.8,108.96)
TS_EN_C: length 4.7
  TOP w0.102: R956.2 202.68,20.78 C1210.1 201.91,21.69 201.48,22.11 201.2,22.11 200.9,22.41 199.85,22.41 199.62,22.18 U37.81
TS_EN_R: length 1.9
  TOP w0.102: v1(56.93,106.23) 57.02,106.32 R436.1
  BOTTOM w0.102: CN29.28 57.35,106.47 57.11,106.23 v1(56.93,106.23)
TYPEC_SBU1: length 12.2
  TOP w0.102: v1(12.71,13.5) TP77.1 13.76,12.99 13.92,12.83 D19.2
  IN3 w0.089: v1(8.98,16.77) 9.21,16.77 9.71,17.27 9.71,17.76 10.27,18.32 10.78,18.32 11.14,17.97 11.14,15.07 v1(12.71,13.5)
  BOTTOM w0.102: CN10.A8 7.53,16.65 7.59,16.58 7.59,16.56 7.71,16.44 8.21,16.44 8.54,16.77 v1(8.98,16.77)
TYPEC_SBU2: length 8.7
  TOP w0.102: v1(9.26,18.79) 9.47,18.79 9.63,18.63 TP78.1 10.24,18.67 D18.2
  IN1 w0.089: v1(9.26,18.79) 9.26,18.71 8.57,18.02 6.28,18.02 5.65,17.39 5.65,17 5.78,16.88 5.78,16.62 5.4,16.24 5.4,15.22 CN10.B8
UART2_CTS#: length 11.5
  BOTTOM w0.079: 85.23,35.6 85.03,35.81 84.98,35.9 84.98,36.12 85.03,36.22 85.03,36.43 84.95,36.63 84.95,37.26 U2030.AD4
  BOTTOM w0.102: R2596.1 86.75,29.83 TP2083.1 86.75,30.33 86.27,30.82 86.27,31.2 87.03,31.96 87.03,33.05 87.56,33.58 87.56,34.21 87.33,34.44 86.59,34.44 86.33,34.7 85.78,34.7 85.32,35.16 85.32,35.51 85.23,35.6
UART2_RTS#: length 9.7
  BOTTOM w0.079: 84.9,35.68 84.89,35.72 84.82,35.85 84.82,36.15 84.87,36.26 84.87,36.4 84.8,36.61 84.8,36.77 84.63,36.93 U2030.AD3
  BOTTOM w0.102: R2578.1 85.33,29.75 TP2081.1 85.81,29.91 86.07,30.16 86.07,31.29 86.83,32.05 86.83,33.59 85.92,34.5 85.7,34.5 85.11,35.08 85.11,35.46 84.9,35.68
UART2_RXD: length 9.3
  BOTTOM w0.102: R2579.1 83.4,29.68 TP2085.1 84.62,29.68 85.28,30.34 85.48,30.34 85.86,30.72 85.86,31.38 86.63,32.14 86.63,33.51 85.84,34.29 85.61,34.29 84.91,34.99 84.91,35.25 84.58,35.58 U2030.AD1
UART2_TXD: length 8.4
  BOTTOM w0.102: U2030.AD2 84.3,36.06 84.3,35.53 84.71,35.12 84.71,34.91 85.53,34.09 85.75,34.09 86.42,33.42 86.42,32.32 84.89,30.8 TP2086.1 84.47,30.8 84.19,30.52 R2597.1
UGATE1_CORE: length 2.1
  BOTTOM w0.508: PQ7000.1 124.25,71.54 v1(124.19,71.6) 123.99,71.8 123.99,71.9 PR7106.2
UGATE2_CORE: length 1.2
  BOTTOM w0.508: PR7078.2 PQ7001.1
UGATE_GT: length 2.8
  BOTTOM w0.102: PQ7004.1 124.84,75.51 125.56,76.23 v1(125.56,76.26)
  BOTTOM w0.508: PQ7004.1 125.3,75.03 125.3,74.42 PR7110.2
UGATE_SA: length 0.9
  TOP w0.508: PR7114.2 138.8,38.53 137.95,38.53 v1(137.89,38.47)
ULT_EDP_HPD: length 211.9
  TOP w0.079: 91.02,36.77 91.02,37.54 90.53,38.03 90.53,39.85 90.46,39.91 90.46,40.37 90.87,40.78 v4(90.94,40.78)
  TOP w0.102: v1(52.42,108.8) 52.42,108.47 53.17,107.72 C6616.2 53.61,106.65 53.61,105.53 R25467.1 ; v1(97.7,22.9) 97.7,24.6 98.38,25.28 98.38,25.94 99.8,27.36 100.38,27.36 100.62,27.6 100.62,27.93 100.62,28.32 100.59,28.35 100.59,30.58 100.7,30.69 100.7,32.3 99.91,33.1 96.74,33.1 96.56,33.28 R2558.1 96.56,34.04 96.18,34.43 95.41,34.43 94.93,34.92 93.81,34.92 92.72,36 91.78,36 91.02,36.77
  IN3 w0.089: v1(52.42,108.8) 52.42,108.87 53.75,110.2 54.29,110.2 55.46,111.37 56.87,111.37 57.08,111.57 58.24,111.57 61.81,115.15 65.9,115.15 67.48,116.72 67.48,118.65 67.99,119.16 67.99,119.86 70.22,122.1 77.04,122.1 77.14,121.99 84.18,121.99 89.98,116.2 91.04,116.2 95.29,111.94 95.29,101.01 95.46,100.84 95.46,99.38 96.89,97.95 97.62,97.95 98.46,97.12 98.46,96.51 98.72,96.25 99.15,96.25 99.73,95.67 99.73,94.93 100.6,94.07 100.85,94.07 101.56,93.36 101.56,93.05 103.03,91.58 103.69,91.58 106.41,88.86 106.41,86.5 104.87,84.96 104.87,80.41 105.46,79.83 105.46,74.24 105.88,73.82 105.88,70.93 106.84,69.97 107.16,69.97 110.11,67.03 110.11,63.3 110.97,62.43 112.04,62.43 113.57,60.91 113.57,54.57 112.34,53.35 111.65,53.35 111.38,53.08 111.38,52.05 112.23,51.2 112.23,46.37 112.9,45.7 115.24,45.7 115.87,45.06 115.87,42.62 116.51,41.98 117.81,41.98 118.79,41 118.79,40.28 119.28,39.8 119.28,37.16 116.84,34.72 112.37,34.72 110.1,32.45 110.1,31.43 106.17,27.5 106.17,25.43 105.72,24.98 104.86,24.98 102.32,22.44 102.32,22.14 101.81,21.63 100.94,21.63 100.06,20.76 100.06,20.05 99.88,19.87 99.22,19.87 98.77,20.33 98.77,20.99 97.7,22.06 v1(97.7,22.9)
  BOTTOM w0.102: v4(90.94,40.78) 90.95,40.79 91.11,40.79 91.15,40.83 91.34,41.02 U2030.L10
ULT_EDP_HPD_R: length 4.2
  TOP w0.102: v1(55.69,107.96) 55.69,107.14 54.15,105.6 R25467.2
  BOTTOM w0.102: CN29.25 55.85,107.8 v1(55.69,107.96)
USB2_ID: length 8.2
  BOTTOM w0.079: U2030.AG3 83.26,36.76 83.65,36.37 83.65,35.9 83.68,35.84 83.68,35.55 83.67,35.52 83.67,35.08 83.66,35.08
  BOTTOM w0.102: 83.66,35.08 83.66,34.99 83.88,34.77 84.56,34.77 85.45,33.89 85.67,33.89 86.22,33.34 86.22,32.41 85.43,31.62 R2561.1
USB2_VBUSSENSE: length 18.2
  TOP w0.079: v4(81.61,39.32) 81.21,38.92 81.21,37.71 80.46,36.96 80.46,35.58 79.74,34.86 79.74,34.61
  TOP w0.102: R2213.1 81.67,27.27 81.67,29.75 80.5,30.93 80.5,32.17 79.74,32.93 79.74,34.61
  BOTTOM w0.102: U2030.AG4 82.87,38.02 82.48,38.41 82.48,39.19 82.28,39.4 81.69,39.4 v4(81.61,39.32)
USB3_SS0RX+: length 2.1
  BOTTOM w0.102: U6502.5 20.14,21.44 20.23,21.53 20.4,21.53 20.76,21.17 21.19,21.17 21.29,21.07 C683.1
USB3_SS0RX-: length 2.1
  BOTTOM w0.102: U6502.4 20.15,21.84 20.24,21.74 20.49,21.74 20.85,21.39 21.18,21.39 21.29,21.49 C682.1
USB3_SS0TX+: length 2.1
  BOTTOM w0.102: C677.1 21.29,22.96 21.14,23.1 20.92,23.1 20.54,22.73 20.21,22.73 20.12,22.64 U6502.2
USB3_SS0TX-: length 2.1
  BOTTOM w0.102: C681.1 21.29,23.46 21.14,23.32 20.83,23.32 20.45,22.94 20.21,22.94 20.12,23.04 U6502.1
USB30_RX1+: length 115.2
  TOP w0.102: R422.2 23.18,53.2 24.07,53.2 C518.2 24.55,53.22 24.82,53.22 25.21,52.83 25.21,51.26 24.76,50.81 23.1,50.81 23.05,50.86 22.26,50.86 v1(22.09,50.69)
  IN3 w0.089: v1(22.09,50.69) 22.28,50.88 22.51,50.88 22.64,50.75 22.64,49.9 22.08,49.35 22.08,47.67 21.17,46.76 21.17,43.29 21.98,42.47 21.98,40.06 25.44,36.6 25.44,35.23 27.22,33.45 27.22,30.57 27.47,30.32 27.47,26.46 29.15,24.78 30.26,24.78 31.63,23.41 40.55,23.41 40.68,23.53 48.44,23.53 48.52,23.46 51.23,23.46 51.7,22.99 61.97,22.99 64.32,25.34 65,25.34 65.54,24.8 66.57,24.8 67.1,25.34 68.35,25.34 68.82,25.81 68.82,29.21 70.4,30.8 73.49,30.8 74.81,29.48 80.8,29.48 81,29.27 83.13,29.27 83.74,29.88 84.18,29.88 89.17,34.87 89.45,34.87 91.55,36.97 91.55,37.18 92.14,37.77 92.14,38.54 92.02,38.65 92.02,39.04 92.19,39.2 92.4,39.2 92.5,39.31 92.6,39.31 v4(93.02,39.72)
  BOTTOM w0.102: U2030.G8 93.35,40.05 v4(93.02,39.72)
USB30_RX1+_C: length 11.5
  TOP w0.102: R422.1 22.15,53.15 22.05,53.05 21.82,53.05 21.13,53.75 18.37,53.75 U16.10 18.2,53.75 17.6,53.75 16.15,52.3 TP9058.1 14.37,52.3 13.62,51.55 13.2,51.55 13.1,51.65 CN2.6
USB30_RX1-: length 115.2
  TOP w0.102: v1(22.09,51.45) 22.09,51.28 22.3,51.08 23.14,51.08 23.19,51.03 24.67,51.03 24.99,51.34 24.99,52.74 24.73,53 24.42,53 24.32,52.9 C513.2 23.78,52.98 23.06,52.98 22.93,52.85 R421.2
  IN3 w0.089: v1(22.09,51.45) 22.09,51.28 22.29,51.08 22.6,51.08 22.84,50.83 22.84,49.82 22.29,49.26 22.29,47.59 21.37,46.67 21.37,43.37 22.19,42.56 22.19,40.14 25.64,36.69 25.64,35.32 27.42,33.53 27.42,30.66 27.67,30.41 27.67,26.54 29.24,24.98 30.35,24.98 31.71,23.61 40.47,23.61 40.59,23.74 48.53,23.74 48.6,23.66 51.32,23.66 51.79,23.19 61.89,23.19 64.24,25.54 65.09,25.54 65.62,25.01 66.48,25.01 67.02,25.54 68.26,25.54 68.62,25.89 68.62,29.3 70.32,31 73.57,31 74.89,29.68 80.88,29.68 81.09,29.48 83.04,29.48 83.65,30.09 84.1,30.09 89.08,35.07 89.37,35.07 91.35,37.05 91.35,37.27 91.93,37.85 91.93,38.46 91.82,38.57 91.82,39.12 92.11,39.41 92.31,39.41 92.39,39.48 v4(92.39,39.69)
  BOTTOM w0.102: v4(92.39,39.69) 92.39,39.87 U2030.H8
USB30_RX1-_C: length 11.5
  TOP w0.102: R421.1 22.15,52.73 22.04,52.84 21.73,52.84 21.04,53.53 20.29,53.53 U16.1 20.09,53.53 17.69,53.53 16.24,52.08 TP9055.1 14.46,52.08 13.71,51.33 13.2,51.33 13.1,51.23 CN2.5
USB30_RX2+: length 89.3
  TOP w0.102: v1(25.51,34.03) 25.26,33.78 25.07,33.78 24.15,32.87 23.81,32.87 C526.2 23.32,32.89 22.8,32.89 R428.2
  IN3 w0.089: v4(93.04,38.76) 92.82,38.54 92.82,37.01 92.32,36.51 92.01,36.51 89.44,33.95 89.09,33.95 84.32,29.17 83.88,29.17 82.64,27.93 81.52,27.93 80.79,27.2 77.69,27.2 77.02,26.53 75.29,26.53 73.23,24.47 67.23,24.47 66.55,23.79 64.47,23.79 63.87,23.2 63.16,23.2 62.27,22.31 51.51,22.31 50.97,22.86 42.19,22.86 42.12,22.8 31.1,22.8 30.31,23.58 29.5,23.58 26.83,26.25 26.83,29.85 26.62,30.06 26.62,30.92 24.67,32.87 24.67,33.37 25.17,33.87 25.35,33.87 v1(25.51,34.03)
  BOTTOM w0.102: v4(93.04,38.76) 93.04,39.15 92.93,39.26 U2030.H6
USB30_RX2+_C: length 10.5
  TOP w0.102: R428.1 21.77,32.65 21.67,32.55 21.14,32.55 20.39,33.31 18.11,33.31 U17.10 17.96,33.31 TP9070.1 15.65,33.31 14.78,32.44 14.35,32.44 13.8,31.89 13.4,31.89 13.1,32.19 CN3.6
USB30_RX2-: length 89.3
  TOP w0.102: R427.2 22.55,32.51 22.71,32.67 23.01,32.67 C523.2 23.56,32.55 23.66,32.65 24.24,32.65 25.16,33.56 25.36,33.56 25.51,33.42 v1(25.51,33.27)
  IN3 w0.089: v1(25.51,33.27) 25.51,33.49 25.33,33.67 25.26,33.67 24.88,33.29 24.88,32.95 26.83,31.01 26.83,30.14 27.04,29.93 27.04,26.33 29.58,23.79 30.4,23.79 31.19,23 42.04,23 42.1,23.06 51.05,23.06 51.6,22.52 62.19,22.52 63.08,23.4 63.79,23.4 64.38,24 66.46,24 67.14,24.68 73.15,24.68 75.21,26.73 76.94,26.73 77.61,27.4 80.7,27.4 81.43,28.13 82.55,28.13 83.8,29.37 84.23,29.37 89.01,34.15 89.36,34.15 91.93,36.71 92.24,36.71 92.62,37.1 92.62,38.61 v4(92.41,38.82)
  BOTTOM w0.102: U2030.J6 92.41,38.9 v4(92.41,38.82)
USB30_RX2-_C: length 10.5
  TOP w0.102: R427.1 21.55,32.33 21.05,32.33 20.3,33.09 20.04,33.09 U17.1 19.83,33.09 TP9067.1 15.74,33.09 14.87,32.22 14.44,32.22 13.1,30.88 CN3.5
USB30_RX3+: length 101.7
  IN3 w0.089: v1(39.52,24.12) 39.51,24.12 39.23,24.39 39.23,24.54 39.32,24.62 41.92,24.62 42.35,24.19 44.42,24.19 44.85,24.62 48.21,24.62 48.77,24.07 51.49,24.07 51.97,23.58 61.72,23.58 64.09,25.94 64.69,25.94 65.1,26.36 65.22,26.36 65.84,25.74 66.26,25.74 66.54,26.03 66.54,26.32 65.86,26.99 65.86,27.12 66.09,27.35 66.21,27.35 66.88,26.67 67.18,26.67 67.5,27 67.5,27.33 66.85,27.98 66.85,28.11 67.08,28.33 67.2,28.33 67.57,27.96 67.9,27.96 68.21,28.27 68.21,28.6 67.84,28.97 67.84,29.1 70.2,31.46 73.82,31.46 74.91,30.36 75.69,30.36 75.88,30.56 76.59,30.56 77.09,30.06 78.4,30.06 78.62,30.28 78.62,30.87 78.73,30.97 79.14,30.97 79.23,30.89 79.23,30.41 79.58,30.06 81.08,30.06 81.38,29.75 82.76,29.75 83.6,30.59 83.91,30.59 84.77,31.45 84.77,33.97 85.33,34.53 85.53,34.53 85.69,34.38 85.69,33.8 85.89,33.59 86.29,33.59 86.5,33.8 86.5,34.25 86.65,34.4 87.48,34.4 87.93,34.85 87.93,35.14 87.51,35.55 87.51,35.69 87.7,35.88 87.91,35.88 88.27,35.52 88.6,35.52 89.01,35.93 89.48,35.93 91.53,37.98 91.53,39.92 91.71,40.09 92.35,40.09 92.53,40.27 92.64,40.27 v4(92.99,40.62)
  BOTTOM w0.102: C683.2 22.07,20.92 22.21,21.07 22.69,21.07 23.29,21.66 23.66,21.66 23.76,21.56 23.76,21.29 23.99,21.06 24.48,21.06 24.7,21.29 24.7,21.49 24.98,21.76 28.34,21.76 28.6,21.5 29.8,21.5 30.03,21.73 30.03,21.97 30.22,22.16 30.46,22.16 30.6,22.02 30.6,21.73 30.84,21.49 31.32,21.49 31.6,21.76 31.6,21.93 31.74,22.07 31.91,22.07 32.05,21.93 32.05,21.71 32.28,21.49 34.62,21.49 34.87,21.74 34.87,22.21 35.05,22.39 35.28,22.39 35.38,22.29 35.38,21.71 35.61,21.49 36.12,21.49 36.37,21.74 36.37,22.29 36.47,22.39 36.7,22.39 36.8,22.29 36.8,21.77 37.03,21.54 37.46,21.54 37.84,21.92 37.84,23.16 38.02,23.34 39.01,23.34 39.24,23.57 39.24,23.84 v1(39.52,24.12) ; U2030.H10 92.99,40.8 v4(92.99,40.62)
USB30_RX3-: length 101.7
  IN3 w0.089: v1(38.74,24.12) 39.03,24.4 39.03,24.62 39.24,24.83 42.01,24.83 42.44,24.4 44.33,24.4 44.77,24.83 48.3,24.83 48.86,24.27 51.57,24.27 52.06,23.79 61.64,23.79 64,26.15 64.6,26.15 65.02,26.56 65.31,26.56 65.92,25.95 66.17,25.95 66.33,26.11 66.33,26.24 65.66,26.91 65.66,27.2 66,27.55 66.3,27.55 66.97,26.88 67.09,26.88 67.3,27.09 67.3,27.25 66.65,27.9 66.65,28.19 66.99,28.54 67.29,28.54 67.66,28.16 67.82,28.16 68.01,28.35 68.01,28.52 67.64,28.89 67.64,29.18 70.12,31.66 73.9,31.66 74.99,30.57 75.6,30.57 75.8,30.76 76.68,30.76 77.18,30.26 78.32,30.26 78.42,30.36 78.42,30.96 78.64,31.18 79.23,31.18 79.44,30.97 79.44,30.49 79.67,30.26 81.16,30.26 81.47,29.96 82.68,29.96 83.52,30.8 83.83,30.8 84.57,31.53 84.57,34.06 85.25,34.73 85.62,34.73 85.89,34.46 85.89,33.88 85.98,33.79 86.21,33.79 86.29,33.88 86.29,34.33 86.57,34.61 87.4,34.61 87.72,34.93 87.72,35.06 87.31,35.47 87.31,35.77 87.62,36.08 88,36.08 88.35,35.72 88.51,35.72 88.92,36.13 89.39,36.13 91.33,38.06 91.33,40 91.62,40.3 92.27,40.3 92.36,40.38 v4(92.36,40.63)
  BOTTOM w0.102: v4(92.36,40.63) 91.97,40.63 91.87,40.73 91.87,40.91 U2030.J10 ; v1(38.74,24.12) 39.03,23.84 39.03,23.66 38.92,23.56 37.93,23.56 37.63,23.25 37.63,22.01 37.37,21.75 37.12,21.75 37.02,21.86 37.02,22.38 36.79,22.6 36.38,22.6 36.16,22.38 36.16,21.83 36.03,21.7 35.7,21.7 35.6,21.8 35.6,22.38 35.37,22.6 34.96,22.6 34.66,22.3 34.66,21.83 34.53,21.7 32.37,21.7 32.27,21.8 32.27,22.02 32,22.28 31.65,22.28 31.38,22.02 31.38,21.85 31.23,21.7 30.93,21.7 30.81,21.82 30.81,22.11 30.55,22.38 30.13,22.38 29.81,22.06 29.81,21.82 29.71,21.72 28.69,21.72 28.43,21.98 24.89,21.98 24.49,21.58 24.49,21.38 24.39,21.28 24.08,21.28 23.98,21.38 23.98,21.65 23.75,21.88 23.2,21.88 22.6,21.28 22.17,21.28 22.07,21.39 C682.2
USB30_RX+_TYPEC1: length 27.3
  TOP w0.102: v1(12.63,14.46) 12.41,14.69 12.21,14.69 11.78,15.12 RV3.1 RV3.10 10.14,15.12 10.05,15.21 9.9,15.21 9.69,15 9.69,13.93 9.21,13.45 7.97,13.45 7.73,13.69 5.52,13.69 CN10.B11
  IN1 w0.089: v1(12.63,14.46) 12.81,14.64 13.13,14.64 13.74,14.03 14.31,14.03 15.15,14.87 18.84,14.87 19.14,15.17 19.14,16.92 18.74,17.32 17.93,17.32 17.84,17.41 17.84,17.79 17.99,17.94 20.01,17.94 20.22,18.15 20.22,18.77 20.01,18.98 18.85,18.98 18.6,19.23 18.6,19.45 v1(18.88,19.73)
  BOTTOM w0.102: U6502.7 18.7,20.44 18.61,20.35 18.61,20 v1(18.88,19.73)
USB30_RX+_TYPEC2: length 25.5
  IN1 w0.089: v1(16.42,23.79) 16.2,23.56 15.76,23.56 15.51,23.31 15.51,22.69 14.94,22.13 14.03,22.13 13.77,21.87 13.77,21.48 13.97,21.27 15.95,21.27 17.17,22.5 17.32,22.5 17.47,22.35 17.47,22.2 15.57,20.31 15.26,20.31 15.02,20.06 15.02,19.6 15.22,19.39 15.41,19.39 15.5,19.3 15.5,18.4 15.41,18.31 14.33,18.31 13.8,17.78 13.8,17.47 13.71,17.39 v1(13.52,17.39)
  BOTTOM w0.102: v1(16.42,23.79) 17.17,23.04 U6502.14 ; CN10.A11 7.55,18.15 7.72,17.98 8.23,17.98 8.35,18.11 9.3,18.11 9.75,17.65 9.75,17.07 9.86,16.97 10,16.97 10.14,17.12 RV2.10 RV2.1 11.71,17.12 12,16.83 12.79,16.83 13.11,17.15 13.29,17.15 v1(13.52,17.39)
USB30_RX-_TYPEC1: length 27.3
  TOP w0.102: CN10.B10 5.52,13.91 7.82,13.91 8.06,13.66 9.12,13.66 9.47,14.02 9.47,15.09 9.81,15.43 9.95,15.43 10.14,15.61 RV3.9 RV3.2 11.59,15.61 12.3,14.9 12.53,14.9 12.63,15.01 v1(12.63,15.1)
  IN1 w0.089: v1(12.63,15.1) 12.63,14.97 12.76,14.85 13.22,14.85 13.83,14.24 14.23,14.24 15.06,15.07 18.75,15.07 18.93,15.25 18.93,16.84 18.65,17.12 17.85,17.12 17.64,17.33 17.64,17.88 17.9,18.14 19.93,18.14 20.02,18.23 20.02,18.69 19.93,18.78 18.76,18.78 18.4,19.14 18.4,19.45 v1(18.12,19.73)
  BOTTOM w0.102: U6502.8 18.3,20.44 18.39,20.35 18.39,20 v1(18.12,19.73)
USB30_RX-_TYPEC2: length 25.5
  IN1 w0.089: v1(16.37,23.08) 16.09,23.36 15.84,23.36 15.71,23.23 15.71,22.61 15.02,21.92 14.11,21.92 13.97,21.78 13.97,21.57 14.06,21.48 15.86,21.48 17.09,22.7 17.41,22.7 17.67,22.44 17.67,22.12 15.66,20.1 15.34,20.1 15.22,19.98 15.22,19.68 15.31,19.59 15.5,19.59 15.7,19.39 15.7,18.31 15.5,18.11 14.42,18.11 14.01,17.7 14.01,17.23 v1(13.52,16.75)
  BOTTOM w0.102: v1(16.37,23.08) 16.82,22.64 U6502.13 ; CN10.A10 7.54,17.65 7.66,17.77 8.32,17.77 8.44,17.89 9.21,17.89 9.54,17.56 9.54,16.98 9.77,16.76 10,16.76 10.14,16.62 RV2.9 RV2.2 12.88,16.62 13.2,16.93 13.34,16.93 v1(13.52,16.75)
USB30_TX1+: length 135.3
  TOP w0.102: C520.1 25.61,57.66 25.61,57.49 25.79,57.31 26.43,57.31 26.72,57.6 26.72,59.07 26.44,59.35 24.17,59.35 23.44,60.07 22.8,60.07 22.69,59.97 v1(22.69,59.79)
  IN3 w0.089: v4(95.21,42.33) 95.21,42.83 95.36,42.99 95.59,42.99 95.82,42.76 95.82,41.89 95.13,41.21 94.56,41.21 94.09,40.74 94.09,39.54 93.61,39.06 93.61,38.41 93.81,38.2 93.81,37.2 92.15,35.54 91.76,35.54 88.9,32.68 88.65,32.68 87.63,31.66 87.63,31.1 86.87,30.34 86.24,30.34 84.4,28.5 84.4,28.19 83.66,27.46 81.71,27.46 80.98,26.73 77.9,26.73 77.14,25.97 75.29,25.97 73.32,24 67.67,24 66.99,23.32 64.69,23.32 64.09,22.72 63.4,22.72 62.58,21.89 51.18,21.89 50.71,22.36 45.37,22.36 44.92,21.91 44.49,21.91 44.07,22.33 34.03,22.33 33.69,21.98 33.29,21.98 32.95,22.32 30.08,22.32 27.8,24.59 25.47,24.59 25.39,24.68 25.39,27.82 25.94,28.38 25.94,30.89 24.09,32.74 24.09,34.04 24.9,34.85 24.9,36.41 21.58,39.74 21.58,40.45 20.36,41.67 20.36,44.82 20.05,45.12 20.05,46.95 19.04,47.97 19.04,49.25 19.68,49.89 19.68,54.25 19.87,54.44 19.87,56.73 20.71,57.57 20.71,58.98 21.93,60.21 22.47,60.21 22.69,59.99 v1(22.69,59.79)
  BOTTOM w0.102: U2030.D13 95.21,42.6 v4(95.21,42.33)
USB30_TX1+_C: length 1.3
  TOP w0.102: C520.2 24.67,57.5 24.47,57.5 R423.2
USB30_TX1+_C_R: length 12.6
  TOP w0.102: CN2.9 13.1,57.94 14.1,56.95 TP9061.1 18.2,56.95 U16.6 18.37,56.95 20.39,56.95 20.88,57.43 20.88,57.76 21.41,58.29 21.67,58.29 C522.1 22.29,58.39 22.36,58.39 22.77,57.99 22.77,57.87 22.96,57.68 23.08,57.68 R423.1
USB30_TX1-: length 135.3
  TOP w0.102: C519.1 26.07,57.1 26.52,57.1 26.93,57.51 26.93,59.16 26.53,59.56 24.26,59.56 23.53,60.29 22.97,60.29 v1(22.69,60.57)
  IN3 w0.089: v4(95.86,43.28) 95.86,43.01 96.02,42.84 96.02,41.81 95.21,41 94.65,41 94.3,40.65 94.3,39.46 93.81,38.98 93.81,38.49 94.02,38.29 94.02,37.11 92.24,35.33 91.84,35.33 88.98,32.47 88.74,32.47 87.84,31.57 87.84,31.02 86.96,30.14 86.32,30.14 84.6,28.41 84.6,28.11 83.74,27.25 81.8,27.25 81.07,26.52 77.98,26.52 77.23,25.77 75.37,25.77 73.4,23.8 67.75,23.8 67.08,23.12 64.78,23.12 64.17,22.52 63.49,22.52 62.66,21.69 51.09,21.69 50.63,22.15 45.45,22.15 45,21.7 44.4,21.7 43.98,22.12 34.12,22.12 33.78,21.78 33.2,21.78 32.87,22.11 30,22.11 27.72,24.39 25.39,24.39 25.18,24.6 25.18,27.9 25.74,28.46 25.74,30.8 23.89,32.66 23.89,34.12 24.7,34.94 24.7,36.33 21.37,39.65 21.37,40.36 20.15,41.58 20.15,44.73 19.85,45.04 19.85,46.87 18.83,47.88 18.83,49.33 19.47,49.97 19.47,54.33 19.66,54.52 19.66,56.82 20.5,57.66 20.5,59.07 21.85,60.41 22.54,60.41 v1(22.69,60.57)
  BOTTOM w0.102: U2030.C13 96.07,43.07 v4(95.86,43.28)
USB30_TX1-_C: length 1.3
  TOP w0.102: R424.2 24.47,57.28 24.67,57.28 C519.2
USB30_TX1-_C_R: length 12.6
  TOP w0.102: CN2.8 13.39,56.73 TP9059.1 20.09,56.73 U16.5 20.29,56.73 20.48,56.73 21.09,57.34 21.09,57.67 21.5,58.08 21.61,58.08 C521.1 22.03,58.08 22.13,58.18 22.26,58.18 22.32,58.11 22.55,57.89 22.55,57.78 22.87,57.47 23.16,57.47 23.29,57.33 R424.1
USB30_TX2+: length 105
  TOP w0.102: C531.1 25.69,37.74 25.88,37.74 26.29,37.33 26.29,36.55 25.86,36.12 24.84,36.12 24.38,35.66 23.6,35.66 v1(23.39,35.45)
  IN3 w0.089: v4(97.55,42.22) 97.39,42.06 97.39,41.8 96.6,41.01 96.6,40.89 95.52,39.8 95.52,37.77 94.98,37.24 94.98,36.91 89.49,31.42 89.49,31.26 89.13,30.9 88.69,30.9 86.96,29.17 86.22,29.17 85.2,28.15 85.2,27.86 83.99,26.66 82.05,26.66 81.32,25.93 78.24,25.93 77.35,25.03 75.53,25.03 73.68,23.18 67.97,23.18 67.32,22.52 65.03,22.52 63.6,21.09 50.84,21.09 50.38,21.56 45.72,21.56 45.26,21.09 44.13,21.09 43.7,21.53 34.39,21.53 34.03,21.17 32.95,21.17 32.6,21.52 29.65,21.52 28.07,23.1 25.4,23.1 24.52,23.98 24.52,28.13 25.14,28.75 25.14,30.55 23.23,32.47 23.23,34.39 23.96,35.12 23.96,35.56 23.87,35.65 23.58,35.65 v1(23.39,35.45)
  BOTTOM w0.102: U2030.A13 97.55,42.63 v4(97.55,42.22)
USB30_TX2+_C: length 1.3
  TOP w0.102: R430.2 24.07,37.58 24.31,37.58 C531.2
USB30_TX2+_C_R: length 11.9
  TOP w0.102: CN3.9 13.1,38.05 14.22,36.93 TP9073.1 17.04,36.93 17.52,36.45 17.9,36.45 U17.6 18.17,36.45 18.92,36.45 19.06,36.58 20.53,36.58 21.53,37.58 21.8,37.58 21.91,37.68 C533.1 22.13,37.73 22.68,37.73 R430.1
USB30_TX2-: length 105
  TOP w0.102: v1(23.39,36.21) 23.39,36 23.51,35.88 24.29,35.88 24.75,36.33 25.77,36.33 26.07,36.64 26.07,37.24 25.79,37.53 25.6,37.53 25.47,37.4 C530.1
  IN3 w0.089: v4(96.92,42.22) 97.05,42.22 97.19,42.07 97.19,41.89 96.4,41.1 96.4,40.98 95.31,39.89 95.31,37.85 94.78,37.32 94.78,36.99 89.29,31.5 89.29,31.34 89.05,31.1 88.61,31.1 86.88,29.37 86.14,29.37 84.99,28.23 84.99,27.95 83.91,26.86 81.96,26.86 81.23,26.13 78.16,26.13 77.26,25.23 75.45,25.23 73.59,23.38 67.89,23.38 67.24,22.73 64.94,22.73 63.51,21.3 50.93,21.3 50.46,21.76 45.64,21.76 45.17,21.3 44.22,21.3 43.78,21.73 34.3,21.73 33.95,21.37 33.03,21.37 32.69,21.72 29.74,21.72 28.15,23.3 25.49,23.3 24.73,24.07 24.73,28.04 25.35,28.67 25.35,30.64 23.43,32.56 23.43,34.3 24.17,35.04 24.17,35.64 23.96,35.85 23.48,35.85 23.39,35.95 v1(23.39,36.21)
  BOTTOM w0.102: U2030.B13 97.05,42.49 97.05,42.35 v4(96.92,42.22)
USB30_TX2-_C: length 1.3
  TOP w0.102: R429.2 24.11,37.36 24.27,37.36 C530.2
USB30_TX2-_C_R: length 11.9
  TOP w0.102: R429.1 22.91,37.41 22.81,37.51 22.47,37.51 C532.1 21.91,37.22 21.76,37.37 21.62,37.37 20.62,36.37 20.12,36.37 U17.5 19.75,36.37 19.15,36.37 19.01,36.23 17.43,36.23 16.95,36.71 TP9071.1 14.13,36.71 13.98,36.87 13.53,36.87 CN3.8
USB30_TX3+: length 101.9
  IN3 w0.089: v1(22.89,22.82) 23.09,23.02 24.49,23.02 25.64,21.87 25.64,21.65 25.85,21.44 27.13,21.44 27.34,21.65 27.34,22.33 27.45,22.44 27.79,22.44 27.88,22.35 27.88,21.32 28.28,20.92 30.95,20.92 31.18,20.7 31.18,18.38 31.43,18.12 32.09,18.12 32.29,18.33 32.29,20.15 32.7,20.56 34.28,20.56 34.65,20.93 35.49,20.93 35.58,20.84 35.58,20.58 35.79,20.37 36.2,20.37 36.4,20.58 36.4,20.84 36.49,20.93 43.45,20.93 43.89,20.48 45.51,20.48 45.99,20.96 50.13,20.96 50.6,20.5 63.86,20.5 65.29,21.93 67.86,21.93 68.5,22.57 75.42,22.57 75.7,22.85 75.7,23.2 75.27,23.63 75.27,23.77 75.61,24.12 77.28,24.12 78.49,25.33 81.56,25.33 82.29,26.06 84.86,26.06 85.79,27 85.79,27.87 86.33,28.41 87.12,28.41 89.01,30.3 89.38,30.3 90.09,31.01 90.09,31.16 95.58,36.65 95.58,36.99 96.15,37.56 96.15,39.37 97.17,40.39 97.17,40.91 97.84,41.59 98.44,41.59 98.79,41.94 98.79,42.52 98.69,42.62 98.69,43.1 v1(98.92,43.33)
  BOTTOM w0.102: v1(22.89,22.82) 22.62,23.09 22.17,23.09 22.07,22.99 C677.2 ; U2030.A15 97.37,44.02 97.48,43.92 98.26,43.92 98.85,43.33 v1(98.92,43.33)
USB30_TX3-: length 101.9
  IN3 w0.089: v4(98.21,43.33) 98.4,43.33 98.49,43.25 98.49,42.54 98.59,42.44 98.59,42.02 98.36,41.79 97.76,41.79 96.96,41 96.96,40.47 95.95,39.46 95.95,37.64 95.38,37.07 95.38,36.74 89.88,31.24 89.88,31.09 89.29,30.5 88.92,30.5 87.03,28.61 86.24,28.61 85.59,27.96 85.59,27.08 84.77,26.26 82.21,26.26 81.48,25.53 78.41,25.53 77.19,24.32 75.53,24.32 75.07,23.86 75.07,23.55 75.5,23.12 75.5,22.93 75.33,22.77 68.42,22.77 67.78,22.13 65.21,22.13 63.78,20.7 50.68,20.7 50.22,21.16 45.9,21.16 45.43,20.69 43.98,20.69 43.53,21.13 36.41,21.13 36.2,20.92 36.2,20.66 36.11,20.57 35.87,20.57 35.79,20.66 35.79,20.92 35.58,21.13 34.57,21.13 34.2,20.76 32.62,20.76 32.09,20.24 32.09,18.41 32,18.32 31.52,18.32 31.38,18.46 31.38,20.78 31.04,21.12 28.36,21.12 28.08,21.4 28.08,22.43 27.87,22.64 27.37,22.64 27.14,22.41 27.14,21.73 27.05,21.64 25.93,21.64 25.84,21.73 25.84,21.96 24.57,23.23 23.25,23.23 v1(22.89,23.58)
  BOTTOM w0.102: C681.2 22.07,23.42 22.18,23.31 22.62,23.31 v1(22.89,23.58) ; U2030.B15 96.92,44.17 97.37,43.72 98.18,43.72 98.31,43.59 98.31,43.43 v4(98.21,43.33)
USB30_TX+_TYPEC1: length 27.2
  IN1 w0.089: v1(13.73,15.23) 13.92,15.42 14.56,15.42 14.79,15.64 14.79,16.35 14.9,16.46 15.17,16.46 15.28,16.35 15.28,15.67 15.49,15.46 18.17,15.46 18.38,15.68 18.38,16.3 18.17,16.51 16.21,16.51 16.14,16.58 16.14,16.9 15.71,17.33 15.71,17.43 v1(15.91,17.64)
  BOTTOM w0.102: v1(15.91,17.64) 15.67,17.88 15.67,18.23 15.28,18.62 15.28,19.34 C686.1 ; v1(13.73,15.23) 13.56,15.39 13.05,15.39 12.8,15.65 12.55,15.65 12.16,15.26 11.97,15.26 11.83,15.12 RV2.5 RV2.6 10.14,15.12 10,15.26 9.86,15.26 9.71,15.12 9.71,14.26 9.96,14.02 11.86,14.02 12.11,13.77 12.11,13.23 11.86,12.98 9.34,12.98 8.53,13.79 7.82,13.79 7.68,13.65 CN10.A2
USB30_TX+_TYPEC1_C: length 3.3
  BOTTOM w0.102: C686.2 15.29,20.49 15.12,20.66 15.12,20.86 15.26,21 16.14,21 16.66,21.53 16.82,21.53 16.91,21.44 U6502.10
USB30_TX+_TYPEC2: length 26.9
  TOP w0.102: CN10.B2 5.43,18.2 9.11,18.2 9.71,17.6 9.71,17.07 9.82,16.97 10,16.97 10.14,17.12 RV3.6 RV3.5 12.09,17.12 12.19,17.22 12.19,17.55 v1(12.69,18.05)
  IN1 w0.089: v1(12.69,18.05) 12.89,17.84 13.01,17.84 13.17,18 13.17,18.93 13.08,19.02 11.95,19.02 11.75,19.23 11.75,19.72 11.95,19.92 12.88,19.92 12.97,20.01 12.97,24.6 15.94,27.57 17.25,27.57 v1(17.51,27.82)
  BOTTOM w0.102: C684.1 18.3,26.21 18.3,27.21 17.99,27.52 17.81,27.52 v1(17.51,27.82)
USB30_TX+_TYPEC2_C: length 2.2
  BOTTOM w0.102: U6502.17 18.7,23.88 18.52,24.07 18.52,24.38 18.26,24.64 18.26,25.02 18.37,25.12 C684.2
USB30_TX-_TYPEC1: length 27.2
  IN1 w0.089: v1(15.14,17.64) 15.28,17.64 15.51,17.41 15.51,17.25 15.94,16.82 15.94,16.5 16.13,16.31 18.08,16.31 18.17,16.22 18.17,15.76 18.08,15.67 15.57,15.67 15.48,15.76 15.48,16.43 15.25,16.67 14.82,16.67 14.58,16.43 14.58,15.73 14.48,15.62 13.82,15.62 13.73,15.71 v1(13.73,15.86)
  BOTTOM w0.102: C685.1 15.07,19.34 15.07,18.53 15.45,18.14 15.45,17.96 v1(15.14,17.64) ; CN10.A3 7.68,14.15 7.82,14.01 8.62,14.01 9.43,13.19 11.77,13.19 11.9,13.32 11.9,13.68 11.77,13.8 9.87,13.8 9.5,14.17 9.5,15.2 9.77,15.47 10,15.47 10.14,15.61 RV2.7 RV2.4 11.83,15.61 11.97,15.47 12.07,15.47 12.46,15.86 12.89,15.86 13.14,15.61 13.47,15.61 v1(13.73,15.86)
USB30_TX-_TYPEC1_C: length 3.3
  BOTTOM w0.102: C685.2 14.91,20.71 14.91,20.95 15.17,21.22 16.05,21.22 16.57,21.74 16.79,21.74 16.88,21.84 U6502.11
USB30_TX-_TYPEC2: length 26.9
  TOP w0.102: v1(12.69,17.41) 12.51,17.41 12.4,17.31 12.4,17.13 12.18,16.9 11.92,16.9 11.64,16.62 RV3.4 RV3.7 10.14,16.62 10,16.76 9.73,16.76 9.5,16.98 9.5,17.51 9.02,17.98 5.46,17.98 5.23,17.75 CN10.B3
  IN1 w0.089: v1(17.51,27.06) 17.51,27.25 17.39,27.37 16.02,27.37 13.17,24.52 13.17,19.93 12.97,19.72 12.04,19.72 11.95,19.63 11.95,19.31 12.04,19.23 13.16,19.23 13.37,19.02 13.37,17.91 13.1,17.64 12.77,17.64 12.69,17.55 v1(12.69,17.41)
  BOTTOM w0.102: v1(17.51,27.06) 17.51,27.16 17.65,27.3 17.9,27.3 18.08,27.13 18.08,26.4 C680.1
USB30_TX-_TYPEC2_C: length 2.2
  BOTTOM w0.102: C680.2 17.93,25.12 18.05,25.01 18.05,24.55 18.3,24.29 U6502.16
USB_BC_ON: length 211.5
  TOP w0.102: U14.4 20.88,46.35 v1(20.53,46.01) ; U37.97 197.25,28.82 197.17,28.74 197.17,27.45 195.51,25.79 195.2,25.79 194.64,25.24 194.64,23.46 v2(194.65,23.45)
  IN2 w0.089: v1(20.53,46.01) 20.53,44.48 21.86,43.16 22.76,43.16 27.16,38.76 29.01,38.76 31.58,36.19 31.58,35.27 35.68,31.17 40.58,31.17 40.75,31 40.75,30.95 41.13,30.57 43.9,30.57 44,30.67 46.7,30.67 47.66,31.63 48.93,31.63 48.96,31.61 49.69,31.61 49.85,31.46 53.55,31.46 54.44,32.35 63.69,32.35 64.2,31.84 64.2,31.3 64.53,30.97 65.04,30.97 67.58,33.51 67.58,33.51 67.68,33.62 73.85,33.62 73.9,33.67 75.12,33.67 75.75,34.3 77.1,34.3 79.06,32.35 80.71,32.35 81.19,31.86 81.19,31.11 82.27,30.03 88.31,30.03 88.89,30.61 91.4,30.61 91.85,30.17 92.78,30.17 93.55,30.95 95.72,30.95 96.05,31.28 100.47,31.28 100.8,30.95 101.83,30.95 103.13,29.64 103.88,29.64 104.1,29.42 104.1,28.94 103.77,28.61 103.77,26.69 104.87,25.59 106.1,25.59 108.94,22.75 113.51,22.75 115.22,24.46 119.4,24.46 119.65,24.7 119.65,24.9 120.04,25.29 120.58,25.29 120.8,25.07 121.61,25.07 122.22,24.46 126.96,24.46 127.52,25.02 131.31,25.02 132.73,23.6 144.26,23.6 145.12,24.46 148.78,24.46 151.71,27.39 157.55,27.39 158.03,27.87 158.03,28.76 158.68,29.41 162.25,29.41 163.09,28.57 165.68,28.57 166.18,29.06 168.15,29.06 168.33,29.24 171.6,29.24 172.21,28.63 175.88,28.63 177.22,27.3 186.68,27.3 186.9,27.52 188.27,27.52 189.95,25.84 191.88,25.84 193.46,24.27 194.48,24.27 194.64,24.11 194.64,23.46 v2(194.65,23.45)
USB_CHARGE_ON: length 213.6
  TOP w0.102: U37.96 198.08,28.18 197.7,27.8 197.7,27.33 195.7,25.34 195.39,25.34 195.1,25.05 195.1,24.58 195.45,24.23 195.45,23.71 195.79,23.38 v2(195.79,23.21) ; v1(22.49,47.18) 23.5,47.18 R416.1 23.06,47.74 22.36,47.74 22.22,47.88 U14.5
  IN2 w0.089: v1(22.49,47.18) 23.34,47.18 23.75,46.77 23.75,43.31 27.78,39.28 28.76,39.28 33.27,34.77 34.73,34.77 36.12,33.38 36.12,32.64 37.38,31.38 40.65,31.38 40.96,31.08 40.96,31.02 41.21,30.77 43.83,30.77 43.93,30.87 46.62,30.87 47.59,31.84 49.01,31.84 49.03,31.81 49.77,31.81 49.92,31.66 53.48,31.66 54.35,32.54 65.16,32.54 67.58,34.95 68.41,34.95 68.65,34.71 68.65,34.34 69.18,33.82 73.77,33.82 74.46,34.5 77.18,34.5 79.09,32.59 80.77,32.59 81.39,31.96 81.39,31.17 82.35,30.22 88.23,30.22 88.81,30.8 91.75,30.8 92.08,31.14 94.61,31.14 94.97,31.5 94.97,31.84 95.35,32.22 99.43,32.22 99.57,32.36 99.72,32.36 100.94,31.14 102.77,31.14 104.29,29.61 104.29,28.87 103.96,28.53 103.96,26.77 104.95,25.78 106.18,25.78 107.96,24 114.49,24 115.14,24.65 119.32,24.65 119.45,24.78 119.45,24.98 119.96,25.48 120.66,25.48 120.88,25.26 121.69,25.26 122.3,24.65 126.88,24.65 127.44,25.21 131.39,25.21 132.81,23.79 144.18,23.79 145.04,24.65 148.71,24.65 151.64,27.59 157.48,27.59 157.84,27.95 157.84,28.84 158.6,29.6 162.33,29.6 163.16,28.76 165.6,28.76 166.1,29.25 168.07,29.25 168.25,29.43 171.68,29.43 172.29,28.82 176.09,28.82 177.42,27.49 186.6,27.49 186.83,27.71 188.35,27.71 190.03,26.04 191.96,26.04 193.52,24.47 194.55,24.47 194.59,24.43 195.2,24.43 195.79,23.85 v2(195.79,23.21)
USB_CLT1: length 210.8
  TOP w0.102: U37.79 197.62,21.38 197.31,21.69 197.31,22.04 196.86,22.49 v2(196.69,22.49) ; U14.6 22.54,48.38 22.54,48.37 22.62,48.37 v1(22.79,48.2)
  IN2 w0.089: v1(22.79,48.2) 22.79,47.99 23.94,46.85 23.94,43.39 27.86,39.47 28.84,39.47 33.35,34.96 34.81,34.96 36.31,33.46 36.31,32.75 37.43,31.63 44.13,31.63 44.66,31.1 46.57,31.1 47.51,32.04 49.08,32.04 49.11,32.02 49.85,32.02 50,31.86 53.4,31.86 54.29,32.75 65.11,32.75 67.5,35.14 68.49,35.14 69.07,34.56 69.07,34.2 69.25,34.02 73.16,34.02 73.65,34.5 74.05,34.5 75.27,35.72 78.63,35.72 79.65,34.71 79.65,34.3 80.21,33.74 80.21,33.02 80.45,32.78 80.86,32.78 81.6,32.04 81.6,31.24 82.43,30.41 88.15,30.41 88.73,30.99 91.67,30.99 92.68,32.01 93.45,32.01 94.13,31.33 94.53,31.33 94.78,31.58 94.78,31.94 95.25,32.41 99.35,32.41 99.49,32.55 99.8,32.55 101.02,31.33 102.85,31.33 104.48,29.69 104.48,28.79 104.15,28.45 104.15,26.87 105.05,25.97 106.26,25.97 108.04,24.19 112.23,24.19 113.71,25.67 120.74,25.67 120.96,25.45 121.77,25.45 122.38,24.84 123.7,24.84 124.41,25.56 124.83,25.56 125.55,24.84 126.73,24.84 127.29,25.4 131.47,25.4 132.89,23.98 144.1,23.98 144.96,24.84 148.63,24.84 151.56,27.78 157.4,27.78 157.65,28.03 157.65,28.92 158.52,29.79 162.41,29.79 163.24,28.95 165.52,28.95 166.02,29.44 167.99,29.44 168.17,29.62 171.76,29.62 172.37,29.01 176.17,29.01 177.5,27.68 186.52,27.68 186.75,27.9 188.43,27.9 188.6,27.73 189.55,27.73 190.59,26.69 191.58,26.69 193.6,24.67 194.62,24.67 194.67,24.62 195.28,24.62 196.37,23.54 196.37,22.81 v2(196.69,22.49)
USB_OC0#: length 224.6
  TOP w0.102: v1(17.61,49.62) 17.85,49.38 U14.13
  IN1 w0.089: v1(100.6,60.03) 101.08,60.03 101.31,60.26 101.31,60.92 100.8,61.43 95.01,61.43 94.68,61.76 94.68,61.99 93.91,62.75 93.91,64.07 94.25,64.4 94.25,64.65 94.75,65.16 94.75,65.62 95.54,66.41 95.54,68.34 95.31,68.57 93.46,68.57 93.2,68.82 93.2,69.43 93.91,70.14 93.91,70.9 94.52,71.51 94.52,71.97 95.16,72.6 95.16,72.91 96.1,73.85 96.1,77.18 94.8,78.47 94.8,82.79 95.06,83.04 95.06,85.43 v1(95.67,86.04) ; v1(83.6,90.6) 82.57,90.6 81.33,91.85 78.72,91.85 78.37,92.2 78.37,92.43 75.31,95.49 70.55,95.49 70.04,96 67.81,96 65.34,98.47 63.95,98.47 62.82,99.59 53.37,99.59 52.88,99.1 49.49,99.1 48.93,98.54 47.76,98.54 v1(47.59,98.72)
  IN3 w0.089: v1(100.6,60.03) 100.65,59.98 100.65,53.57 101.63,52.59 102.45,52.59 103.53,51.5 104.34,51.5 105.41,50.43 105.9,50.43 107.47,48.87 107.47,47.63 107.71,47.38 107.71,45.35 107.15,44.79 v1(107.15,44.39) ; v1(17.61,49.62) 16.73,50.5 16.73,53.55 15.53,54.75 15.53,56.2 16.18,56.85 16.46,56.85 17.13,57.52 17.13,58.56 18.86,60.29 19.65,60.29 23.48,64.12 23.48,71.36 18.53,76.31 18.53,78.72 18.12,79.13 18.12,83.45 17.87,83.7 17.87,86.32 19.45,87.91 19.45,88.67 19.7,88.91 19.7,94.95 20.32,95.58 v1(20.32,96.2)
  BOTTOM w0.102: v1(107.15,44.39) 107.26,44.39 108.72,42.93 108.72,41.41 108.44,41.13 105.96,41.13 105.75,40.93 104.57,40.93 103.69,40.05 103.69,38.64 103.54,38.49 103.08,38.49 102.4,39.18 R2514.2 101.35,39.18 101.05,39.49 C2583.1 101.05,40.02 100.79,40.28 98.47,40.28 98.44,40.31 97.4,40.31 U2030.A9 ; v1(83.6,90.6) 83.6,89.67 84.14,89.14 85.29,89.14 85.81,88.62 85.81,88.2 86.76,87.26 89.57,87.26 90.32,86.5 95,86.5 95.47,86.04 v1(95.67,86.04) ; v1(20.32,96.2) 20.32,96.66 22.73,99.07 22.73,100.83 22.02,101.54 21.9,101.66 21.9,102.37 24.27,104.74 25.36,104.74 26.35,103.74 26.35,101.97 28.33,99.99 44.9,99.99 46.17,98.72 v1(47.59,98.72)
