# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LID#_C: length 13.3
  TOP w0.102: v2(181.09,30.63) 181.27,30.46 181.27,30.11 181.39,29.99 R25315.1 181.67,29.7 181.81,29.57 D65.1 C6572.1 ; U37.118 188.85,28.98 v2(189.13,28.7)
  IN2 w0.089: v2(189.13,28.7) 188.11,29.72 183.94,29.72 182.85,30.82 181.27,30.82 v2(181.09,30.63)
LINE1-L: length 17.1
  TOP w0.381: C589.1 209.91,44.09 v1(209.17,44.84)
  IN1 w0.381: v1(209.17,44.84) 208.8,44.84 205.87,41.9 205.51,41.9 200.59,36.98 v1(200.59,34.45)
  BOTTOM w0.203: v1(200.59,34.45) 200.62,34.43 201.02,34.03 U20.22
LINE1-R: length 22.1
  TOP w0.381: v1(211.38,45.84) 211.38,45.16 C594.1
  IN1 w0.381: v1(199.83,34.4) 199.83,33.95 200.14,33.64 200.85,33.64 201.48,34.28 201.48,35.47 202.22,36.21 202.22,37.35 205.88,41.01 206.23,41.01 209.17,43.95 209.54,43.95 211.38,45.79 v1(211.38,45.84)
  BOTTOM w0.203: v1(199.83,34.4) 200.26,33.97 200.64,33.97 200.99,33.63 U20.21
LINE1-VREFO-L: length 17.4
  TOP w0.381: v1(214.91,45.45) 214.04,45.45 R476.2
  IN1 w0.381: v1(204.68,37.88) 204.68,38.55 206.25,40.12 206.6,40.12 209.54,43.06 209.91,43.06 211.56,44.72 212.77,44.72 213.51,45.45 v1(214.91,45.45)
  BOTTOM w0.203: U20.31 204.86,37.7 v1(204.68,37.88)
LINE1-VREFO-R: length 18.8
  TOP w0.381: v1(216.01,42.56) 216.01,43 R477.2
  IN1 w0.381: v1(203.97,37.58) 204.41,37.14 204.94,37.14 205.57,37.77 205.57,38.19 206.61,39.23 206.97,39.23 209.91,42.17 210.27,42.17 211.37,43.27 211.95,43.27 212.22,43.54 213.63,43.54 213.9,43.27 215.63,43.27 216.01,42.89 v1(216.01,42.56)
  BOTTOM w0.203: U20.30 204.46,37.09 v1(203.97,37.58)
LPC_LAD0: length 165.5
  TOP w0.102: U37.10 184,24.58 184.1,24.48 184.1,24.05 184.95,23.2 185.91,23.2 186.5,22.61 187.31,22.61 189.01,20.91 189.4,20.91 191.66,18.65 v2(192.64,18.65)
  IN1 w0.089: v1(66.09,32.69) 66.42,32.69 66.76,32.35 68.39,32.35 68.79,31.94 72.76,31.94 75.63,29.07 75.63,26.91 77,25.54 81.62,25.54 81.93,25.84 87.11,25.84 87.13,25.87 92.19,25.87 94.06,23.99 94.29,23.99 94.94,23.35 95.95,23.35 97.58,21.72 100.61,21.72 101.06,21.28 102.25,21.28 102.78,20.75 110.37,20.75 110.8,20.32 120.07,20.32 120.33,20.58 121.12,20.58 121.64,20.06 124.24,20.06 124.51,20.34 127.35,20.34 128.02,19.67 131.8,19.67 132.12,19.35 137.09,19.35 138.18,20.44 166.33,20.44 166.64,20.13 178.9,20.13 179.09,20.33 180.98,20.33 182.27,19.04 184,19.04 184.4,18.64 186.67,18.64 187.01,18.3 187.46,18.3 189.19,16.57 190.44,16.57 191.45,15.56 196.17,15.56 196.39,15.78 196.39,16.09 195.79,16.7 195.79,16.86 194.57,18.07 194.13,18.07 193.55,18.65 v2(192.64,18.65)
  BOTTOM w0.102: v2(192.64,18.65) 193.69,18.65 193.87,18.47 R673.2 ; v1(66.09,32.69) 66,32.78 66,37.58 66.23,37.81 R2527.2
LPC_LAD1: length 163.5
  TOP w0.102: U37.9 184.11,24.98 184.31,24.78 184.31,24.14 184.95,23.51 186.04,23.51 186.63,22.92 187.43,22.92 189.14,21.21 189.7,21.21 191.86,19.06 192.81,19.06 193.05,18.82 193.05,16.48 v2(193.15,16.38)
  IN1 w0.089: v1(67.01,33.58) 67.41,33.18 70.84,33.18 70.93,33.09 70.93,32.69 71.02,32.6 71.19,32.6 71.28,32.69 71.28,33.09 71.37,33.18 71.55,33.18 71.64,33.09 71.64,32.69 71.73,32.6 71.91,32.6 71.99,32.69 71.99,33.09 72.08,33.18 72.38,33.18 72.86,32.7 72.98,32.7 73.4,33.12 73.52,33.12 73.65,33 73.65,32.87 73.23,32.45 73.23,32.33 73.36,32.2 73.48,32.2 73.9,32.62 74.03,32.62 74.15,32.49 74.15,32.37 73.74,31.95 73.74,31.82 73.86,31.7 73.99,31.7 74.4,32.12 74.53,32.12 74.66,31.99 74.66,31.86 74.24,31.45 74.24,31.32 76.24,29.32 76.24,27.16 77.27,26.14 80.92,26.14 81.24,26.45 86.85,26.45 87.67,27.27 91.65,27.27 94.32,24.6 98.85,24.6 100.42,23.03 100.84,23.03 101.03,22.85 101.03,22.13 101.3,21.86 102.49,21.86 103.02,21.33 111.77,21.33 111.96,21.52 114.13,21.52 114.31,21.33 120.7,21.33 120.82,21.21 124.06,21.21 124.35,21.51 125.58,21.51 126.17,20.92 132.42,20.92 133.41,19.93 136.66,19.93 137.76,21.02 166.57,21.02 166.88,20.72 178.66,20.72 179.06,21.12 181.02,21.12 182.51,19.63 184.24,19.63 184.64,19.23 186.91,19.23 187.25,18.89 187.7,18.89 189.43,17.15 190.69,17.15 191.21,16.62 192.91,16.62 v2(193.15,16.38)
  BOTTOM w0.102: v1(67.01,33.58) 66.51,34.08 66.51,36.56 R2525.2 ; R2662.2 193.15,15.77 v2(193.15,16.38)
LPC_LAD2: length 160.3
  TOP w0.102: U37.8 184.07,25.38 184.52,24.93 184.52,24.25 184.96,23.81 186.97,23.81 189.26,21.52 189.83,21.52 191.98,19.37 192.93,19.37 193.35,18.94 193.35,16.75 193.69,16.41 v2(193.69,16.09)
  IN1 w0.089: v2(193.69,16.09) 193.45,15.85 192.58,15.85 192.21,16.22 191.2,16.22 190.56,16.86 189.31,16.86 187.58,18.59 187.13,18.59 186.79,18.94 184.52,18.94 184.12,19.33 182.39,19.33 180.9,20.83 179.18,20.83 178.78,20.43 166.76,20.43 166.45,20.73 137.88,20.73 136.79,19.64 132.24,19.64 131.92,19.96 128.14,19.96 127.47,20.63 126.04,20.63 125.46,21.21 124.47,21.21 124.13,20.87 120.21,20.87 119.95,20.61 110.92,20.61 110.49,21.04 102.9,21.04 102.37,21.57 101.18,21.57 100.73,22.01 97.7,22.01 96.07,23.64 95.06,23.64 94.41,24.29 94.2,24.29 91.53,26.96 87.79,26.96 86.98,26.15 81.8,26.15 81.49,25.84 77.13,25.84 75.93,27.04 75.93,29.2 72.88,32.24 68.92,32.24 68.44,32.73 67.07,32.73 66.66,33.13 v1(66.56,33.13)
  BOTTOM w0.102: v1(66.56,33.13) 66.51,33.18 66.51,33.56 66.2,33.87 66.2,36.79 R2529.2 ; v2(193.69,16.09) 193.83,15.95 193.83,14.96 R2663.2
LPC_LAD3: length 162.5
  TOP w0.102: U37.7 184.07,25.78 184.75,25.09 186.49,25.09 187.29,24.3 187.29,23.93 189.39,21.82 189.96,21.82 192.11,19.67 193.06,19.67 193.66,19.07 193.66,16.88 194.27,16.27 v2(194.27,15.96)
  IN1 w0.089: v1(67.44,34.05) 68.79,34.05 69.3,33.54 73.52,33.54 75.88,31.18 76.31,31.18 76.54,30.95 76.54,27.29 77.4,26.43 80.8,26.43 81.13,26.76 86.73,26.76 87.54,27.57 91.78,27.57 94.45,24.9 98.97,24.9 100.21,23.66 101.42,23.66 103.45,21.63 111.57,21.63 111.75,21.81 114.25,21.81 114.43,21.63 120.82,21.63 120.94,21.51 123.94,21.51 124.23,21.8 125.7,21.8 126.29,21.21 133.43,21.21 133.84,20.8 137.12,20.8 137.64,21.32 146.86,21.32 147.5,21.95 148.23,21.95 148.86,21.32 151.47,21.32 152.1,21.95 153.48,21.95 154.11,21.32 166.69,21.32 167,21.01 177.22,21.01 178,21.79 180.76,21.79 182.63,19.92 184.36,19.92 184.76,19.52 187.03,19.52 187.37,19.18 187.82,19.18 189.56,17.44 190.81,17.44 191.33,16.92 193.4,16.92 194.27,16.05 v2(194.27,15.96)
  BOTTOM w0.102: R2664.2 193.42,13.86 v1(194.27,14.71) v2(194.27,15.96) ; v1(67.44,34.05) 67.21,34.28 66.91,34.28 66.72,34.47 66.72,36.23 66.82,36.33 R2531.2
LPC_LFRAME#: length 174.5
  TOP w0.102: U37.6 183.98,26.18 184.76,25.4 186.61,25.4 187.59,24.42 187.59,24.06 189.52,22.13 190.08,22.13 192.24,19.98 193.18,19.98 193.96,19.2 193.96,17.17 v2(194.13,17)
  IN1 w0.089: v2(194.13,17) 193.72,17 193.52,17.21 191.46,17.21 190.93,17.74 189.68,17.74 187.94,19.47 187.49,19.47 187.15,19.81 184.88,19.81 184.49,20.21 182.75,20.21 180.88,22.08 177.88,22.08 177.1,21.3 167.12,21.3 166.82,21.61 154.23,21.61 153.6,22.24 147.38,22.24 146.74,21.61 137.39,21.61 136.87,21.09 133.96,21.09 133.55,21.51 126.41,21.51 125.82,22.09 123.34,22.09 123.31,22.06 122.01,22.06 121.76,22.31 120.76,22.31 120.37,21.92 114.55,21.92 114.37,22.1 111.58,22.1 111.4,21.92 103.57,21.92 101.54,23.95 100.33,23.95 99.09,25.19 94.59,25.19 91.91,27.88 87.39,27.88 86.57,27.06 81.02,27.06 80.68,26.72 77.54,26.72 76.85,27.42 76.85,29.53 76.97,29.65 78.74,29.65 78.83,29.74 78.83,29.95 78.71,30.06 76.97,30.06 76.85,30.19 76.85,30.31 76.95,30.42 78.34,30.42 78.47,30.54 78.47,30.69 78.37,30.8 77.13,30.8 76.44,31.48 76.01,31.48 73.65,33.84 69.43,33.84 68.31,34.97 v1(68.31,35.64)
  BOTTOM w0.076: 74.03,42.24 74.23,42.24 74.4,42.41 75.44,42.41 75.47,42.44 U2030.BA12
  BOTTOM w0.102: 74.03,42.24 71.98,42.24 69.76,40.02 69.76,37.65 68.31,36.2 v1(68.31,35.64) ; v2(194.13,17) 194.11,16.98 R675.2
M_A_A0: length 39.5
  IN1 w0.14: v2(52.12,61.23) 52.12,61.7 51.99,61.83 49.79,61.83 49.65,61.97 49.65,62.22 49.8,62.38 51.97,62.38 52.17,62.58 52.17,64.13 53.69,65.66 53.69,67.66 54.49,68.45 62.26,68.45 62.94,67.77 66.18,67.77 69.73,64.21 71.68,64.21 72.26,64.79 v2(72.26,65.03)
  BOTTOM w0.076: U2030.AY50 75.78,64.05 75.74,64.07 75.6,64.16 75.53,64.17 75.47,64.21 75.44,64.21 75.36,64.21 75.32,64.2 75.29,64.19 75.22,64.16 75.21,64.16 75.13,64.15 75.07,64.15 74.97,64.15 74.88,64.18 74.85,64.19 74.81,64.19 74.66,64.2 74.6,64.2 74.41,64.01 73.88,64.01 73.24,64.66 72.95,64.66 72.58,65.03 v2(72.26,65.03)
  BOTTOM w0.165: JDIM2000.144 51.62,60.46 52.12,60.96 v2(52.12,61.23)
M_A_A1: length 43
  TOP w0.165: v2(70.51,65.01) 70.09,65.01 69.96,65.14 68.01,65.14 67.6,64.73 63.48,64.73 62.44,63.69 59.96,63.69 59.79,63.85 59.79,65.55 59.63,65.71 59.3,65.71 59.13,65.55 59.13,63.85 58.97,63.69 58.68,63.69 58.51,63.86 58.51,64.69 58.34,64.85 57.97,64.85 57.79,64.67 57.79,62.23 57.62,62.07 55.73,62.07 55.59,61.93 55.59,61.33 55.39,61.12 55.15,61.12 54.98,61.3 54.98,61.9 54.81,62.07 54.44,62.07 54.28,61.9 54.28,61.29 54.11,61.13 53.87,61.13 53.69,61.31 53.69,62.47 53.89,62.68 54.46,62.68 54.61,62.82 54.61,63.14 54.82,63.35 55.13,63.35 55.3,63.18 55.3,62.85 55.47,62.68 57.01,62.68 57.24,62.91 57.24,63.14 57.09,63.29 55.92,63.29 55.8,63.41 v2(55.8,63.79)
  BOTTOM w0.076: 71.61,64.55 72.76,64.55 72.83,64.49 73.17,64.49 73.81,63.85 74.67,63.85 U2030.BB50
  BOTTOM w0.102: v2(70.51,65.01) 70.51,64.84 70.8,64.55 71.61,64.55
  BOTTOM w0.165: JDIM2000.133 55.98,63.2 55.8,63.38 v2(55.8,63.79)
M_A_A2: length 40.9
  IN1 w0.14: v2(71.68,65.01) 71.21,64.54 70,64.54 66.33,68.21 65.06,68.21 64.92,68.35 64.92,68.69 64.78,68.83 64.5,68.83 64.36,68.69 64.36,68.35 64.22,68.21 63.88,68.21 63.74,68.35 63.74,69.02 63.49,69.28 63.29,69.28 63.19,69.17 63.19,68.61 63.06,68.49 62.86,68.49 62.65,68.7 62.65,69.55 62.51,69.69 62.23,69.69 62.09,69.55 62.09,69.05 61.94,68.9 61.49,68.9 61.35,69.04 61.35,69.55 61.21,69.69 60.93,69.69 60.79,69.55 60.79,69.04 60.65,68.9 57.28,68.9 57.12,69.05 57.12,69.55 56.98,69.69 53.78,69.69 53.24,69.16 53.24,68.96 53.36,68.85 53.78,68.85 53.94,68.69 53.94,68.49 53.78,68.34 53.3,68.34 53.17,68.21 53.17,66.01 v2(52.73,65.57)
  BOTTOM w0.076: U2030.AY51 76.14,64.32 76.03,64.32 75.86,64.29 75.75,64.29 75.58,64.33 75.52,64.36 75.45,64.38 75.34,64.38 75.26,64.36 75.22,64.34 75.17,64.32 75.13,64.32 75.07,64.32 74.99,64.32 74.93,64.33 74.88,64.35 74.65,64.37 74.52,64.35 74.34,64.18 73.95,64.18 73.3,64.82 73.05,64.82 72.44,65.43 72.1,65.43 v2(71.68,65.01)
  BOTTOM w0.165: JDIM2000.132 51.85,63.46 52.73,64.33 v2(52.73,65.57)
M_A_A3: length 44.1
  TOP w0.165: v2(56.39,63.82) 56.97,64.4 56.97,64.6 56.6,64.96 56.6,65.19 56.73,65.32 58.24,65.32 60.03,67.11 60.26,67.11 60.43,66.95 60.43,64.32 60.59,64.16 60.91,64.16 61.09,64.33 61.09,66.51 61.25,66.67 61.58,66.67 61.75,66.51 61.75,64.32 61.91,64.16 62.23,64.16 62.41,64.34 62.41,66.7 62.57,66.87 62.88,66.87 63.07,66.68 63.07,65.62 63.23,65.46 63.56,65.46 63.73,65.62 63.73,66.63 63.89,66.79 64.21,66.79 64.39,66.61 64.39,65.62 64.55,65.46 64.88,65.46 65.05,65.62 65.05,66.63 65.21,66.79 65.54,66.79 65.71,66.62 65.71,65.62 65.87,65.46 66.21,65.46 66.37,65.62 66.37,66.51 66.54,66.67 66.87,66.67 67.03,66.51 67.03,65.62 67.2,65.46 67.53,65.46 67.69,65.62 67.69,66.51 67.86,66.67 69.01,66.67 v2(69.75,65.93)
  BOTTOM w0.076: 71.61,64.32 73.11,64.32 73.81,63.62 74.89,63.62 U2030.BA50
  BOTTOM w0.102: 71.61,64.32 70.42,64.32 69.75,64.99 v2(69.75,65.93)
  BOTTOM w0.165: v2(56.39,63.82) 56.51,63.7 JDIM2000.131
M_A_A4: length 42.1
  IN1 w0.14: v2(70.89,66.23) 71.03,66.23 71.71,66.91 71.71,67.26 69.65,69.33 67.58,69.33 66.35,70.56 64.72,70.56 63.26,72.02 51.19,72.02 50.31,71.13 50.31,67.9 49.32,66.91 47.39,66.91 46.36,65.89 v2(46.36,65.79)
  BOTTOM w0.076: U2030.BB52 74.64,65.35 73.27,65.35 72.7,65.92 71.86,65.92 71.56,66.23
  BOTTOM w0.102: 71.56,66.23 v2(70.89,66.23)
  BOTTOM w0.165: v2(46.36,65.79) 46.36,65.72 47.63,64.46 JDIM2000.128
M_A_A5: length 41.1
  IN1 w0.14: v2(70.24,65.64) 70.24,66.09 69.92,66.42 68.71,66.42 65.86,69.28 64.12,69.28 63.26,70.14 60.44,70.14 60.29,69.99 60.29,69.5 60.15,69.35 59.87,69.35 59.73,69.49 59.73,69.99 59.59,70.13 59.32,70.13 59.18,69.99 59.18,69.5 59.03,69.35 58.76,69.35 58.62,69.49 58.62,69.99 58.47,70.13 58.28,70.13 58.14,69.99 58.14,69.5 57.97,69.34 57.74,69.34 57.6,69.48 57.6,69.97 57.43,70.14 53.63,70.14 52.75,69.26 52.75,67 51.86,66.11 50.8,66.11 49.96,65.28 49.96,65.08 50.15,64.89 52.02,64.89 52.14,65.02 v2(52.14,65.62)
  BOTTOM w0.076: U2030.BA51 75.56,64.74 arc(75.55,64.76) 75.53,64.77 75.25,64.82 75.18,64.85 75.11,64.85 75.08,64.86 75.01,64.85 74.94,64.84 74.87,64.82 74.84,64.82 arc(74.84,64.82) 74.83,64.82 74.75,64.81 arc(74.74,64.8) 74.72,64.8 74.44,64.8 74.23,65.01 73.9,65.01 73.88,64.99 73.16,64.99 72.56,65.59 71.65,65.59 71.48,65.43 71.17,65.43
  BOTTOM w0.102: v2(70.24,65.64) 70.46,65.43 71.17,65.43
  BOTTOM w0.165: JDIM2000.126 51.99,64.95 52.14,65.11 v2(52.14,65.62)
M_A_A6: length 44.5
  TOP w0.165: v2(55.81,65.8) 55.81,66.17 55.89,66.24 57.6,66.24 62.57,71.21 63.8,71.21 63.97,71.05 63.97,69.25 64.13,69.09 64.44,69.09 64.63,69.28 64.63,71.05 64.79,71.21 65.12,71.21 65.29,71.05 65.29,69.25 65.45,69.09 65.76,69.09 65.95,69.28 65.95,71.05 66.11,71.21 66.44,71.21 66.61,71.05 66.61,69.25 66.77,69.09 67.08,69.09 67.27,69.28 67.27,71.05 67.43,71.21 67.76,71.21 67.93,71.05 67.93,69.47 68.09,69.3 68.39,69.3 68.59,69.5 68.59,71.05 68.75,71.21 69.22,71.21 69.39,71.05 69.39,67.9 70.05,67.23 70.48,67.23 71.4,66.32 v2(72.12,66.32)
  BOTTOM w0.076: v2(72.12,66.32) 72.54,66.32 73.34,65.51 74.91,65.51 75.17,65.25 U2030.BA52
  BOTTOM w0.165: JDIM2000.127 56.74,64.7 55.81,65.63 v2(55.81,65.8)
M_A_A7: length 42.5
  IN1 w0.14: v2(70.47,66.64) 70.38,66.64 69.83,67.19 68.53,67.19 66,69.72 64.3,69.72 63.44,70.58 62.89,70.58 62.75,70.72 62.75,70.99 62.61,71.13 62.33,71.13 62.19,70.99 62.19,70.72 62.05,70.58 61.78,70.58 61.64,70.72 61.64,70.99 61.5,71.13 61.22,71.13 61.08,70.99 61.08,70.72 60.94,70.58 60.66,70.58 60.52,70.72 60.52,70.99 60.38,71.13 60.1,71.13 59.96,70.99 59.96,70.72 59.82,70.58 59.54,70.58 59.4,70.72 59.4,70.99 59.26,71.13 58.98,71.13 58.84,70.99 58.84,70.72 58.7,70.58 58.42,70.58 58.28,70.72 58.28,70.99 58.14,71.13 57.86,71.13 57.72,70.99 57.72,70.72 57.58,70.58 53.44,70.58 53.31,70.44 52.4,70.44 52.23,70.28 52.23,69.42 52.09,69.28 51.49,69.28 51.35,69.14 51.35,68.88 51.49,68.74 52.11,68.74 52.23,68.61 52.23,68.31 52.08,68.15 51.47,68.15 51.32,68.01 51.32,67.81 51.46,67.67 52,67.67 52.23,67.43 52.23,67.12 51.78,66.66 50.67,66.66 49.92,65.9 48.89,65.9 v2(48.75,65.77)
  BOTTOM w0.076: U2030.AW52 76.51,65.15 76.18,65.47 75.64,65.47 75.43,65.68 73.42,65.68 72.3,66.8 71.77,66.8 71.61,66.64
  BOTTOM w0.102: 71.61,66.64 v2(70.47,66.64)
  BOTTOM w0.165: JDIM2000.122 48.94,65.95 v2(48.75,65.77)
M_A_A8: length 44.3
  TOP w0.165: v2(56.98,65.8) 57.82,65.8 60.18,68.15 60.57,68.15 60.74,67.99 60.74,67.3 60.9,67.14 61.19,67.14 61.39,67.34 61.39,69.36 61.56,69.52 61.86,69.52 62.05,69.33 62.05,67.5 62.22,67.33 62.52,67.33 62.71,67.52 62.71,70.53 62.91,70.73 63.21,70.73 63.37,70.57 63.37,67.43 63.54,67.26 63.87,67.26 64.03,67.43 64.03,68.34 64.22,68.53 64.53,68.53 64.69,68.37 64.69,67.43 64.86,67.26 65.19,67.26 65.35,67.43 65.35,68.42 65.54,68.61 65.85,68.61 66.01,68.44 66.01,67.43 66.18,67.26 66.51,67.26 66.68,67.43 66.68,68.46 66.84,68.63 67.12,68.63 67.29,68.46 67.29,67.34 67.44,67.19 67.77,67.19 67.91,67.33 67.91,68.69 68.08,68.86 68.38,68.86 68.56,68.68 68.56,67.32 68.73,67.15 69.34,67.15 70.8,65.7 71.2,65.7 v2(71.33,65.83)
  BOTTOM w0.076: v2(71.33,65.83) 71.4,65.76 72.63,65.76 73.23,65.16 73.81,65.16 73.83,65.18 74.3,65.18 74.5,64.98 74.72,64.97 arc(74.73,64.97) 74.73,64.97 74.81,64.98 arc(74.83,64.98) 74.84,64.98 74.9,65 74.99,65.02 75.08,65.02 75.13,65.02 75.22,65.01 75.29,64.98 75.45,64.95 75.61,64.98 75.74,64.98 U2030.AY52
  BOTTOM w0.165: JDIM2000.125 57.22,65.2 56.98,65.44 v2(56.98,65.8)
M_A_A9: length 44.7
  TOP w0.165: v2(69.98,68.31) 69.98,69.62 71.87,71.52 71.87,72.32 71.41,72.78 67.39,72.78 67.2,72.59 67.2,72.08 67.03,71.91 66.78,71.91 66.62,72.07 66.62,74.09 66.41,74.3 66.17,74.3 65.99,74.11 65.99,71.96 65.81,71.78 65.55,71.78 65.38,71.95 65.38,74.09 65.22,74.25 64.92,74.25 64.75,74.09 64.75,72.04 64.56,71.84 64.32,71.84 64.13,72.04 64.13,72.84 63.94,73.02 63.65,73.02 63.48,72.86 63.48,72.07 63.32,71.91 62.51,71.91 57.29,66.69 55.76,66.69 v2(55.31,67.14)
  BOTTOM w0.076: U2030.BB54 74.67,66.2 73.66,66.2 71.94,67.92
  BOTTOM w0.102: v2(69.98,68.31) 70.09,68.41 71.45,68.41 71.94,67.92
  BOTTOM w0.165: JDIM2000.121 57.54,66.2 57.36,66.39 56.06,66.39 v2(55.31,67.14)
M_A_A10: length 41.6
  IN1 w0.14: v2(78.19,63.58) 78.58,63.19 78.85,63.19 78.99,63.32 78.99,64.66 78.85,64.8 78.55,64.8 78.42,64.67 78.42,64.42 78.27,64.26 77.99,64.26 77.84,64.41 77.84,64.56 77.7,64.7 77.39,64.7 76.42,63.73 76.18,63.73 75.65,63.2 75.65,62.64 74.43,61.42 68.73,61.42 65.13,65.01 59.37,65.01 57.07,62.71 55.56,62.71 51.78,58.94 51.78,58.25 52.73,57.3 v2(52.73,57.09)
  BOTTOM w0.102: JDIM2000.146 52,57.95 52.73,57.22 v2(52.73,57.09)
  BOTTOM w0.165: U2030.AT50 78.37,63.8 78.19,63.62 v2(78.19,63.58)
M_A_A11: length 40.4
  IN1 w0.14: v2(70.42,67.9) 69.48,67.9 69.33,68.06 69.33,68.26 69.2,68.39 68.92,68.39 68.79,68.26 68.79,68.03 68.67,67.9 68.41,67.9 66.18,70.14 64.51,70.14 63.08,71.58 54.58,71.58 54.44,71.44 54.44,71.17 54.3,71.03 54.02,71.03 53.88,71.17 53.88,71.44 53.74,71.58 51.51,71.58 50.87,70.94 50.87,70.52 50.99,70.4 51.54,70.4 51.68,70.26 51.68,69.97 51.54,69.83 51.07,69.83 50.87,69.63 50.87,67.49 49.73,66.35 48.08,66.35 v2(47.53,65.8)
  BOTTOM w0.076: 72.08,67.47 72.22,67.34 72.29,67.34 73.62,66.01 74.92,66.01 75.07,66.16 75.07,66.16 75.18,66.28 U2030.BA54
  BOTTOM w0.102: 72.08,67.47 71.56,67.99 70.52,67.99 70.44,67.9 v2(70.42,67.9)
  BOTTOM w0.165: JDIM2000.120 48.19,66.46 v2(47.53,65.8)
M_A_A12: length 44.8
  TOP w0.165: v2(56.48,67.14) 56.48,67.55 56.79,67.85 57.65,67.85 64.43,74.63 64.43,76.77 64.59,76.94 65.02,76.94 65.21,76.75 65.21,74.94 65.38,74.78 65.71,74.78 65.87,74.94 65.87,76.67 66.04,76.84 66.32,76.84 66.51,76.65 66.51,74.82 66.7,74.64 66.94,74.64 67.09,74.79 67.09,75.07 67.25,75.22 67.48,75.22 67.65,75.05 67.65,73.44 67.87,73.23 71.59,73.23 72.53,72.29 72.53,71.55 70.55,69.56 70.55,68.49 71.29,67.75 v2(71.29,67.09)
  BOTTOM w0.076: 71.61,67.09 72.25,67.09 73.5,65.84 75.4,65.84 75.62,66.07 76.17,66.07 76.48,66.38 U2030.AW54
  BOTTOM w0.102: 71.61,67.09 v2(71.29,67.09)
  BOTTOM w0.165: JDIM2000.119 57.51,66.7 57.46,66.65 56.71,66.65 56.48,66.88 v2(56.48,67.14)
M_A_A13: length 43.9
  IN1 w0.14: v2(77.5,61.71) 76.42,61.71 75.19,60.48 73.89,60.48 73.35,59.95 68.42,59.95 65.25,63.12 64.69,63.68 59.92,63.68 54.34,58.1 54.34,56.56 53.97,56.18 53.97,55.04 53.63,54.71 53.63,54.07 53.92,53.78 54.86,53.78 54.96,53.68 54.96,53.47 54.85,53.35 53.63,53.35 53.25,52.98 51.29,52.98 51.12,53.14 51.12,53.86 51.26,54 52.28,54 52.31,54.03 52.33,54.03 52.58,54.27 52.58,54.3 v2(52.74,54.46)
  BOTTOM w0.165: JDIM2000.158 52.46,54.95 52.74,54.68 v2(52.74,54.46) ; U2030.AU46 77.86,62.12 77.5,61.76 v2(77.5,61.71)
M_A_ACT#: length 39.4
  IN1 w0.14: v2(47.79,68.99) 47.79,69.16 48.28,69.66 48.28,71.93 51.14,74.79 60.86,74.79 61,74.65 61,74.21 61.14,74.07 61.4,74.07 61.56,74.24 61.56,74.4 61.7,74.54 61.98,74.54 62.12,74.4 62.12,74.21 62.26,74.07 63.96,74.07 65.65,72.38 66.23,72.38 67.39,71.22 70.35,71.22 73.7,67.87 73.7,67.37 v2(73.62,67.29)
  BOTTOM w0.076: U2030.BA55 75.49,67.17 75.26,67.17 75.13,67.22 75.02,67.22 74.88,67.17 74.4,67.17 74.25,67.32 74.05,67.32 73.98,67.39 73.72,67.39 v2(73.62,67.29)
  BOTTOM w0.165: JDIM2000.114 49.23,67.95 48.84,68.34 48.25,68.34 47.79,68.79 v2(47.79,68.99)
M_A_ALERT#: length 49.2
  TOP w0.165: v2(73.28,63.59) 73.28,62.82 71.88,61.42 67.84,61.42 66.36,62.9 R2186.1
  IN1 w0.14: v2(73.28,63.59) 73.28,66.66 70.03,69.91 67.6,69.91 66.31,71.21 64.99,71.21 63.53,72.67 58.06,72.67 57.23,73.49 51.75,73.49 49.66,71.4 49.66,68.17 v2(48.95,67.45)
  BOTTOM w0.076: U2030.AW50 76.37,63.66 76.18,63.66 76.16,63.63 75.88,63.63 75.83,63.68 75.6,63.68 75.3,63.38 73.48,63.38 v2(73.28,63.59)
  BOTTOM w0.165: JDIM2000.116 48.95,67.46 v2(48.95,67.45)
M_A_BA#0: length 40.4
  IN1 w0.14: v2(77.54,65.33) 77.3,65.33 76.88,64.91 76.68,64.91 76.43,65.16 76.23,65.16 76.07,64.99 76.07,64.73 76.29,64.51 76.29,64.31 75.3,63.32 75.3,62.79 74.18,61.68 69.06,61.68 65.28,65.46 59.18,65.46 56.95,63.23 55.45,63.23 54.88,62.66 54.68,62.66 54.48,62.86 54.28,62.86 54.08,62.66 54.08,62.46 54.28,62.26 54.28,62.06 54.09,61.87 53.89,61.87 53.12,62.64 52.92,62.64 52.77,62.49 52.77,62.2 53.49,61.47 53.49,61.27 51.29,59.07 51.29,57.39 v2(51.56,57.12)
  BOTTOM w0.165: U2030.AU52 v2(77.54,65.33) ; v2(51.56,57.12) 51.4,56.95 JDIM2000.150
M_A_BA#1: length 46.1
  TOP w0.165: v2(78.17,62.64) 78.48,62.95 78.48,62.96 78.9,63.38 78.9,64.4 78.75,64.55 78.4,64.55 78.07,64.22 76.76,64.22 75.98,65.01 75.98,66.82 75.86,66.94 75.55,66.94 75.37,66.76 75.37,65.8 75.2,65.62 73.8,65.62 73.29,65.11 73.29,64.43 73.06,64.2 69.9,64.2 69.73,64.03 69.73,63.47 69.57,63.31 68.34,63.31 68.13,63.11 68.13,62.88 68.36,62.65 71.65,62.65 71.79,62.51 71.79,62.28 71.6,62.09 68.12,62.09 66.42,63.79 63.87,63.79 62.83,62.75 59.08,62.75 58.73,62.39 58.73,61.63 58.02,60.92 56.72,60.92 56.3,60.5 v2(55.49,60.5)
  BOTTOM w0.165: v2(55.49,60.5) 55.49,59.88 57.16,58.2 JDIM2000.145 ; U2030.AT48 78.17,62.69 v2(78.17,62.64)
M_A_BG#0: length 44.1
  TOP w0.165: v2(54.33,69.2) 54.33,68.93 54.69,68.57 v1(55.08,68.57) 55.21,68.44 57.58,68.44 63.82,74.68 63.82,77.22 63.98,77.38 66.74,77.38 66.96,77.17 66.96,76.55 68.1,75.41 68.1,74.12 68.55,73.67 71.78,73.67 73.02,72.43 73.02,71.4 71.03,69.42 71.03,68.64 72.4,67.27 72.76,67.27 v2(73.17,67.69)
  BOTTOM w0.076: U2030.AY55 76.27,67.04 75.98,66.75 75.82,66.67 75.64,66.67 75.48,66.73 75.34,66.73 75.12,66.66 75,66.66 74.92,66.69 74.87,66.72 74.46,66.72 74.27,66.53 73.8,66.53 73.17,67.16 v2(73.17,67.69)
  BOTTOM w0.165: v2(54.33,69.2) 54.33,68.93 55.55,67.7 JDIM2000.115
M_A_BG#1: length 44.5
  TOP w0.165: v2(72.76,68.1) 73.45,68.8 73.45,69.51 75.09,71.16 75.09,72.26 71.97,75.38 71.97,76.14 71.67,76.44 68.97,76.44 68.3,77.11 68.3,79.4 68.09,79.61 62.74,79.61 62.4,79.27 62.4,75.17 57.32,70.09 56.21,70.09 55.83,69.71 55.82,69.71 55.5,69.38 v2(55.5,69.2)
  BOTTOM w0.076: U2030.AY54 75.82,66.43 75.47,66.55 75.34,66.55 75.11,66.49 74.97,66.49 74.84,66.55 74.53,66.55 74.35,66.37 73.73,66.37 72.63,67.47 72.63,67.97 v2(72.76,68.1)
  BOTTOM w0.165: v2(55.5,69.2) 55.5,69.07 56.36,68.2 JDIM2000.113
M_A_CAS#: length 41.9
  IN1 w0.14: v2(77.5,62.65) 77.01,62.17 76.3,62.17 74.99,60.86 73.82,60.86 73.18,60.22 69.6,60.22 69.45,60.36 69.45,60.51 69.33,60.64 69.13,60.64 69.02,60.53 69.02,60.35 68.9,60.22 68.74,60.22 64.84,64.13 59.74,64.13 53.88,58.27 53.88,56.73 53.52,56.37 53.52,55.31 53.15,54.95 50.58,54.95 50.42,55.1 50.42,55.36 50.59,55.53 52.26,55.53 v2(52.74,56.02)
  BOTTOM w0.165: v2(77.5,62.65) 77.5,62.67 U2030.AU48 ; v2(52.74,56.02) 52.74,55.8 52.4,55.46 JDIM2000.156
M_A_CB0: length 4.2
  TOP w0.102: R2172.2 49.37,74.47 48.85,74.47 v2(48.33,73.95)
  BOTTOM w0.102: v2(48.33,73.95) 48.83,73.46 JDIM2000.92
M_A_CB1: length 4.1
  TOP w0.102: R2168.2 v2(55.84,73.04)
  BOTTOM w0.102: v2(55.84,73.04) 55.84,73.27 56.41,73.84 57.33,73.84 57.47,73.7 JDIM2000.91
M_A_CB2: length 2.5
  TOP w0.102: R2176.2 56.96,71.7 v2(56.96,71.08)
  BOTTOM w0.102: JDIM2000.101 57.08,71.2 v2(56.96,71.08)
M_A_CB3: length 4.6
  TOP w0.102: v2(55.21,71.08) 55.21,71.48 R2178.2
  BOTTOM w0.102: v2(55.21,71.08) 56.09,70.2 JDIM2000.105
M_A_CB4: length 4.4
  TOP w0.102: v2(48.31,75) 48.31,75.21 49.31,76.21 R2167.2
  BOTTOM w0.102: JDIM2000.88 48.86,74.46 v2(48.31,75)
M_A_CB5: length 5.7
  TOP w0.102: R2169.2 54.71,73.11 v2(54.67,73.07)
  BOTTOM w0.102: JDIM2000.87 55.71,74.7 54.67,73.67 v2(54.67,73.07)
M_A_CB6: length 4.3
  TOP w0.102: v2(52.74,72.53) 52.74,72.68 52.69,72.73 R2179.2
  BOTTOM w0.102: v2(52.74,72.53) 52.74,72.38 51.82,71.46 JDIM2000.100
M_A_CB7: length 2.5
  TOP w0.102: R2180.2 51.8,70.86 v2(51.7,70.96)
  BOTTOM w0.102: JDIM2000.104 51.43,70.46 51.7,70.73 v2(51.7,70.96)
M_A_CKE0: length 39.8
  TOP w0.165: v2(72.38,68.55) 72.68,68.85 72.68,70.12 73.8,71.24 73.8,72.6 71.44,74.97 69.49,74.97 67.63,76.83 67.63,78.8 67.5,78.93 67.07,78.93 66.91,78.78 66.91,78.23 66.74,78.06 66.28,78.06 66.1,78.23 66.1,78.77 65.94,78.93 65.52,78.93 65.37,78.78 65.37,78.22 65.2,78.06 64.66,78.06 64.5,78.22 64.5,78.83 64.4,78.93 63.97,78.93 63.84,78.8 63.84,78.19 63.09,77.44 63.09,74.91 57.41,69.23 56.68,69.23 v2(56.67,69.22)
  BOTTOM w0.076: v2(72.38,68.55) 72.55,68.72 72.93,68.72 74.17,67.49 74.39,67.49 74.54,67.34 74.85,67.34 74.99,67.39 75.18,67.39 U2030.BA56
  BOTTOM w0.165: v2(56.67,69.22) 56.68,69.2 JDIM2000.109
M_A_CKE1: length 35.8
  IN1 w0.14: v2(71.96,68.98) 71.96,69.01 70.42,70.55 67.52,70.55 66.22,71.86 65.26,71.86 63.8,73.32 60.53,73.32 60.39,73.46 60.39,73.85 60.25,73.99 59.98,73.99 59.83,73.85 59.83,73.46 59.69,73.32 59.45,73.32 59.31,73.46 59.31,73.84 59.17,73.98 58.89,73.98 58.75,73.84 58.75,73.46 58.61,73.32 58.33,73.32 57.5,74.14 51.41,74.14 48.97,71.7 48.97,69.05 48.98,69.04 48.98,69 v2(48.96,68.99)
  BOTTOM w0.076: 72.69,69.24 74.28,67.66 74.69,67.66 U2030.BB56
  BOTTOM w0.102: v2(71.96,68.98) 72.23,69.24 72.69,69.24
  BOTTOM w0.165: JDIM2000.110 49,68.95 v2(48.96,68.99)
M_A_CLK0: length 38.9
  IN1 w0.089: v2(55.22,63.81) 54.99,63.81 54.85,63.95 54.85,64.39 55.33,64.87 55.33,66.08 55.48,66.23 57.46,66.23 57.66,66.44 57.66,66.74 57.75,66.83 58.18,66.83 58.27,66.74 58.27,66.28 58.48,66.08 59.1,66.08 59.34,66.31 59.34,66.69 59.43,66.78 59.85,66.78 59.94,66.69 59.94,66.46 60.17,66.23 60.79,66.23 61,66.44 61,66.68 61.13,66.81 61.52,66.81 61.61,66.72 61.61,66.44 61.91,66.14 65.51,66.14 69.64,62 73.25,62 73.95,62.7 74.19,62.7 75.45,63.96 75.45,65.54 76.4,66.48 76.65,66.48 76.81,66.33 76.81,66.12 77.2,65.73 77.63,65.73 77.93,66.02 77.96,66.02 v2(78.17,66.24)
  BOTTOM w0.102: v2(55.22,63.81) 54.95,63.81 54.88,63.73 54.88,63.56 56.36,62.08 57.45,62.08 57.58,62.2 JDIM2000.137
  BOTTOM w0.114: v2(78.17,66.24) 78.35,65.99 U2030.AT53
M_A_CLK0#: length 38.8
  IN1 w0.089: v2(54.45,63.81) 54.65,64 54.65,64.48 55.13,64.96 55.13,66.16 55.4,66.43 57.37,66.43 57.46,66.52 57.46,66.82 57.67,67.03 58.26,67.03 58.47,66.82 58.47,66.37 58.56,66.28 59.02,66.28 59.14,66.4 59.14,66.78 59.35,66.99 59.94,66.99 60.14,66.78 60.14,66.55 60.26,66.43 60.7,66.43 60.79,66.52 60.79,66.76 61.05,67.01 61.6,67.01 61.81,66.81 61.81,66.52 61.99,66.34 65.59,66.34 69.73,62.21 73.17,62.21 73.86,62.9 74.1,62.9 75.25,64.04 75.25,65.62 76.31,66.69 76.74,66.69 77.01,66.41 77.01,66.2 77.28,65.93 77.54,65.93 77.63,66.02 77.63,66.15 77.54,66.24 v2(77.54,66.24)
  BOTTOM w0.102: JDIM2000.139 57.56,61.7 57.39,61.88 56.27,61.88 54.68,63.47 54.68,63.58 v2(54.45,63.81)
  BOTTOM w0.114: U2030.AU53 77.64,65.78 77.54,65.87 v2(77.54,66.24)
M_A_CLK1: length 38.7
  IN1 w0.089: v2(52.93,63.76) 53.17,64 53.17,64.25 54.32,65.4 54.32,67.28 54.87,67.83 62,67.83 62.69,67.14 65.92,67.14 70.36,62.71 73.07,62.71 74.51,64.15 74.51,65.97 76.2,67.67 77.7,67.67 v2(78.19,67.18)
  BOTTOM w0.102: v2(52.93,63.76) 53.06,63.62 53.22,63.46 53.22,62.7 52.48,61.95 JDIM2000.138
  BOTTOM w0.114: v2(78.19,67.18) 78.19,67.02 U2030.AT55
M_A_CLK1#: length 38.7
  IN1 w0.089: v2(77.53,67.18) 77.53,67.38 77.44,67.46 76.29,67.46 74.71,65.89 74.71,64.06 73.16,62.5 70.28,62.5 65.84,66.94 62.6,66.94 61.92,67.63 54.95,67.63 54.52,67.19 54.52,65.31 53.37,64.17 53.37,63.86 53.48,63.76 v2(53.69,63.76)
  BOTTOM w0.102: JDIM2000.140 51.1,61.46 51.39,61.75 52.56,61.75 53.42,62.61 53.42,63.66 53.52,63.76 v2(53.69,63.76)
  BOTTOM w0.114: v2(77.53,67.18) 77.42,67.08 77.42,66.82 77.55,66.69 77.61,66.69 U2030.AU55
M_A_CS#0: length 41.3
  IN1 w0.079: v2(78.2,60.78) 77.83,61.16 77.2,61.16 77.04,61
  IN1 w0.14: 77.04,61 75.73,59.69 74.96,59.69 74.54,59.28 74.54,57.98 74.36,57.8 74.08,57.8 73.9,57.97 73.9,59.24 73.75,59.39 67.95,59.39 67.27,60.07 61.99,60.07 61.78,60.29 61.78,60.49 61.93,60.64 62.45,60.64 62.55,60.74 62.55,60.95 62.39,61.1 59.68,61.1 59.38,61.4 59.18,61.4 58.92,61.14 58.92,60.94 59.17,60.7 59.17,60.5 58.99,60.32 58.72,60.32 58.51,60.53 58.32,60.53 57.87,60.09 57.87,59.85 58.46,59.27 58.46,59.07 58.32,58.93 58.12,58.93 57.51,59.54 57.33,59.54 57.13,59.35 57.13,59.13 57.72,58.54 57.72,58.34 57.58,58.2 57.27,58.2 56.73,58.74 56.52,58.74 56.35,58.56 56.35,58.37 56.97,57.74 56.97,57.59 56.83,57.44 56.59,57.44 56,58.04 55.82,58.04 55.64,57.85 55.64,57.64 56.06,57.22 v2(56.06,57.13)
  BOTTOM w0.165: U2030.AU45 77.88,61.21 v2(78.2,60.78) ; JDIM2000.149 57.53,57.2 56.95,56.63 56.55,56.63 56.14,57.04 56.14,57.06 v2(56.06,57.13)
M_A_CS#1: length 42.7
  IN1 w0.14: v2(77.57,60.76) 77.36,60.76 75.62,59.02 75.08,59.02 74.95,58.89 74.95,58.6 75.09,58.46 75.36,58.46 75.47,58.35 75.47,57.99 75.33,57.85 74.96,57.85 74.85,57.73 74.85,57.45 75.01,57.29 75.33,57.29 75.47,57.15 75.47,55.2 75.3,55.03 75.04,55.03 74.88,55.19 74.88,56.67 74.76,56.79 74.44,56.79 74.27,56.62 74.27,56.14 74.16,56.02 73.92,56.02 73.67,56.27 73.67,57.51 72.78,58.4 69.02,58.4 68.46,58.96 67.73,58.96 67.03,59.65 61.58,59.65 61.4,59.83 61.4,60.11 61.23,60.28 60.97,60.28 60.84,60.15 60.84,59.75 60.57,59.48 59.49,59.48 56.63,56.62 55.32,56.62 54.61,55.91 54.61,54.68 v2(54.38,54.45)
  BOTTOM w0.165: v2(54.38,54.45) 54.83,54.9 57.26,54.9 57.57,55.2 JDIM2000.157 ; v2(77.57,60.76) 77.86,60.32 U2030.AU43
M_A_DQ0: length 49.7
  IN1 w0.089: v2(57.15,96.27) 58.21,96.27 60.2,94.28 67.58,94.28 68.39,93.48 73.43,93.48 75.63,91.28 75.63,88.73 75.9,88.45 75.9,88.33 75.63,88.06 75.63,87.91 75.73,87.81 75.88,87.81 76.15,88.08 76.27,88.08 76.4,87.95 76.4,87.83 75.85,87.28 75.85,87.13 75.93,87.06 76.14,87.06 76.65,87.57 76.78,87.57 76.9,87.45 76.9,87.32 76.71,87.13 76.71,87.03 76.84,86.9 76.99,86.9 77.16,87.07 77.28,87.07 77.41,86.94 77.41,86.82 77.21,86.63 77.21,86.5 77.34,86.37 77.46,86.37 77.66,86.57 77.78,86.57 77.91,86.44 77.91,86.32 77.74,86.15 77.74,86.02 77.87,85.9 77.99,85.9 78.16,86.07 78.29,86.07 78.41,85.94 78.41,85.81 78.24,85.64 78.24,85.52 78.37,85.4 78.5,85.4 78.66,85.56 78.79,85.56 78.92,85.44 78.92,85.31 78.76,85.15 78.76,85.04 78.89,84.92 79.03,84.92 79.17,85.06 79.29,85.06 79.42,84.93 79.42,84.81 79.28,84.67 79.28,84.54 79.4,84.41 79.53,84.41 79.67,84.56 79.8,84.56 81.24,83.12 81.24,82.94 81.04,82.74 81.04,82.61 81.16,82.49 81.32,82.49 81.52,82.69 81.66,82.69 81.85,82.5 81.85,82.36 81.2,81.71 81.2,81.53 81.32,81.42 81.49,81.42 82.13,82.05 82.3,82.05 82.46,81.89 82.46,81.76 81.91,81.2 81.91,80.81 v2(82.28,80.44)
  BOTTOM w0.076: 81.64,78.06 81.64,78.01 81.54,77.91 81.54,76.6 81.57,76.58 U2030.AL71
  BOTTOM w0.102: 81.64,78.06 81.64,78.06 81.64,79.8 v2(82.28,80.44) ; v2(57.15,96.27) 57.15,96.15 57.59,95.7 JDIM2000.3
M_A_DQ1: length 51.5
  IN1 w0.089: v2(52.71,95.47) 54.76,95.47 56.24,96.95 59.21,96.95 60.02,96.14 62.18,96.14 63.43,94.89 67.83,94.89 68.64,94.09 74,94.09 76.94,91.15 76.94,88.27 83.13,82.08 83.13,80.24 82.79,79.89 82.79,79.19 v2(82.4,78.8)
  BOTTOM w0.076: U2030.AL68 81.88,74.05 82.38,74.05 82.53,74.19 82.53,76.03 82.46,76.18 82.46,77.04 82.73,77.31 82.73,77.9 82.81,77.98 82.81,78.1
  BOTTOM w0.102: JDIM2000.8 51.69,94.45 v2(52.71,95.47) ; v2(82.4,78.8) 82.59,78.8 82.81,78.58 82.81,78.1
M_A_DQ2: length 51.3
  IN1 w0.089: v2(80.62,80.02) 79.53,81.1 78.73,81.1 74.65,85.19 71.13,85.19 68.16,88.16 68.16,89.29 66.98,90.47 66.98,90.63 67.35,90.99 67.35,91.13 67.26,91.22 67.12,91.22 66.72,90.83 66.62,90.83 66.51,90.94 66.51,91.07 66.86,91.43 66.86,91.57 66.75,91.68 66.62,91.68 65.5,90.56 65.36,90.56 65.23,90.69 65.23,90.79 66.42,91.98 66.42,92.08 66.29,92.2 66.14,92.2 64.88,90.94 64.73,90.94 64.6,91.07 64.6,91.17 65.58,92.15 65.58,92.33 65.46,92.45 65.29,92.45 64.36,91.53 64.22,91.53 64.1,91.65 64.1,91.78 64.55,92.24 64.55,92.37 64.47,92.45 59.49,92.45 58.65,93.3 56.47,93.3 v2(55.85,92.68)
  BOTTOM w0.076: U2030.AN68 80.34,74.57 80.05,74.87 80.05,75.43 79.83,75.64 79.83,76.64 79.83,76.64 79.83,77.54 79.99,77.7 79.99,78.31 80.01,78.32
  BOTTOM w0.102: JDIM2000.21 57.56,91.21 57.16,91.6 56.78,91.6 55.85,92.54 v2(55.85,92.68) ; v2(80.62,80.02) 80.34,80.02 80.01,79.68 80.01,78.32
M_A_DQ3: length 50.2
  IN1 w0.089: v2(51.7,92.68) 51.7,92.83 52.86,93.98 58.83,93.98 59.75,93.06 66.42,93.06 66.58,92.9 66.73,92.9 66.93,93.1 67.09,93.1 68.77,91.42 68.77,88.41 71.38,85.8 71.68,85.8 71.77,85.89 71.77,86.36 71.86,86.45 72.04,86.45 72.13,86.36 72.13,85.89 72.22,85.8 72.4,85.8 72.48,85.89 72.48,86.43 72.57,86.52 72.75,86.52 72.84,86.43 72.84,85.89 72.93,85.8 73.11,85.8 73.2,85.89 73.2,86.41 73.29,86.5 73.46,86.5 73.55,86.41 73.55,85.89 73.64,85.8 73.82,85.8 73.91,85.89 73.91,86.41 74,86.5 74.17,86.5 74.26,86.41 74.26,85.89 74.35,85.8 74.9,85.8 78.99,81.71 79.99,81.71 81.43,80.27 81.43,78.37 v2(80.73,77.67)
  BOTTOM w0.076: v2(80.73,77.67) 80.35,77.29 80.35,76.92 80.68,76.59 80.68,76.17 80.57,75.95 80.57,75.54 80.34,75.31 U2030.AN69
  BOTTOM w0.102: JDIM2000.16 51.48,92.45 v2(51.7,92.68)
M_A_DQ4: length 50.2
  IN1 w0.089: v2(82.36,79.38) 82.36,79.95 82.79,80.38 82.79,81.99 76.24,88.55 76.24,88.68 76.31,88.76 76.54,88.76 76.64,88.86 76.64,89.01 76.54,89.11 76.03,89.11 75.93,89.22 75.93,89.39 76.01,89.47 76.57,89.47 76.64,89.54 76.64,89.73 76.54,89.83 76.01,89.83 75.93,89.9 75.93,90.1 76.02,90.19 76.55,90.19 76.64,90.28 76.64,90.45 76.55,90.54 76.02,90.54 75.93,90.63 75.93,91.41 73.56,93.78 68.51,93.78 67.71,94.59 63.3,94.59 63.08,94.81 62.95,94.81 62.73,94.59 62.6,94.59 62.48,94.72 62.48,94.84 62.7,95.07 62.7,95.19 62.05,95.84 59.85,95.84 59.53,95.52 59.4,95.52 59.27,95.64 59.27,95.78 59.55,96.06 59.55,96.18 59.41,96.32 59.29,96.32 59.05,96.07 58.84,96.07 58.76,96.15 58.76,96.56 58.67,96.65 56.37,96.65 55.97,96.24 v2(55.97,96.02)
  BOTTOM w0.076: 81.85,78.06 81.85,77.98 81.72,77.85 81.72,76.76 81.77,76.71 81.77,76.57 81.84,76.41 81.84,76.23 81.79,76.11 81.79,75.88 81.7,75.79 U2030.AL70
  BOTTOM w0.102: 81.85,78.06 81.85,79.13 82.1,79.38 v2(82.36,79.38) ; JDIM2000.7 57.42,94.7 56.4,95.72 56.27,95.72 v2(55.97,96.02)
M_A_DQ5: length 50.8
  IN1 w0.089: v2(82.38,78.21) 83.13,78.96 83.13,79.75 83.48,80.1 83.48,82.17 77.25,88.4 77.25,91.27 74.13,94.39 69.61,94.39 69.52,94.48 69.52,94.84 69.43,94.93 69.25,94.93 69.16,94.84 69.16,94.48 69.07,94.39 68.77,94.39 67.96,95.2 63.56,95.2 62.3,96.45 60.15,96.45 59.3,97.29 56.15,97.29 54.77,95.92 51.98,95.92 v2(51.53,95.48)
  BOTTOM w0.076: U2030.AL69 81.74,75.36 81.74,75.37 81.78,75.43 81.78,75.44 81.86,75.62 81.92,75.72 81.96,75.78 81.96,76.08 82.01,76.19 82.01,76.44 81.94,76.6 81.94,77.05 81.9,77.09 81.9,77.73 v2(82.38,78.21)
  BOTTOM w0.102: v2(51.53,95.48) 51.51,95.45 JDIM2000.4
M_A_DQ6: length 49.4
  IN1 w0.089: v2(52.88,92.65) 53.86,93.64 54.96,93.64 55.05,93.55 55.05,93.34 55.14,93.25 55.31,93.25 55.4,93.34 55.4,93.55 55.49,93.64 58.74,93.64 59.62,92.76 66.29,92.76 66.61,92.44 66.71,92.44 66.95,92.69 67.08,92.69 67.2,92.56 67.2,92.44 66.95,92.19 66.95,92.06 67.08,91.94 67.2,91.94 67.46,92.19 67.57,92.19 67.7,92.06 67.7,91.93 67.44,91.66 67.44,91.53 67.56,91.41 67.68,91.41 67.96,91.68 68.08,91.68 68.21,91.55 68.21,91.37 67.42,90.59 67.42,90.46 67.55,90.34 67.67,90.34 68.18,90.84 68.3,90.84 68.41,90.73 68.41,90.59 67.93,90.11 67.93,89.95 68.04,89.84 68.16,89.84 68.34,90.02 68.41,90.02 68.46,89.97 68.46,88.29 71.25,85.5 74.77,85.5 78.86,81.41 79.81,81.41 81.09,80.13 81.09,78.61 v2(80.73,78.26)
  BOTTOM w0.076: U2030.AN70 80.4,75.82 80.4,75.96 80.51,76.21 80.51,76.51 80.16,76.86 80.16,77.4 80.34,77.58 80.34,77.86 80.53,78.06
  BOTTOM w0.102: JDIM2000.20 51.68,91.45 v2(52.88,92.65) ; 80.53,78.06 v2(80.73,78.26)
M_A_DQ7: length 48.4
  IN1 w0.089: v2(80.59,79.43) 79.22,80.8 78.61,80.8 77.6,81.81 77.06,81.81 76.99,81.89 76.99,82.04 77.13,82.18 77.13,82.28 76.85,82.56 76.62,82.56 76.49,82.43 76.49,82.13 76.17,81.81 75.68,81.81 75.45,82.04 75.45,82.3 76.18,83.02 76.18,83.15 76.06,83.28 75.93,83.28 75.43,82.78 75.31,82.78 75.18,82.9 75.18,83.03 75.68,83.53 75.68,83.65 75.55,83.78 75.43,83.78 74.93,83.28 74.8,83.28 74.68,83.41 74.68,83.53 75.18,84.03 75.18,84.16 75.05,84.28 74.92,84.28 74.43,83.78 74.3,83.78 74.13,83.96 74.13,84.06 74.64,84.57 74.64,84.72 74.51,84.85 74.36,84.85 73.87,84.36 73.72,84.36 73.2,84.89 71,84.89 67.99,87.9 67.52,88.37 67.52,88.5 67.85,88.84 67.85,88.96 67.73,89.09 67.6,89.09 67.27,88.75 67.14,88.75 67.01,88.88 67.01,89 67.45,89.44 67.45,89.57 67.33,89.69 67.2,89.69 66.76,89.25 66.64,89.25 66.51,89.38 66.51,89.5 66.93,89.92 66.93,90.07 66.8,90.19 66.7,90.19 66.26,89.75 66.13,89.75 66.01,89.88 66.01,90.01 66.42,90.42 66.42,90.52 66.3,90.65 66.15,90.65 65.76,90.26 64.79,90.26 62.9,92.15 59.27,92.15 58.61,92.81 58.61,92.9 58.52,92.99 58.34,92.99 58.26,92.9 58.26,92.68 58.17,92.59 57.99,92.59 57.9,92.68 57.9,92.9 57.81,92.99 57.63,92.99 57.54,92.9 57.54,92.68 57.46,92.59 57.15,92.59 v2(57.05,92.69)
  BOTTOM w0.076: U2030.AN71 80.24,76.53 79.99,76.78 79.99,77.47 80.17,77.65 80.17,78.12 80.19,78.14
  BOTTOM w0.102: JDIM2000.17 57.53,92.21 v2(57.05,92.69) ; 80.19,78.14 80.21,78.16 80.21,79.06 v2(80.59,79.43)
M_A_DQ8: length 39.8
  IN1 w0.089: v2(79.19,79.4) 78.75,79.84 78.13,79.84 77.12,80.85 75.22,80.85 74.39,81.68 74.39,82.51 72.85,84.05 69.87,84.05 62.57,91.35 58.94,91.35 58.85,91.44 57.33,91.44 57.01,91.75 53.7,91.75 v2(52.78,90.83)
  BOTTOM w0.076: U2030.AR70 79.49,75.94 79.49,77.71 79.61,77.83 79.61,78.98 v2(79.19,79.4)
  BOTTOM w0.102: v2(52.78,90.83) 52.78,90.38 52.4,90 52.06,90 51.52,89.45 JDIM2000.28
M_A_DQ9: length 40.7
  IN1 w0.089: v2(56.88,90.83) 58.6,90.83 58.69,90.74 58.98,90.74 59.09,90.62 59.09,90.22 59.22,90.09 59.4,90.09 59.49,90.18 59.49,90.65 59.58,90.74 59.77,90.74 59.86,90.65 59.86,90.18 59.95,90.09 60.14,90.09 60.23,90.18 60.23,90.65 60.31,90.74 60.5,90.74 60.59,90.65 60.59,90.18 60.68,90.09 60.87,90.09 60.96,90.18 60.96,90.65 61.05,90.74 61.24,90.74 61.33,90.65 61.33,90.18 61.42,90.09 61.56,90.09 61.66,90.18 61.66,90.64 61.76,90.74 61.91,90.74 62.01,90.64 62.01,90.18 62.11,90.09 62.27,90.09 62.34,90.16 62.34,90.33 62.42,90.41 62.54,90.41 69.58,83.36 70.86,83.36 74.06,80.16 76.84,80.16 77.75,79.26 78.42,79.26 78.75,78.92 78.75,78.05 79.43,77.37 79.84,77.37 79.92,77.29 79.92,77.09 79.82,76.99 79.28,76.99 v2(78.93,77.34)
  BOTTOM w0.076: U2030.AR68 79.11,74.55 78.76,74.91 78.76,75.08 78.84,75.16 78.84,76.37 79.09,76.62 79.09,77.18 v2(78.93,77.34)
  BOTTOM w0.102: JDIM2000.25 57.35,90.21 56.88,90.67 v2(56.88,90.83)
M_A_DQ10: length 37.9
  IN1 w0.089: v2(52.15,87.76) 52.15,87.95 53.05,88.85 56.6,88.85 56.69,88.93 56.69,89.54 56.78,89.63 56.96,89.63 57.04,89.54 57.04,88.93 57.13,88.85 57.31,88.85 57.4,88.93 57.4,89.54 57.49,89.63 57.67,89.63 57.76,89.54 57.76,88.93 57.84,88.85 61.95,88.85 62.04,88.76 62.04,88.37 62.12,88.28 62.32,88.28 62.41,88.37 62.41,88.52 62.5,88.61 62.67,88.61 69.12,82.16 70.4,82.16 74.16,78.4 76.75,78.4 v2(76.77,78.42)
  BOTTOM w0.076: 77.48,77.62 77.48,77.2 77.79,76.89 77.79,76.42 U2030.AU71
  BOTTOM w0.102: v2(76.77,78.42) 76.79,78.4 76.93,78.4 77.3,78.03 77.3,77.8 77.48,77.62 ; JDIM2000.38 51.71,86.95 52.15,87.4 v2(52.15,87.76)
M_A_DQ11: length 39.8
  IN1 w0.089: v2(76.21,76.74) 76.21,75.82 76.32,75.72 76.32,75.01 75.91,74.61 75.91,73.47 75.77,73.33 75.56,73.33 75.47,73.42 75.47,74.02 75.39,74.11 75.2,74.11 75.09,74 75.09,73.43 74.99,73.33 74.81,73.33 74.72,73.42 74.72,74.25 74.84,74.38 74.84,75.88 74.75,75.97 74.63,75.97 74.54,75.88 74.54,74.66 74.45,74.57 74.32,74.57 74.23,74.66 74.23,76.04 73.67,76.6 73.67,77.59 70.13,81.13 68.69,81.13 62.6,87.22 57.53,87.22 v2(56.99,87.76)
  BOTTOM w0.076: 77.91,74.36 77.49,74.78 77.49,75.14 77.31,75.32 77.08,75.32 76.86,75.54 76.86,75.77 76.63,76 76.41,76 76.18,76.22 76.18,76.71 v2(76.21,76.74)
  BOTTOM w0.102: JDIM2000.37 57.49,87.21 56.99,87.7 v2(56.99,87.76)
M_A_DQ12: length 38.7
  IN1 w0.089: v2(79.17,78.81) 79.17,78.85 78.44,79.59 77.9,79.59 76.98,80.51 74.4,80.51 73.25,81.65 73.25,81.89 73.8,82.44 73.8,82.54 73.68,82.66 73.52,82.66 73,82.14 72.88,82.14 72.75,82.27 72.75,82.39 73.26,82.9 73.26,83.05 73.15,83.17 73.02,83.17 72.5,82.64 72.38,82.64 71.31,83.71 69.72,83.71 62.39,91.04 58.81,91.04 58.72,91.13 57.2,91.13 56.92,91.41 55.93,91.41 55.71,91.19 v2(55.71,90.83)
  BOTTOM w0.076: U2030.AR71 79.32,76.42 79.32,78.67 v2(79.17,78.81)
  BOTTOM w0.102: v2(55.71,90.83) 55.71,90.57 57.08,89.21 JDIM2000.29
M_A_DQ13: length 40.7
  IN1 w0.089: v2(51.61,90.82) 52.88,92.09 57.1,92.09 57.45,91.74 58.98,91.74 59.07,91.65 62.7,91.65 64.59,89.76 65.43,89.76 70.8,84.39 72.99,84.39 74.96,82.43 74.96,81.83 75.47,81.32 77.39,81.32 78.4,80.3 78.91,80.3 v2(79.23,79.98)
  BOTTOM w0.076: U2030.AR69 79.11,75.11 79.65,75.65 79.65,77.59 79.78,77.73 79.78,79.69 79.49,79.98 v2(79.23,79.98)
  BOTTOM w0.102: v2(51.61,90.82) 51.61,90.67 51.39,90.45 JDIM2000.24
M_A_DQ14: length 38.6
  IN1 w0.089: v2(53.37,87.75) 53.56,87.75 54.31,88.5 58.76,88.5 58.85,88.41 58.85,88.01 58.95,87.91 59.12,87.91 59.21,88 59.21,88.35 59.29,88.43 59.47,88.43 59.56,88.35 59.56,88.01 59.66,87.91 59.83,87.91 59.92,88 59.92,88.37 60.01,88.46 60.18,88.46 60.27,88.37 60.27,88.01 60.37,87.91 60.54,87.91 60.63,88 60.63,88.37 60.72,88.46 60.89,88.46 60.98,88.37 60.98,88.01 61.08,87.91 61.25,87.91 61.34,88 61.34,88.37 61.43,88.46 61.61,88.46 61.69,88.38 61.69,88.04 61.8,87.94 62.86,87.94 68.98,81.82 70.31,81.82 74.11,78.02 76.44,78.02 v2(76.63,77.84)
  BOTTOM w0.076: U2030.AU70 77.61,75.94 77.61,76.8 77.45,76.96 77.27,77.14 77.27,77.41 77.1,77.58 76.93,77.75
  BOTTOM w0.102: v2(53.37,87.75) 53.37,87.31 52.02,85.95 JDIM2000.42 ; 76.93,77.75 76.84,77.84 v2(76.63,77.84)
M_A_DQ15: length 39.1
  IN1 w0.089: v2(55.8,87.75) 56.21,88.16 57.63,88.16 57.71,88.08 57.71,87.63 57.78,87.57 57.97,87.57 58.06,87.66 58.06,88.06 58.15,88.15 58.33,88.15 58.42,88.06 58.42,87.66 58.51,87.57 62.74,87.57 68.83,81.47 70.22,81.47 74.16,77.53 74.16,76.91 74.26,76.81 74.53,76.81 74.62,76.9 74.62,77.59 74.71,77.68 75.02,77.68 75.16,77.54 75.16,75.33 75.25,75.24 75.4,75.24 75.49,75.33 75.49,77.61 75.58,77.7 75.94,77.7 v2(76.24,77.4)
  BOTTOM w0.076: 76.77,77.4 77.43,76.74 77.43,75.86 77.51,75.78 77.51,75.4 U2030.AU69
  BOTTOM w0.102: 76.77,77.4 v2(76.24,77.4) ; JDIM2000.41 57.45,86.21 57.28,86.37 57.18,86.37 v2(55.8,87.75)
M_A_DQ16: length 32.1
  IN1 w0.089: v2(70.68,77.94) 70.86,78.12 70.86,78.25 69.6,79.5 68.02,79.5 62.52,85 62.18,85 62.04,85.14 62.04,85.44 61.94,85.54 61.74,85.54 61.65,85.45 61.65,85.08 61.56,85 61.38,85 61.29,85.08 61.29,85.45 61.2,85.54 61.02,85.54 60.94,85.45 60.94,85.08 60.85,85 60.67,85 60.58,85.08 60.58,85.45 60.49,85.54 60.31,85.54 60.22,85.45 60.22,85.08 60.14,85 59.96,85 59.87,85.08 59.87,85.45 59.78,85.54 59.6,85.54 59.51,85.45 59.51,85.08 59.42,85 59.25,85 59.16,85.08 59.16,85.45 59.07,85.54 58.89,85.54 58.8,85.45 58.8,85.08 58.71,85 58.53,85 58.45,85.08 58.45,85.45 58.36,85.54 58.13,85.54 58.04,85.45 58.04,85.12 57.95,85.03 57.77,85.03 57.68,85.12 57.68,85.36 57.54,85.5 v2(56.95,85.5)
  BOTTOM w0.076: 70.98,77.04 71.53,77.04 72.35,76.23 72.35,75.41 72.83,74.92 72.83,73.8 74.07,72.56 U2030.BB65
  BOTTOM w0.102: v2(70.68,77.94) 70.67,77.94 70.67,77.16 70.78,77.04 70.98,77.04 ; v2(56.95,85.5) 57.27,85.5 57.57,85.21 JDIM2000.45
M_A_DQ17: length 34.6
  IN1 w0.089: v2(73.08,76) 72.84,76.23 72.84,77.72 70.03,80.53 68.44,80.53 62.35,86.63 53.35,86.63 v2(52.18,85.46)
  BOTTOM w0.076: v2(73.08,76) 73.64,76 74.08,75.56 74.08,74.8 74.69,74.19 74.87,74.19 75.06,74.01 75.06,73.74 75.39,73.41 75.39,73.11 75.43,73.07 75.51,73 75.63,72.95 75.86,72.95 76.05,72.95 76.15,72.85 76.33,72.85 76.62,72.56 U2030.AW65
  BOTTOM w0.102: JDIM2000.46 51.68,84.95 v2(52.18,85.46)
M_A_DQ18: length 35.2
  IN1 w0.089: v2(56.53,82.34) 56.53,82.28 56.96,81.86 57.52,81.86 57.61,81.95 57.61,82.69 57.7,82.78 57.88,82.78 57.96,82.69 57.96,81.95 58.05,81.86 58.24,81.86 58.33,81.95 58.33,82.69 58.42,82.78 58.59,82.78 58.68,82.69 58.68,81.99 58.81,81.86 58.99,81.86 59.07,81.94 59.07,82.69 59.15,82.78 60.7,82.78 61.15,82.34 61.15,82.21 60.91,81.97 60.91,81.84 61,81.76 61.22,81.76 61.77,82.31 62,82.31 62.08,82.22 62.08,82.09 61.74,81.74 61.74,81.55 61.87,81.41 62.08,81.41 62.39,81.73 62.53,81.73 68.26,76 v2(69.17,76)
  BOTTOM w0.076: U2030.AW63 76.48,71.33 76.17,71.02 75.62,71.02 75.4,70.8 73.9,70.8 73.09,71.61 73.09,71.93 72.75,72.26 72.27,72.74 71.77,73.25 71.77,74.32 71.15,74.94
  BOTTOM w0.102: 71.15,74.94 70.89,75.19 69.39,75.19 69.17,75.41 69.17,76 v2(69.17,76) ; JDIM2000.59 57.17,81.7 v2(56.53,82.34)
M_A_DQ19: length 33.9
  IN1 w0.089: v2(52.12,81.6) 52.12,81.6 54.34,83.81 61.65,83.81 61.73,83.73 61.73,83.6 61.66,83.53 61.66,83.4 61.76,83.3 61.91,83.3 62.06,83.45 62.26,83.45 68.63,77.09 70.4,77.09 v2(71.51,75.98)
  BOTTOM w0.076: v2(71.51,75.98) 71.77,75.72 71.77,75.15 72.29,74.63 72.29,73.54 72.67,73.15 73.23,72.6 73.66,72.16 73.66,71.74 73.74,71.66 73.97,71.42 74.08,71.32 74.41,71.32 74.6,71.51 75.47,71.51 75.69,71.43 75.94,71.43 U2030.AY63
  BOTTOM w0.102: JDIM2000.62 51.48,80.95 v2(52.12,81.6)
M_A_DQ20: length 33
  IN1 w0.089: v2(55.78,85.5) 55.78,85.8 55.88,85.9 62.1,85.9 68.16,79.85 69.75,79.85 71.38,78.22 71.38,78.06 70.76,77.44 70.76,77.25 71.4,76.61 71.59,76.61 71.86,76.87 71.86,77.05 v2(71.42,77.49)
  BOTTOM w0.076: U2030.BA65 75.28,72.68 75.18,72.68 75.07,72.79 74.93,72.79 74.8,72.84 74.02,72.84 73,73.86 73,74.99 72.51,75.47 72.51,76.3 71.75,77.06 71.75,77.16 v2(71.42,77.49)
  BOTTOM w0.102: JDIM2000.49 57.44,84.21 56.91,84.73 56.66,84.73 56.31,85.08 56.19,85.08 55.78,85.49 v2(55.78,85.5)
M_A_DQ21: length 34.1
  IN1 w0.089: v2(53.43,85.5) 54.17,86.24 62.25,86.24 68.3,80.19 69.89,80.19 71.98,78.09 v2(71.98,77.78)
  BOTTOM w0.076: U2030.AY65 75.82,72.79 75.72,72.79 75.59,72.79 75.53,72.82 75.38,72.84 75.25,72.84 75.14,72.95 74.96,72.95 74.85,73.01 74.1,73.01 73.8,73.31 73.32,73.79 73.16,73.95 73.16,75.06 72.68,75.54 72.68,76.4 71.98,77.09 v2(71.98,77.78)
  BOTTOM w0.102: v2(53.43,85.5) 51.88,83.95 JDIM2000.50
M_A_DQ22: length 33.9
  IN1 w0.089: v2(55.36,82.34) 55.3,82.34 54.91,82.73 54.6,82.73 54.5,82.83 54.5,83.02 54.6,83.13 55.3,83.13 55.39,83.04 55.39,82.8 55.46,82.73 55.66,82.73 55.75,82.82 55.75,83.04 55.84,83.13 56.02,83.13 56.11,83.04 56.11,82.83 56.2,82.74 56.38,82.74 56.47,82.83 56.47,83.04 56.56,83.13 56.73,83.13 56.82,83.04 56.82,82.83 56.91,82.74 57.09,82.74 57.18,82.83 57.18,83.04 57.27,83.13 60.89,83.13 61.36,82.65 62.09,82.65 68.34,76.4 69.3,76.4 v2(69.75,75.95)
  BOTTOM w0.076: U2030.BA63 75.17,71.23 74.9,70.97 73.96,70.97 73.74,71.19 73.28,71.65 73.28,72.01 71.96,73.33 71.96,74.42 70.91,75.47 70.43,75.47
  BOTTOM w0.102: v2(55.36,82.34) 55.36,82.13 56.79,80.7 JDIM2000.63 ; 70.43,75.47 70.09,75.47 69.75,75.81 69.75,75.95 v2(69.75,75.95)
M_A_DQ23: length 32.5
  IN1 w0.089: v2(53.31,81.61) 53.31,82.27 53.62,82.57 53.74,82.57 53.86,82.46 53.96,82.46 54.08,82.57 54.08,82.7 53.95,82.83 53.95,82.9 54.51,83.47 61.05,83.47 61.53,82.99 62.24,82.99 68.48,76.75 70.14,76.75 v2(70.92,75.96)
  BOTTOM w0.076: 71.46,75.22 71.46,75.2 72.12,74.55 72.12,73.43 72.54,73.01 73.02,72.53 73.48,72.08 73.48,71.69 73.86,71.31 74.01,71.15 74.67,71.15 U2030.BB63
  BOTTOM w0.102: v2(70.92,75.96) 70.92,75.76 71.46,75.22 ; JDIM2000.58 51.17,81.95 51.32,82.1 52.82,82.1 v2(53.31,81.61)
M_A_DQ24: length 31.1
  IN1 w0.089: v2(52.8,79.97) 54.48,79.97 55.43,80.92 59.87,80.92 60.22,80.57 62.49,80.57 68.01,75.06 69.89,75.06 v2(70.62,74.33)
  BOTTOM w0.076: U2030.BA61 75.17,70.2 74.91,70.47 73.76,70.47 72.69,71.54 72.69,71.8 71.37,73.11 71.37,73.28 70.62,74.03 v2(70.62,74.33)
  BOTTOM w0.102: JDIM2000.70 51.33,78.95 51.48,79.11 52.34,79.11 52.8,79.57 v2(52.8,79.97)
M_A_DQ25: length 32.3
  IN1 w0.089: v2(51.63,79.98) 51.63,80.03 52.05,80.45 54.47,80.45 55.28,81.26 61.24,81.26 61.58,80.92 62.63,80.92 68.15,75.4 70.12,75.4 v2(71.28,74.25)
  BOTTOM w0.076: U2030.AW61 76.51,70.1 76.18,70.43 75.64,70.43 75.43,70.64 73.83,70.64 72.91,71.56 72.91,71.85 72.62,72.13 72.14,72.61 71.56,73.19 71.56,73.97 71.33,74.2 v2(71.28,74.25)
  BOTTOM w0.102: v2(51.63,79.98) 51.57,79.98 51.55,79.95 JDIM2000.66
M_A_DQ26: length 31.3
  IN1 w0.089: v2(52.95,76.55) 54.28,76.55 55.2,77.47 57.8,77.47 58.03,77.24 58.03,76.21 58.14,76.1 59.18,76.1 59.3,76.22 59.3,76.71 59.41,76.82 61.75,76.82 62.23,77.31 62.57,77.31 66.91,72.97 68.39,72.97 v2(69.13,72.24)
  BOTTOM w0.076: 71.81,70.59 72.13,70.59 72.63,70.08 73.88,68.84 74.7,68.84 U2030.BB59
  BOTTOM w0.102: JDIM2000.84 52.22,75.46 52.95,76.18 v2(52.95,76.55) ; 71.81,70.59 70.35,70.59 69.41,71.52 69.41,71.95 v2(69.13,72.24)
M_A_DQ27: length 33.4
  IN1 w0.089: v2(51.78,76.62) 52.36,77.2 54.44,77.2 55.05,77.82 58.41,77.82 58.51,77.72 58.51,76.97 58.59,76.88 58.76,76.88 58.86,76.98 58.86,77.72 58.95,77.82 62.55,77.82 67.05,73.31 68.61,73.31 v2(69.71,72.22)
  BOTTOM w0.076: 70.44,72.75 71,72.75 72.11,71.63 72.11,71.41 73.04,70.49 73.55,69.97 74.32,69.97 74.52,69.77 74.88,69.77 74.88,69.77 74.99,69.82 75.15,69.82 75.26,69.77 75.26,69.77 75.26,69.77 75.27,69.76 75.5,69.76 75.67,69.82 75.86,69.82 75.92,69.78 76.51,69.78 76.7,69.59 U2030.AW59
  BOTTOM w0.102: v2(51.78,76.62) 51.61,76.46 JDIM2000.80 ; 70.44,72.75 70.24,72.75 v2(69.71,72.22)
M_A_DQ28: length 30.7
  IN1 w0.089: v2(55.38,80.05) 55.38,80.25 55.71,80.58 59.34,80.58 59.48,80.44 59.48,79.48 59.6,79.36 60.4,79.36 60.49,79.44 60.49,79.66 60.59,79.75 60.76,79.75 60.84,79.67 60.84,79.44 60.93,79.36 61.11,79.36 61.2,79.44 61.2,79.69 61.31,79.8 61.47,79.8 61.56,79.71 61.56,79.44 61.64,79.36 61.82,79.36 61.91,79.44 61.91,79.64 62.01,79.74 62.18,79.74 62.27,79.65 62.27,79.44 62.36,79.36 62.52,79.36 62.61,79.44 62.61,79.62 62.7,79.7 62.88,79.7 62.96,79.62 62.96,79.44 63.05,79.36 63.17,79.36 67.8,74.72 68.88,74.72 v2(69.27,74.33)
  BOTTOM w0.076: 70.67,73.55 71.62,72.6 72.36,71.86 72.52,71.7 72.52,71.48 73.69,70.3 74.64,70.3 U2030.BB61
  BOTTOM w0.102: v2(69.27,74.33) 69.81,73.79 70.43,73.79 70.67,73.55 ; v2(55.38,80.05) 55.38,79.85 56.52,78.7 JDIM2000.71
M_A_DQ29: length 32.2
  IN1 w0.089: v2(56.55,80.08) 56.55,79.07 56.63,79 56.89,79 56.98,79.09 56.98,79.55 57.07,79.64 57.25,79.64 57.34,79.55 57.34,79.09 57.42,79 57.6,79 57.69,79.09 57.69,80.15 57.78,80.23 57.96,80.23 58.05,80.14 58.05,79.09 58.14,79 58.31,79 58.4,79.09 58.4,80.12 58.49,80.21 58.67,80.21 58.76,80.12 58.76,79.09 58.85,79 63.04,79 67.73,74.3 v2(68.54,74.3)
  BOTTOM w0.076: U2030.AY61 75.94,70 75.68,70 75.58,69.97 75.58,69.97 75.5,69.94 75.29,69.94 75.15,69.99 75,69.99 74.94,69.97 74.85,69.94 74.59,69.94 74.39,70.14 73.62,70.14 72.35,71.41 72.35,71.63 70.84,73.14 70.44,73.14
  BOTTOM w0.102: v2(56.55,80.08) 57.04,79.59 57.4,79.59 57.52,79.7 JDIM2000.67 ; v2(68.54,74.3) 69.7,73.14 70.44,73.14
