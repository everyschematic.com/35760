# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_CPU_SVIDCLK: length 61.8
  TOP w0.102: v1(140.66,61.62) 141.13,61.62 PR7003.2
  IN1 w0.089: v1(140.66,61.62) 140.49,61.62 138.94,63.17 134.18,63.17 133.34,64.01 133.34,67.63 130.21,70.75 124.05,70.75 122.85,71.95 121.83,71.95 118.22,75.55 108.47,75.55 107.35,76.67 106.96,76.67 106.87,76.76 106.87,77.34 106.78,77.43 106.49,77.43 106.4,77.34 106.4,76.76 106.31,76.67 106.02,76.67 105.93,76.76 105.93,77.34 105.84,77.43 105.55,77.43 105.46,77.34 105.46,76.76 105.37,76.67 104.9,76.67 104.75,76.52 101.33,76.52 100.37,75.55 100.37,74.41 99.87,73.91 99.71,73.91 99.17,73.37 99.17,72.81 v1(99.27,72.71)
  BOTTOM w0.102: v1(99.27,72.71) 98.6,72.03 98.16,72.03 97.55,71.42 U2030.A63 ; v1(140.66,61.62) 140.74,61.62 141.98,60.38 PR7015.1
H_CPU_SVIDDAT: length 60.8
  TOP w0.102: v1(139.84,61.04) 140.27,60.61 PR7001.2
  IN1 w0.089: v1(139.84,61.04) 139.14,61.04 137.94,62.23 133.79,62.23 132.4,63.62 132.4,67.24 129.82,69.81 123.66,69.81 122.46,71.01 121.39,71.01 117.59,74.81 107.89,74.81 106.97,75.73 105.29,75.73 103.23,73.67 102.91,73.67 102.78,73.8 102.78,74.1 103.54,74.87 103.54,75.09 103.41,75.22 103.11,75.22 102.45,74.56 102.22,74.56 101.74,75.04 v1(101.74,75.4)
  BOTTOM w0.102: PR7019.1 140.28,60.38 140.07,60.59 140.07,60.81 v1(139.84,61.04) ; U2030.D64 95.96,71.99 96.28,71.66 96.51,71.66 96.85,72.01 97.56,72.01 97.99,72.44 98.16,72.44 98.68,72.96 98.68,73.3 99.25,73.87 99.96,73.87 100.29,74.2 100.29,74.51 100.44,74.66 101.65,74.66 R2459.2 101.76,75.37 v1(101.74,75.4)
H_PROCHOT#: length 169.2
  TOP w0.102: v1(173.17,30.94) 173.17,28.23 173.7,27.7 173.7,27.06 173.43,26.79 173.43,26.24 173.54,26.13 173.54,24.62 173.81,24.34 Q6509.3 ; v1(135.9,47.33) 136.74,46.49 136.74,44.31 137.62,43.43 138.68,43.43 139.57,42.54 141.84,42.54 142.25,42.13 142.25,40.4 143.83,38.82 143.83,38.22 143.07,37.47 143.07,35.81 142.43,35.17 142.43,32.55 141.57,31.69 139.9,31.69 138.42,30.21 v1(137.65,30.21)
  IN1 w0.089: v1(137.98,61.31) 137.98,61.31 137.53,61.76 134.86,61.76 133.87,60.77 v1(133.87,60.67) ; v1(99.06,78.64) 99.14,78.57 99.5,78.21 99.5,77.68 97.39,75.58 97.39,73.11 97.72,72.78 98.03,72.78 99.27,71.54 101.76,71.54 105.48,75.26 106.77,75.26 107.62,74.41 107.62,69 107.92,68.71 114.99,68.71 116.05,69.77 116.05,71.19 117.5,72.64 118.97,72.64 121.36,70.26 v1(122.19,70.26)
  IN3 w0.089: v1(133.87,60.67) 132.75,61.78 132.75,67.49 129.99,70.26 v1(122.19,70.26) ; v1(173.17,30.94) 170.43,30.94 169.25,32.12 165.89,32.12 164.76,33.24 163.77,33.24 163.4,33.61 159.54,33.61 159.05,33.12 157.87,33.12 157.39,33.61 157.39,34.53 156.06,35.86 149.38,35.86 149.01,36.23 148.47,36.23 147.8,35.56 146.79,35.56 146.47,35.88 144.49,35.88 141.04,32.43 139.06,32.43 138.97,32.35 138.36,32.35 137.65,31.63 v1(137.65,30.21) ; v1(135.9,47.33) 137.25,47.33 138.24,48.32 138.92,48.32 140.42,49.82 141.13,49.82 142.16,50.85 142.16,51.66 141.85,51.97 141.85,56.82 141.16,57.52 141.16,57.85 139.03,59.98 139.03,60.44 138.52,60.95 138.35,60.95 v1(137.98,61.31)
  BOTTOM w0.102: R2451.2 98.92,79.64 R2452.1 99.06,79.49 v1(99.06,78.64) ; v1(137.65,30.21) 137.78,30.34 PR22.1 137.39,30.76 136.94,30.31 PU1.10 ; v1(137.98,61.31) 138.38,60.92 138.64,60.92 139.13,60.44 139.13,60.21 PR7012.2
H_PROCHOT#_R: length 9.1
  BOTTOM w0.102: U2030.C65 96.21,72.55 96.71,73.05 96.71,73.39 96.93,73.61 97.64,73.61 97.92,73.89 98.3,73.89 98.95,74.54 98.95,76.02 98.27,76.69 R2452.2
HDA_BCLK_R: length 10.7
  BOTTOM w0.076: U2030.AY22 75.76,48.13 74.23,48.13 73.93,47.83
  BOTTOM w0.079: 73.93,47.83 73.22,47.83 73.21,47.83
  BOTTOM w0.102: 73.21,47.83 73.1,47.83 72.42,47.14 67.68,47.14 R2496.2 66.95,47.87 v1(66.95,48.62)
HDA_RST#_R: length 10.9
  BOTTOM w0.076: 73.85,47.17 74.05,47.17 74.29,47.41 75.43,47.41 75.65,47.63 75.77,47.63 75.83,47.56 76.22,47.56 76.5,47.85 U2030.AW22
  BOTTOM w0.079: 73.85,47.17 73.42,47.17 73.29,47.04
  BOTTOM w0.102: 73.29,47.04 72.63,46.38 68.1,46.38 v1(67.87,46.16) R2498.2
HDA_SDO_R: length 13.7
  BOTTOM w0.076: 73.77,47.59 73.95,47.59 74.21,47.85 U2030.BB22
  BOTTOM w0.079: 73.77,47.59 73.17,47.59
  BOTTOM w0.102: R2494.1 63.41,47.24 v1(63.8,47.24) 64.93,47.24 65.06,47.11 R2495.2 65.59,47.26 66.86,47.26 66.96,47.16 C2575.2 67.13,46.89 72.45,46.89 73.15,47.59 73.17,47.59
HDA_SYNC_R: length 11.5
  BOTTOM w0.076: 73.6,47.37 73.97,47.37 74.18,47.58 75.13,47.58 U2030.BA22
  BOTTOM w0.079: 73.6,47.37 73.29,47.37 73.19,47.27
  BOTTOM w0.102: 73.19,47.27 72.55,46.64 67.61,46.64 C2577.2 66.96,45.8 66.79,45.63 66.08,45.63 v1(65.8,45.91) R2497.2
HDMI_EQ0: length 4.6
  TOP w0.102: R749.1 17.11,84.15 17.11,83.92 R746.1 v1(17.61,82.42) U23.8
HDMI_EQ1: length 4.4
  TOP w0.102: R747.1 22.69,84.2 R748.1 21.37,82.88 21.37,81.8 21.52,81.65 21.91,81.65 22.01,81.54 U23.2
HDMI_HPD: length 24.5
  TOP w0.102: v1(20.97,75.02) 21.01,75.06 U23.21 ; R25297.1 13.99,87.44 VC2.1 14.39,87.44 15.11,86.71 16.46,86.71 v1(16.56,86.61) 16.78,86.4 17.31,86.4 17.66,86.05 R1250.1 18.81,86.46 18.81,87.46 19.17,87.83 20.34,87.83 20.69,88.18 Q6507.3
  IN1 w0.089: v1(16.56,86.61) 17,86.17 17,85.45 18.18,84.26 18.18,80.81 18.91,80.08 18.91,77.08 v1(20.97,75.02)
HDMI_HPD_C: length 8.5
  TOP w0.102: v1(12.28,85.33) 12.24,85.37 C616.1 13.1,86.85 R25297.2
  IN1 w0.089: CN37.19 11.2,81.85 11.82,81.85 12.97,83 12.97,84.63 v1(12.28,85.33)
HDMI_HPD_CON: length 162.9
  TOP w0.102: v1(23.3,86.55) 23.1,86.55 22.87,86.32 22.87,85.75 R750.1
  IN1 w0.089: v1(21.42,99.6) 21.42,97.88 22.21,97.09 22.21,95.41 22.76,94.87 24.53,94.87 26.96,92.44 26.96,88.15 26.01,87.2 23.95,87.2 v1(23.3,86.55) ; v4(90.93,40.15) 91.14,40.15 91.35,40.37 91.35,41.07 91.2,41.23 90.61,41.23 89.77,42.07 89.32,42.52 89.32,42.78 88.73,43.36 88.73,48.34 85.69,51.38 85.69,70.57 85.43,70.83 85.43,74.1 86.22,74.89 86.22,81.19 86.78,81.75 86.78,83.97 87.02,84.21 87.02,85.22 86.44,85.8 86.44,87.08 87.73,88.37 87.73,90.22 88.57,91.05 88.57,94.3 89.27,94.99 v2(89.27,95.19)
  IN2 w0.089: v1(21.42,99.6) 21.42,100.59 23.86,103.03 23.86,103.89 25.55,105.58 37.6,105.58 37.75,105.43 40.74,105.43 43.08,107.76 45.78,107.76 46.06,107.48 47.82,107.48 48.43,108.09 49.24,108.09 50.56,109.41 54.71,109.41 55.16,108.96 60.53,108.96 60.99,108.49 63.26,108.49 63.52,108.23 63.52,107.35 63.76,107.1 66.61,107.1 71.49,102.22 73.87,102.22 78.03,98.07 84.59,98.07 84.81,97.85 86.35,97.85 86.83,98.33 87.9,98.33 88.83,97.4 88.83,95.62 v2(89.27,95.19)
  BOTTOM w0.102: v4(90.93,40.15) 91.19,40.15 U2030.L9
HDMI_MB_HPD_R: length 7.5
  TOP w0.102: U23.5 v1(20.51,82.35) 20.51,83.11 20.41,83.22 20.41,84.54 20.29,84.66 R25294.2 20.29,85.41 21.3,86.41 Q6507.1 21.64,85.84 21.57,85.77 R750.2
HDMI_SCLK: length 43.1
  TOP w0.102: v1(20.71,63) 22.64,64.93 22.64,65.14 23.29,65.78 C614.1 23.48,65.96 23.48,67.41 R490.2 24.3,66.84 Q41.3 ; U23.19 20.01,74.52 v1(19.41,73.91)
  IN1 w0.089: v1(20.71,63) 20.71,63.59 23.44,66.32 23.44,71.21 22.66,71.99 22.66,72.31 20.86,74.12 19.61,74.12 v1(19.41,73.91)
  BOTTOM w0.102: v1(19.41,73.91) 19.25,73.91 19.02,74.14 18.4,74.14 17.75,74.79 16.98,74.79 16.49,74.31 14.02,74.31 D13089.2 13.56,74.33 13.51,74.33 13.5,74.32 13.13,74.32 12.59,74.86 12.59,80.59 12,81.18 11.21,81.18 10.79,80.76 10.79,79.44 CN37.15
HDMI_SDATA: length 41.1
  TOP w0.102: v1(20.18,61.71) 20.2,61.69 21.25,61.69 22.79,63.22 C613.1 23.3,63.06 22.99,62.74 22.99,62.35 23.35,61.99 25.06,61.99 25.6,62.54 Q41.6 ; U23.20 20.51,75.32 20.42,75.23 v1(20.42,73.19) ; R491.2 22.9,70.28 v1(22.83,70.34)
  IN1 w0.089: v1(20.42,73.19) 20.5,73.27 21.14,73.27 22.27,72.13 22.27,71.83 23.02,71.07 23.02,70.53 v1(22.83,70.34) 23.05,70.12 23.05,66.48 20.03,63.46 20.03,61.86 v1(20.18,61.71)
  BOTTOM w0.102: CN37.16 12.18,78.62 12.18,74.69 12.97,73.91 13.5,73.91 D13090.2 14.04,73.9 16.66,73.9 17.14,74.38 17.56,74.38 18.22,73.72 18.85,73.72 19.09,73.48 19.58,73.48 19.87,73.19 v1(20.42,73.19)
HP-L2: length 18.2
  TOP w0.381: R476.1 R472.2 212.59,46.48 R474.1 211.03,46.48 210.5,45.96 C589.2 209.98,45.29 v1(209.74,45.53)
  BOTTOM w0.203: U20.32 205.26,36.84
  BOTTOM w0.381: v1(209.74,45.53) 209.9,45.36 209.9,42.88 209.13,42.11 207.14,42.11 205.26,40.23 205.26,36.84
HP-L3: length 4
  TOP w0.381: v1(214.9,46.11) 214.37,46.11 R472.1 C592.2
  BOTTOM w0.305: v1(214.9,46.11) 214.61,46.4 CN35.4
HP-R2: length 18.9
  TOP w0.381: v1(212.04,45.69) 213.12,44.61 C594.2 213.98,44.61 214.43,44.17 R475.1 R477.1 R473.2
  BOTTOM w0.203: U20.33 205.66,37.05 206.06,37.45
  BOTTOM w0.381: v1(212.04,45.69) 210.79,44.44 210.79,42.52 209.5,41.22 207.51,41.22 206.06,39.77 206.06,37.45
HP-R3: length 5
  TOP w0.381: v1(216.32,46.87) 216.06,46.87 216.04,46.85 C593.2 215.44,46.51 215.63,46.32 R473.1
  BOTTOM w0.254: CN35.2 214.13,47.4 214.65,46.87 216.27,46.87
  BOTTOM w0.381: 216.27,46.87 v1(216.32,46.87)
HP_JD#: length 21.8
  TOP w0.102: v2(201.33,29.88) 201.33,30.41 200.8,30.95 R451.2
  IN2 w0.089: v2(201.33,29.88) 201.84,30.39 201.84,35.34 202.82,36.33 204.5,36.33 210.07,41.9 212.25,41.9 v1(212.33,41.97)
  BOTTOM w0.102: v1(212.33,41.97) 212.4,41.9 CN35.13
HWPG: length 100.5
  TOP w0.102: v1(174.06,25.23) 174.06,24.67 174.59,24.13 174.59,21.86 176.2,20.26 181.15,20.26 181.53,19.87 182.13,19.87 182.43,20.18 U37.21 ; R2256.2 109.97,27.95 108.84,26.82 v1(108.84,26.3) ; R25312.1 169.51,29.15 170.01,29.65 D60.2 170.01,31.2 169.2,32.02 D64.2 D51.2 168.6,29.89 168.34,29.63 D61.2 D62.2 D2016.2 168.34,25.39 v1(167.96,25.01)
  IN3 w0.089: v1(174.06,25.23) 173.83,25.01 v1(167.96,25.01) 167.01,24.06 161.74,24.06 160.51,22.83 158.88,22.83 157.68,21.63 154.61,21.63 153.71,22.53 152.77,22.53 151.36,21.13 136.68,21.13 135.37,22.44 132.8,22.44 132.57,22.2 127.78,22.2 127.14,22.84 123.66,22.84 123.19,22.38 121.14,22.38 120.67,21.91 109.89,21.91 108.84,22.95 v1(108.84,26.3)
HWPG_1.5V: length 2.6
  TOP w0.102: PR284.1 164.17,28.97 164.3,29.09 164.43,29.09 164.63,29.29 PR6416.2 165.1,29.45 v1(165.32,29.23) 165.58,28.97 D61.1
HWPG_1.8VS5: length 140.1
  TOP w0.102: PR9256.1 44.52,28.66 PR9255.2 44.16,27.9 44.16,27.06 43.34,26.25 v1(43.34,24.85) ; v1(164.89,24.85) 165.59,25.55 165.59,26.45 166.04,26.9 D62.1
  IN2 w0.089: v1(43.34,24.85) 43.67,25.18 48.27,25.18 49.69,23.76 52.28,23.76 54.21,21.83 62.52,21.83 64.22,23.53 64.6,23.53 64.61,23.53 74.46,23.53 75.68,24.75 77.51,24.75 78.27,23.99 80.93,23.99 82.33,25.39 90.87,25.39 91.52,26.04 92.18,26.04 92.31,25.9 93.26,25.9 94.11,25.06 98.71,25.06 100.29,23.48 101.03,23.48 104.87,19.65 118.94,19.65 119.8,18.79 124.37,18.79 124.81,18.34 142.38,18.34 146.4,22.36 148.47,22.36 149.12,21.72 151.87,21.72 152.12,21.96 153.46,21.96 153.93,21.49 155.16,21.49 155.95,22.27 157.49,22.27 158.75,23.53 160.74,23.53 161.57,24.37 163.61,24.37 164.09,24.85 v1(164.89,24.85)
HWPG_1.35VGFX: length 75.7
  TOP w0.102: v2(93.39,92.41) 93,92.02 89.41,92.02 88.35,93.08 87.51,93.08 86.56,94.03 R25549.2 86.16,94.07 85.88,93.79 R25550.1
  IN2 w0.089: v2(93.39,92.41) 93.41,92.43 94.07,92.43 96.58,89.93 97.09,89.93 97.98,90.82 101.41,90.82 102.3,89.93 103.2,89.93 105.7,87.43 106.06,87.43 106.18,87.31 108.29,87.31 108.65,86.96 112.63,86.96 113.25,86.34 113.25,84.1 114.17,83.18 115.27,83.18 117.94,80.5 121.68,80.5 122.24,81.06 126.83,81.06 128.28,79.62 140.27,79.62 142.53,77.35 142.53,70.52 142.03,70.02 142.03,69.89 v1(142.12,69.8)
  BOTTOM w0.254: PR9088.2 142.2,69.8 v1(142.12,69.8) 141.87,69.55 PR9090.2
HWPG_1VS5: length 68.5
  TOP w0.102: D64.1 166.53,32.02 167.76,30.79 v1(167.76,30.6)
  IN2 w0.089: v1(119.45,42.1) 121,40.55 121,39 121.74,38.26 121.74,37.14 127.24,31.63 128.46,31.63 129.47,30.62 129.47,28.48 133.21,24.74 143.36,24.74 144.22,25.6 146.26,25.6 147.16,26.51 147.16,27.13 146.47,27.82 146.47,28.49 147.13,29.15 147.13,29.41 147.41,29.7 148.4,29.7 148.65,29.45 148.65,29.1 149.15,28.61 151.77,28.61 152.61,29.45 155.68,29.45 157.56,31.33 162.09,31.33 162.88,30.54 164.25,30.54 164.58,30.21 167.37,30.21 v1(167.76,30.6)
  BOTTOM w0.203: v1(119.45,42.1) 119.45,41.91 PR275.2 PR276.2
HWPG_VDDR: length 196.4
  TOP w0.102: v1(167.13,30.66) 166.96,30.49 D51.1
  IN2 w0.089: v1(123.29,40.79) 122.74,40.25 122.74,39.1 122.59,38.95 122.59,37.49 127.6,32.49 129.84,32.49 130.52,31.81 130.52,31.17 131.05,30.64 131.38,30.64 132,30.01 132,27.16 133.56,25.6 142.34,25.6 146.63,29.89 148.48,29.89 148.84,29.53 148.84,29.18 149.23,28.8 151.69,28.8 152.54,29.64 155.6,29.64 157.48,31.52 164.02,31.52 164.81,30.73 165.34,30.73 165.42,30.66 v1(167.13,30.66)
  IN3 w0.089: v1(123.29,40.79) 123.11,40.97 123.11,41.21 122.46,41.85 122.46,48.28 119.98,50.77 119.98,51.54 119.32,52.19 117.69,52.19 117.45,52.43 117.45,52.98 118.74,54.27 118.74,61.75 115.59,64.9 115.59,68.5 114.13,69.96 114.13,70.95 114.21,71.03 114.76,71.03 115.17,71.44 115.17,73.27 114.13,74.31 114.13,75.41 113.11,76.43 107.73,76.43 107.38,76.79 107.38,82.61 108.19,83.43 108.19,90.54 108.7,91.05 108.7,92.19 108.44,92.44 108.44,92.54 108.17,92.82 107.86,92.82 107.81,92.77 107.49,92.77 106.15,94.11 106.15,94.38 105.85,94.68 105.85,97.88 104.92,98.81 101.07,98.81 100.92,98.96 100.92,99.92 99.52,101.31 99.52,101.57 98.44,102.65 98.44,103.08 98.06,103.47 98.06,111.75 97.68,112.12 97.68,113.52 97.01,114.19 97.01,115.17 95.9,116.28 94.65,116.28 92.67,118.26 90.36,118.26 84.9,123.72 77.86,123.72 77.76,123.83 68.65,123.83 67.81,124.67 64.46,124.67 64,125.13 64,125.31 v1(63.71,125.59)
  BOTTOM w0.102: v1(63.71,125.59) 63.46,125.84 62.32,125.84 62.05,125.58 PR9265.1 62.05,124.5 PR267.2
I2CA_SCL: length 13.1
  BOTTOM w0.102: U8.B7 98.83,93.43 98.83,92.33 98.43,91.93 96.18,91.93 95.47,91.22 94.55,91.22 94.23,90.91 92.15,90.91 91.2,89.96 R326.1 91.65,88.96 91.65,87.9 R25540.1
I2CA_SDA: length 9.4
  BOTTOM w0.102: U8.A7 99.23,92.45 98.51,91.73 96.27,91.73 95.56,91.02 94.7,91.02 94.38,90.7 92.61,90.7 92.17,90.27 R25492.1
ICMNT: length 92.2
  TOP w0.102: C6564.2 v1(198.73,11.92) 198.73,13.13 199.98,14.39 v2(199.98,15.12) 199.98,16.23 199.63,16.58 U37.67
  IN2 w0.089: v2(199.98,15.12) 199.98,15.12 199.79,15.31 199.79,15.58 199.42,15.95 199.42,17.97 199.69,18.25 200.25,18.25 200.63,18.62 200.63,19.09 200.26,19.46 199.5,19.46 198.67,20.28 198.67,23.42 198.05,24.04 198.05,25.44 197.27,26.22 196.65,26.22 196.55,26.11 195.13,26.11 194.84,25.83 194.05,25.83 192.96,26.93 192.96,28.45 190.92,30.48 185.42,30.48 184.33,31.58 181.48,31.58 181.48,31.58 181.36,31.58 180.76,32.18 177.88,32.18 177.07,31.37 175.11,31.37 174.75,31.02 174.32,31.02 174,31.34 170.62,31.34 169.92,32.03 165.46,32.03 164.81,32.69 160.93,32.69 158.89,34.73 156.03,34.73 154.8,33.49 146.71,33.49 146.48,33.26 145.5,33.26 144.59,34.17 143.34,34.17 139.86,30.69 138.42,30.69 137.43,31.69 v1(137.43,32.88)
  BOTTOM w0.203: PR32.1 137.17,32.63 v1(137.43,32.88) 137.43,33.35 PC37.2
ILIM_HI: length 2.4
  TOP w0.102: U14.16 18.03,47.88 17.82,48.09 16.8,48.09 16.57,47.86 R414.1
ILIM_LO: length 2.1
  TOP w0.102: R415.2 16.81,48.38 U14.15
IMON_CORE: length 1.8
  BOTTOM w0.203: PR7014.2 141.54,50.28 140.95,50.87 PU7000.1
IMON_GT: length 3.6
  BOTTOM w0.203: PR7004.2 137.32,59.83 137.7,59.45 PC423.1 138.08,59.45 138.4,59.13 138.55,59.13 138.85,58.83 138.85,58.41 138.61,58.17 138.61,58.17 138.55,58.11 PU7000.30
IMON_SA: length 3.3
  TOP w0.203: PR7005.2 141.57,56.14 142.02,56.59 PC7003.2 142.1,56.76 142.68,56.17 v1(142.89,56.17)
  BOTTOM w0.203: PU7000.39 142.38,55.87 142.69,56.17 v1(142.89,56.17)
IMVP_PWRGD: length 65.8
  IN1 w0.089: v1(132.36,60.13) 132.36,59.57 133.98,57.94 136.09,57.94 137.12,58.96 137.6,58.96 137.78,58.79 137.78,58.46 138.07,58.17 138.99,58.17 141.08,60.26 141.08,62.01 140.82,62.28 v1(140.4,62.28) ; v1(123.11,69.3) 121.76,69.3 118.81,72.25 117.66,72.25 116.44,71.03 116.44,69.61 115.15,68.31 107.66,68.31 106.57,69.4 v1(104.95,69.4)
  IN3 w0.089: v1(123.11,69.3) 123.67,69.86 129.82,69.86 132.36,67.33 v1(132.36,60.13)
  BOTTOM w0.102: PR7067.1 PR7068.2 143.85,58.31 143.95,58.41 143.95,59.1 143.88,59.18 143.88,60.1 143.66,61.18 143.47,61.37 143.47,62.17 143.46,62.2 143.27,62.39 142.61,62.39 142.49,62.28 v1(140.4,62.28) ; U2029.2 104.96,70.98 104.81,70.83 104.81,70.17 104.95,70.03 v1(104.95,69.4) 104.63,69.4 104.53,69.3 R2466.1
IMVP_PWRGD_3V: length 130.8
  IN1 w0.089: v2(61.77,27.57) 63.53,25.81 63.53,23.25 64.28,22.5 64.28,21.56 65.51,20.33 67.09,20.33 67.82,19.6 81.15,19.6 83.5,21.96 88.91,21.96 93.47,17.39 v1(95.9,17.39)
  IN3 w0.089: v1(103.99,69.68) 104.11,69.68 104.79,69 105.01,69 106.24,67.77 106.24,67.42 107.12,66.54 107.12,65.02 108.14,63.99 v1(108.77,63.99) 108.77,62.62 110.75,60.64 110.75,57.16 108.05,54.46 108.05,51.04 110.44,48.64 110.44,41.87 108.77,40.19 108.77,32.17 106.13,29.52 106.13,28.79 104.79,27.45 104.57,27.45 103.1,25.98 103.1,24.55 102.59,24.04 100.63,24.04 100.2,23.61 97.78,23.61 97.23,23.06 97.23,21.72 97.88,21.07 97.88,20.49 97.04,19.66 97.04,18.54 v1(95.9,17.39)
  BOTTOM w0.102: v1(108.77,63.99) 110.1,63.99 110.71,63.38 Q2024.2 ; v2(61.77,27.57) 61.77,28.7 62.8,29.72 62.8,32.3 62.27,32.83 62.27,39.46 63.87,41.06 R2512.2 ; U2029.4 103.54,69.86 103.58,69.82 103.58,69.48 103.55,69.45 R2483.1 103.81,68.9 103.86,68.95 R2466.2 104.08,69.59 v1(103.99,69.68)
IN_CLK: length 120.4
  TOP w0.102: v1(27.16,81.59) 27.16,81.32 27.04,81.2 26.67,81.2 26.59,81.28 25.45,81.28 25.36,81.36 R1291.1 C849.1
  IN3 w0.089: v1(27.16,81.59) 27.16,81.33 27.03,81.19 26.66,81.19 26.59,81.27 26.15,81.27 25.84,81.57 25.84,83.01 26.13,83.3 26.13,86.98 26.82,87.68 26.82,94.2 26.17,94.85 26.17,97.46 26.64,97.93 27.01,97.93 30.86,101.78 37.58,101.78 39.19,100.16 42.33,100.16 42.65,99.84 45.62,99.84 46.24,99.22 52.36,99.22 56.09,102.96 58.34,102.96 58.68,102.61 64.97,102.61 66.61,100.98 69.4,100.98 70.98,99.4 74.47,99.4 74.77,99.1 75.23,99.1 76.19,98.13 76.94,98.13 77.27,97.81 77.27,97.3 78.29,96.27 79.58,96.27 81.32,94.52 81.97,94.52 83.55,92.94 83.55,92.31 84.59,91.27 85.08,91.27 86.84,89.52 87.36,89.52 90.51,86.37 90.51,84.91 91.91,83.52 91.91,82.5 92.52,81.89 92.52,79.9 92.92,79.5 92.92,77.08 92.67,76.83 92.67,75.31 93.81,74.17 93.81,73.52 93.61,73.32 93.61,72.2 95.59,70.22 95.59,69.09 95.14,68.64 94.11,68.64 93.91,68.45 93.91,68.1 93.82,68.01 v4(93.68,68.01)
  BOTTOM w0.102: U2030.G56 93.57,67.61 93.79,67.83 93.79,67.9 v4(93.68,68.01)
IN_CLK#: length 120.4
  TOP w0.102: v1(27.16,80.81) 26.99,80.99 26.58,80.99 26.5,81.06 25.56,81.06 25.36,80.86 R1290.1 C847.1
  IN3 w0.089: v1(27.16,80.81) 26.99,80.99 26.58,80.99 26.5,81.06 26.06,81.06 25.64,81.49 25.64,83.09 25.93,83.38 25.93,87.07 26.62,87.76 26.62,94.12 25.97,94.77 25.97,97.55 26.55,98.13 26.93,98.13 30.78,101.98 37.66,101.98 39.28,100.37 42.41,100.37 42.74,100.04 45.71,100.04 46.32,99.43 52.28,99.43 56.01,103.16 58.42,103.16 58.77,102.82 65.05,102.82 66.69,101.18 69.49,101.18 71.06,99.6 74.55,99.6 74.86,99.3 75.32,99.3 76.28,98.34 77.02,98.34 77.47,97.89 77.47,97.38 78.38,96.47 79.66,96.47 81.41,94.73 82.05,94.73 83.75,93.03 83.75,92.39 84.67,91.48 85.17,91.48 86.92,89.72 87.45,89.72 90.72,86.46 90.72,85 92.11,83.6 92.11,82.59 92.72,81.98 92.72,79.99 93.13,79.58 93.13,77 92.88,76.75 92.88,75.4 94.02,74.26 94.02,73.43 93.81,73.23 93.81,72.28 95.79,70.3 95.79,69.01 95.23,68.44 94.19,68.44 94.12,68.36 94.12,68.18 v4(94.29,68.01)
  BOTTOM w0.102: v4(94.29,68.01) 94.29,67.9 U2030.F56
IN_CLK#_R: length 11.2
  TOP w0.102: v1(26.3,80.63) R1290.2
  BOTTOM w0.102: C1679.1 16.87,81.29 19.64,81.29 v1(20.18,80.76) 20.71,81.29 23.42,81.29 23.62,81.09 25.84,81.09 v1(26.3,80.63)
IN_CLK_R: length 11.2
  TOP w0.102: v1(26.3,81.77) R1291.2
  BOTTOM w0.102: v1(26.3,81.77) 25.83,81.3 23.71,81.3 23.51,81.51 20.72,81.51 v1(20.18,82.05) 19.63,81.51 16.86,81.51 C1681.1
IN_D0: length 134.4
  TOP w0.102: C852.1 R1285.1 25.36,75.62 25.42,75.56 27.15,75.56 27.24,75.65 v1(27.24,75.88)
  IN3 w0.089: v4(93.67,65.33) 93.79,65.33 93.91,65.46 93.91,65.88 94.28,66.25 94.92,66.25 96.88,68.2 96.88,71.87 96.3,72.45 96.3,73.13 95.52,73.92 95.52,74.92 94.4,76.03 94.4,82.23 93.1,83.53 93.1,85.86 92.87,86.1 92.87,87.09 89.11,90.86 88.52,90.86 86.77,92.61 86.29,92.61 85.01,93.89 84.29,93.89 81.33,96.85 80.68,96.85 79.88,97.66 79.33,97.66 77.66,99.33 76.69,99.33 75.73,100.29 75.27,100.29 74.89,100.67 71.95,100.67 68.32,104.3 65.42,104.3 64.2,105.52 59.55,105.52 58.21,104.18 55.59,104.18 51.91,100.5 46.72,100.5 46.16,101.05 43.55,101.05 42.43,102.17 38.95,102.17 38.15,102.97 30.21,102.97 29.38,102.14 28.55,102.14 24.71,98.31 24.71,87.15 24.93,86.94 24.93,83.87 24.62,83.57 24.62,80.76 25.22,80.16 25.22,79.32 25.9,78.64 25.9,76.17 26.48,75.6 26.73,75.6 26.85,75.47 27.1,75.47 27.24,75.61 v1(27.24,75.88)
  BOTTOM w0.102: v4(93.67,65.33) 93.79,65.44 93.79,65.56 93.7,65.65 93.7,65.73 93.66,65.78 U2030.G53
IN_D0#: length 134.4
  TOP w0.102: v1(27.24,75.1) 26.99,75.35 25.56,75.35 25.36,75.15 R1284.1 C853.1
  IN3 w0.089: v4(94.29,65.35) 94.12,65.52 94.12,65.8 94.36,66.04 95,66.04 97.08,68.12 97.08,71.96 96.51,72.54 96.51,73.21 95.72,74 95.72,75 94.6,76.12 94.6,82.32 93.31,83.61 93.31,85.95 93.07,86.18 93.07,87.18 89.19,91.06 88.61,91.06 86.85,92.81 86.37,92.81 85.09,94.09 84.38,94.09 81.41,97.06 80.77,97.06 79.97,97.86 79.42,97.86 77.75,99.53 76.77,99.53 75.81,100.49 75.35,100.49 74.97,100.87 72.03,100.87 68.4,104.51 65.5,104.51 64.29,105.72 59.46,105.72 58.13,104.39 55.51,104.39 51.83,100.7 46.8,100.7 46.25,101.26 43.63,101.26 42.51,102.37 39.03,102.37 38.23,103.17 30.12,103.17 29.3,102.35 28.47,102.35 24.51,98.39 24.51,87.07 24.73,86.85 24.73,83.96 24.42,83.65 24.42,80.67 25.02,80.08 25.02,79.24 25.7,78.56 25.7,76.09 26.39,75.39 26.64,75.39 26.76,75.27 27.07,75.27 v1(27.24,75.1)
  BOTTOM w0.102: U2030.F53 94,65.64 v4(94.29,65.35)
IN_D0#_R: length 12.9
  TOP w0.102: R1284.2 v1(26.58,74.92)
  BOTTOM w0.102: C1685.1 16.87,75.2 17.51,75.2 18.77,76.45 23.19,76.45 23.83,75.81 24.18,75.81 v1(24.72,75.28) 25.25,75.81 25.5,75.81 25.93,75.38 26.45,75.38 26.58,75.25 v1(26.58,74.92)
IN_D0_R: length 12.9
  TOP w0.102: R1285.2 v1(26.58,76.06)
  BOTTOM w0.102: C1684.1 16.86,75.41 17.42,75.41 18.68,76.67 23.28,76.67 23.92,76.03 24.17,76.03 v1(24.72,76.57) 25.26,76.03 25.59,76.03 26.02,75.6 26.42,75.6 26.58,75.75 v1(26.58,76.06)
IN_D1: length 120
  TOP w0.102: C851.1 R1287.1 25.36,77.67 25.53,77.5 26.59,77.5 26.9,77.19 27.33,77.19 27.6,77.46 27.6,77.63 27.33,77.89 27.19,77.89 v1(27.05,77.75)
  IN3 w0.089: v4(94.3,69.03) 94.48,69.03 94.55,69.1 94.55,69.4 92.44,71.52 92.44,73.26 92.04,73.66 92.04,77.12 92.29,77.37 92.29,79.16 91.93,79.51 91.93,81.64 91.3,82.27 91.3,83.11 89.8,84.61 89.8,86.24 87.28,88.76 86.75,88.76 85.27,90.24 84.97,90.24 84.55,90.66 84.33,90.66 79.32,95.67 77.81,95.67 75.1,98.39 74.64,98.39 74.28,98.74 70.54,98.74 68.99,100.29 66.45,100.29 64.72,102.02 58.37,102.02 58.2,102.19 56.2,102.19 52.64,98.63 49.4,98.63 48.58,97.8 46.72,97.8 45.28,99.24 42.4,99.24 42.08,99.57 38.94,99.57 37.33,101.18 31.11,101.18 27.77,97.84 27.77,94.98 27.42,94.63 27.42,87.43 27.21,87.22 27.21,83.27 27.9,82.59 27.9,81.77 28.59,81.08 28.59,78.07 28.06,77.53 27.8,77.53 27.42,77.91 27.21,77.91 v1(27.05,77.75)
  BOTTOM w0.102: U2030.F58 94.2,68.52 94.42,68.74 94.42,68.9 v4(94.3,69.03)
IN_D1#: length 120
  TOP w0.102: v1(27.6,78.3) 27.6,77.93 27.81,77.72 27.81,77.37 27.42,76.97 26.81,76.97 26.5,77.28 25.52,77.28 25.36,77.13 R1286.1 C848.1
  IN3 w0.089: v1(27.6,78.3) 27.6,78.02 27.88,77.74 27.98,77.74 28.39,78.15 28.39,81 27.7,81.69 27.7,82.5 27.01,83.19 27.01,87.31 27.22,87.51 27.22,94.71 27.57,95.07 27.57,97.93 31.02,101.38 37.42,101.38 39.03,99.77 42.16,99.77 42.49,99.45 45.36,99.45 46.81,98 48.49,98 49.32,98.83 52.55,98.83 56.11,102.39 58.28,102.39 58.45,102.22 64.81,102.22 66.53,100.49 69.07,100.49 70.62,98.94 74.37,98.94 74.72,98.59 75.18,98.59 77.89,95.88 79.4,95.88 84.41,90.87 84.63,90.87 85.05,90.45 85.35,90.45 86.84,88.96 87.37,88.96 90,86.33 90,84.7 91.5,83.2 91.5,82.36 92.14,81.72 92.14,79.6 92.49,79.24 92.49,77.29 92.24,77.03 92.24,73.75 92.64,73.35 92.64,71.6 94.76,69.49 94.76,69.2 v4(94.93,69.03)
  BOTTOM w0.102: v4(94.93,69.03) 94.65,68.75 U2030.E58
IN_D1#_R: length 11.2
  TOP w0.102: v1(26.3,76.82) R1286.2
  BOTTOM w0.102: v1(26.3,76.82) 25.84,77.28 25.08,77.28 24.89,77.09 18.12,77.09 v1(17.57,76.54) 17.02,77.09 16.86,77.09 C1680.1
IN_D1_R: length 11.2
  TOP w0.102: v1(26.3,77.96) R1287.2
  BOTTOM w0.102: C1683.1 16.87,77.3 17.04,77.3 v1(17.57,77.83) 18.1,77.3 24.8,77.3 24.99,77.49 25.83,77.49 v1(26.3,77.96)
IN_D2: length 126
  TOP w0.102: C854.1 R1289.1 25.36,79.46 25.45,79.37 26.57,79.37 26.63,79.31 27.02,79.31 27.16,79.46 v1(27.16,79.69)
  IN3 w0.089: v1(27.16,79.69) 27.16,79.38 27.08,79.3 26.57,79.3 26.51,79.37 26.09,79.37 25.82,79.64 25.82,80.61 25.23,81.19 25.23,83.32 25.53,83.61 25.53,87.34 25.31,87.57 25.31,97.44 26.5,98.64 26.76,98.64 30.49,102.37 37.83,102.37 38.74,101.46 42.29,101.46 43.31,100.44 45.88,100.44 46.51,99.82 52.09,99.82 55.86,103.59 58.46,103.59 59.25,104.37 62.71,104.37 63.54,103.55 67.34,103.55 69.07,101.81 69.41,101.81 71.21,100.01 74.7,100.01 75.02,99.69 75.48,99.69 76.44,98.73 77.41,98.73 79.09,97.06 79.63,97.06 80.43,96.26 81.08,96.26 84.21,93.13 84.8,93.13 86.21,91.72 86.21,90.99 87.08,90.12 89,90.12 91.74,87.37 91.74,85.24 92.49,84.49 92.49,84.41 92.49,82.81 93.23,82.07 93.23,80.31 93.65,79.89 93.65,75.36 94.82,74.19 94.82,72.85 96.29,71.38 96.29,68.85 95.02,67.58 94.29,67.58 93.84,67.14 v4(93.68,67.14)
  BOTTOM w0.102: v4(93.68,67.14) 93.68,66.77 93.76,66.69 U2030.F55
IN_D2#: length 126
  TOP w0.102: v1(27.16,78.91) 26.97,79.1 26.54,79.1 26.48,79.16 25.54,79.16 25.36,78.98 R1288.1 C850.1
  IN3 w0.089: v1(27.16,78.91) 26.98,79.1 26.49,79.1 26.42,79.16 26.01,79.16 25.61,79.56 25.61,80.52 25.03,81.11 25.03,83.4 25.33,83.7 25.33,87.26 25.11,87.48 25.11,97.53 26.42,98.84 26.67,98.84 30.41,102.58 37.91,102.58 38.83,101.66 42.38,101.66 43.39,100.65 45.97,100.65 46.59,100.02 52.01,100.02 55.78,103.79 58.38,103.79 59.17,104.58 62.79,104.58 63.62,103.75 67.42,103.75 69.16,102.02 69.49,102.02 71.3,100.21 74.79,100.21 75.11,99.9 75.56,99.9 76.53,98.93 77.5,98.93 79.17,97.26 79.72,97.26 80.52,96.46 81.17,96.46 84.3,93.33 84.89,93.33 86.42,91.8 86.42,91.07 87.17,90.32 89.08,90.32 91.95,87.46 91.95,85.33 92.7,84.58 92.7,84.32 92.7,82.89 93.43,82.15 93.43,80.39 93.85,79.97 93.85,75.44 95.02,74.28 95.02,72.93 96.49,71.46 96.49,68.77 95.1,67.38 94.38,67.38 94.33,67.33 v4(94.33,67.07)
  BOTTOM w0.102: v4(94.33,67.07) 94.33,67.01 U2030.E55
IN_D2#_R: length 11.9
  TOP w0.102: v1(26.3,78.73) R1288.2
  BOTTOM w0.102: C1682.1 16.86,79.25 17.65,79.25 18.24,79.83 22.32,79.83 v1(22.87,79.28) 23.42,79.83 24.81,79.83 25.45,79.19 26.2,79.19 26.3,79.09 v1(26.3,78.73)
IN_D2_R: length 11.9
  TOP w0.102: v1(26.3,79.87) R1289.2
  BOTTOM w0.102: v1(26.3,79.87) 26.3,79.51 26.2,79.41 25.54,79.41 24.9,80.05 23.4,80.05 v1(22.87,80.58) 22.34,80.05 18.15,80.05 17.56,79.46 16.87,79.46 C1686.1
INT_AMIC-VREFO: length 4.6
  BOTTOM w0.203: C564.1 203.21,38.09 202.39,37.27 v1(202.38,37.27) 202.38,37.18 203.26,36.29 U20.27
  BOTTOM w0.381: C564.1 202.64,38.36 202.36,38.08 R447.2
INT_EDP_AUXN: length 73.6
  TOP w0.102: C556.2 62.45,109.07 62.56,109.17 63.06,109.17 63.21,109.03 63.21,107.15 63.52,106.83 64.85,106.83 65.04,106.64 65.04,106.46 v1(64.79,106.21)
  IN3 w0.089: v4(95.11,61.9) 94.99,61.9 94.45,62.44 94.45,62.67 95.51,63.73 95.51,63.95 97.67,66.12 97.67,72.46 97.33,72.8 97.33,73.51 96.45,74.39 96.45,76.4 95.26,77.59 95.26,82.51 93.98,83.79 93.98,86.23 93.74,86.46 93.74,87.46 89.45,91.75 88.89,91.75 87.18,93.45 87.18,93.55 86.55,94.18 86.55,94.93 85.6,95.87 84.02,95.87 82.69,97.2 82.5,97.2 81.97,97.73 81.05,97.73 80.25,98.53 79.7,98.53 78.02,100.2 77.05,100.2 76.09,101.17 75.63,101.17 75.16,101.64 72.22,101.64 67.47,106.39 67.47,106.58 67.03,107.02 65.33,107.02 65.08,106.77 65.08,106.5 v1(64.79,106.21)
  BOTTOM w0.102: v4(95.11,61.9) 94.65,61.44 U2030.E45
INT_EDP_AUXN_C: length 11.7
  TOP w0.102: C556.1 61.67,108.99 61.49,109.17 60.83,109.17 60.73,109.07 R25271.1 60.28,109.09 60.27,109.09 60.22,109.14 59.41,109.14 59.31,109.04 59.31,108.31 v1(59.53,108.09)
  BOTTOM w0.102: v1(59.53,108.09) 59.31,108.31 59.31,108.67 58.96,109.03 55.31,109.03 54.52,108.24 54.52,107.76 54.35,107.59 CN29.22
INT_EDP_AUXP: length 73.6
  TOP w0.102: C557.2 62.45,109.49 62.55,109.39 63.15,109.39 63.42,109.12 63.42,107.24 63.61,107.05 64.94,107.05 65.25,106.73 65.25,106.51 v1(65.55,106.21)
  IN3 w0.089: v4(94.27,61.7) 94.54,61.7 94.65,61.81 94.65,61.95 94.25,62.36 94.25,62.76 95.3,63.82 95.3,64.04 97.47,66.2 97.47,72.38 97.13,72.72 97.13,73.43 96.25,74.31 96.25,76.31 95.06,77.51 95.06,82.43 93.78,83.71 93.78,86.14 93.54,86.38 93.54,87.37 89.37,91.54 88.81,91.54 86.98,93.37 86.98,93.46 86.35,94.1 86.35,94.84 85.52,95.67 83.94,95.67 82.6,97 82.42,97 81.89,97.53 80.96,97.53 80.16,98.33 79.61,98.33 77.94,100 76.97,100 76.01,100.96 75.55,100.96 75.08,101.43 72.14,101.43 67.26,106.31 67.26,106.5 66.94,106.82 65.42,106.82 65.28,106.68 65.28,106.48 v1(65.55,106.21)
  BOTTOM w0.102: v4(94.27,61.7) 94.4,61.56 94.4,61.38 94.23,61.21 U2030.F45
INT_EDP_AUXP_C: length 11.7
  TOP w0.102: v1(58.77,108.09) 58.99,108.09 59.1,108.19 59.1,109.13 59.32,109.36 60.17,109.36 R25270.1 60.73,109.49 60.83,109.39 61.49,109.39 61.67,109.57 C557.1
  BOTTOM w0.102: CN29.23 54.85,107.61 54.73,107.72 54.73,108.15 55.4,108.81 58.87,108.81 59.1,108.58 59.1,108.19 58.99,108.09 v1(58.77,108.09)
INT_EDP_TXN0: length 83.7
  IN3 w0.089: v4(98.17,63.93) 98.3,63.93 98.42,64.04 98.42,66.12 98.54,66.24 98.54,70.62 98.91,71 98.91,71.5 98.56,71.85 98.56,73.41 98.18,73.8 97.84,73.8 96.99,74.65 96.99,77.73 96.4,78.31 96.4,81.98 94.45,83.93 94.45,86.51 94.21,86.74 94.21,87.65 89.65,92.22 89.09,92.22 87.68,93.63 87.68,94.46 86.23,95.91 86.23,96.62 85.23,97.62 84.18,97.62 83.6,98.2 81.24,98.2 80.44,99 79.89,99 77.26,101.64 75.83,101.64 75.32,102.14 72.42,102.14 67.94,106.63 67.94,106.96 67.4,107.49 65.06,107.49 64.32,106.75 58.34,106.75 57.21,105.62 56.12,105.62 55.95,105.45 55.95,105.24 v1(56.2,104.99)
  BOTTOM w0.076: v4(98.17,63.93) 98.3,63.93 98.42,63.81 98.42,63.43 98.07,63.08 97.28,63.08 97.15,63.05 96.92,63.05 96.85,63.07 96.59,63.07 96.43,63 96.23,62.8 96.23,62.68 96.19,62.64 U2030.C47
  BOTTOM w0.102: C553.2 54.6,103.13 54.72,103.01 54.72,102.49 55.02,102.19 55.65,102.19 55.95,102.5 55.95,104.74 v1(56.2,104.99)
INT_EDP_TXN0_C: length 4.1
  BOTTOM w0.102: C553.1 54.67,104.29 54.67,104.56 53,106.23 53,106.51 52.85,106.66 CN29.19
INT_EDP_TXN1: length 106.1
  IN3 w0.089: v1(49.76,101.84) 49.49,101.84 49.39,101.94 49.39,102.53 50.25,103.39 50.65,103.39 55.08,107.81 55.08,108.04 55.54,108.49 56.81,108.49 57.4,109.09 62.38,109.09 63.74,110.44 65.87,110.44 66.93,109.38 68.81,109.38 71.51,106.69 73.47,106.69 75.24,104.91 75.93,104.91 76.73,104.11 76.73,103.83 77.11,103.45 77.98,103.45 80.18,101.25 81.28,101.25 82.39,100.14 85.31,100.14 85.51,99.94 85.87,99.94 86.84,98.97 88.6,98.97 89.12,98.44 89.95,98.44 90.84,97.55 90.84,94.62 91.62,93.84 91.62,93.75 91.89,93.48 91.89,92.51 92.59,91.81 93.25,91.81 96.68,88.38 96.68,84.94 98.6,83.01 99.26,83.01 100.26,82.02 100.26,80.41 99.48,79.64 99.48,77.19 100.85,75.82 100.85,74.71 101.41,74.15 101.41,72.53 101.15,72.27 101.15,71.11 100.82,70.78 100.82,65.44 100.7,65.31 100.7,62.16 99.83,61.3 99.83,60.74 99.78,60.68 v1(99.55,60.68)
  BOTTOM w0.076: 97.78,61.16 97.71,61.16 97.71,61.16 97.48,61.07 97.27,61.07 97.13,61.12 96.99,61.12 96.76,61.06 96.61,61.06 96.46,61.13 96.04,61.13 95.75,61.42 U2030.D46
  BOTTOM w0.102: C555.2 52.65,103.13 52.74,103.04 52.74,102.44 51.47,101.18 49.62,101.18 49.48,101.32 49.48,101.55 v1(49.76,101.84) ; 97.78,61.16 99.73,61.16 99.84,61.05 99.84,60.77 99.75,60.68 v1(99.55,60.68)
INT_EDP_TXN1_C: length 3.9
  BOTTOM w0.102: CN29.16 51.35,106.64 51.49,106.49 51.49,106.18 52.68,104.99 52.68,104.33 C555.1
INT_EDP_TXN2: length 95
  IN3 w0.089: v1(100.24,62.31) 99.87,62.68 99.87,63.2 100.24,63.57 100.24,65.49 100.43,65.68 100.43,70.98 100.6,71.15 100.6,72.37 100.98,72.75 100.98,73.82 100.39,74.41 100.39,75.51 98.66,77.24 98.66,81.2 97.93,81.93 97.93,82.46 96.28,84.11 96.28,88.04 94,90.31 94,90.5 93.09,91.41 92.43,91.41 91.5,92.34 91.5,93.23 90.44,94.29 90.44,97.3 89.69,98.05 88,98.05 87.53,98.52 86.51,98.52 86.01,99.02 84.76,99.02 84.03,99.75 82.22,99.75 81.11,100.86 80.02,100.86 77.81,103.06 76.38,103.06 75.63,103.81 74.37,103.81 73.06,105.12 71.94,105.12 70.47,106.59 70.47,107.16 68.68,108.95 66.81,108.95 65.71,110.05 63.93,110.05 62.57,108.69 57.87,108.69 57.47,108.29 57.47,107.85 57.14,107.53 55.35,107.53 50.68,102.86 50.68,102.11 v1(50.42,101.85)
  BOTTOM w0.102: v1(50.42,101.85) 50.67,102.09 50.67,102.68 C1675.2 ; v1(100.24,62.31) 100.05,62.12 100.05,61.9 99.78,61.63 97.48,61.63 97.37,61.53 U2030.A45
INT_EDP_TXN2_C: length 3.8
  BOTTOM w0.102: C1675.1 50.24,103.91 50.63,104.3 50.63,104.73 49.83,105.53 49.83,106.15 49.99,106.3 49.99,106.49 49.85,106.64 CN29.13
INT_EDP_TXN3: length 97
  IN3 w0.089: v1(47.53,102.04) 47.81,101.76 48.45,101.76 48.77,101.44 51.42,101.44 54.49,104.52 54.49,105.83 55.5,106.84 57.3,106.84 58.01,107.56 62.89,107.56 63.33,107.99 63.33,108.48 64.28,109.43 65.48,109.43 66.58,108.34 67.84,108.34 68.9,107.28 68.9,106.8 72.69,103.01 75.59,103.01 76.16,102.44 77.59,102.44 79.77,100.26 80.87,100.26 82.12,99 83.93,99 84.51,98.42 85.77,98.42 86.82,97.37 87.54,97.37 88.56,96.35 88.56,94.26 89.22,93.6 90.28,93.6 90.9,92.98 90.9,92.1 92.22,90.78 92.87,90.78 93.41,90.25 93.41,89.59 95.04,87.96 95.04,87.05 95.25,86.84 95.25,84.28 97.29,82.24 97.29,81.7 97.93,81.07 97.93,76.91 99.14,75.7 99.14,74.31 99.5,73.95 99.8,73.95 100.29,73.46 100.29,72.98 99.96,72.65 99.96,71.66 99.83,71.53 99.83,66.1 99.63,65.9 99.63,63.9 98.72,62.99 98.72,62.44 v1(98.9,62.25)
  BOTTOM w0.102: C1678.2 48.59,102.73 48.59,102.35 48.06,101.81 47.76,101.81 v1(47.53,102.04) ; U2030.A47 97.23,62.64 97.17,62.58 97.17,62.43 97.25,62.36 97.55,62.36 97.85,62.66 98.5,62.66 v1(98.9,62.25)
INT_EDP_TXN3_C: length 3.5
  BOTTOM w0.102: CN29.10 48.35,106.66 48.49,106.52 48.49,105.33 48.6,105.23 48.6,104.31 C1678.1
INT_EDP_TXP0: length 83.8
  IN3 w0.089: v1(55.44,104.99) 55.74,105.29 55.74,105.54 56.04,105.83 57.13,105.83 58.26,106.96 64.24,106.96 64.97,107.69 67.49,107.69 68.14,107.04 68.14,106.71 72.5,102.35 75.4,102.35 75.91,101.84 77.34,101.84 79.98,99.2 80.52,99.2 81.33,98.4 83.68,98.4 84.27,97.82 85.32,97.82 86.43,96.7 86.43,96 87.89,94.54 87.89,93.71 89.18,92.42 89.73,92.42 94.42,87.74 94.42,86.83 94.65,86.59 94.65,84.02 96.61,82.06 96.61,78.39 97.19,77.81 97.19,74.74 97.93,74 98.26,74 98.77,73.5 98.77,71.93 99.12,71.59 99.12,70.91 98.74,70.54 98.74,66.15 98.62,66.03 98.62,64.11 v1(98.8,63.93)
  BOTTOM w0.076: v1(98.8,63.93) 98.58,63.71 98.58,63.36 98.14,62.92 97.3,62.92 97.18,62.88 96.9,62.88 96.82,62.91 96.63,62.91 96.52,62.86 96.4,62.74 U2030.C46
  BOTTOM w0.102: C552.2 54.94,102.76 54.94,102.58 55.11,102.41 55.56,102.41 55.74,102.59 55.74,104.69 v1(55.44,104.99)
INT_EDP_TXP0_C: length 4.1
  BOTTOM w0.102: C552.1 54.89,104.33 54.89,104.65 53.22,106.31 53.22,106.53 53.35,106.66 CN29.20
INT_EDP_TXP1: length 106
  IN3 w0.089: v1(49,101.84) 49.19,102.02 49.19,102.61 50.17,103.59 50.57,103.59 54.88,107.9 54.88,108.12 55.45,108.7 56.72,108.7 57.31,109.29 62.3,109.29 63.66,110.65 65.96,110.65 67.02,109.59 68.89,109.59 71.59,106.89 73.55,106.89 75.32,105.12 76.01,105.12 76.93,104.2 76.93,103.92 77.19,103.66 78.06,103.66 80.26,101.45 81.36,101.45 82.47,100.34 85.39,100.34 85.59,100.14 85.95,100.14 86.92,99.17 88.68,99.17 89.21,98.65 90.03,98.65 91.04,97.64 91.04,94.71 91.82,93.93 91.82,93.84 92.1,93.56 92.1,92.59 92.68,92.01 93.33,92.01 96.88,88.46 96.88,85.02 98.69,83.22 99.35,83.22 100.46,82.1 100.46,80.33 99.68,79.55 99.68,77.27 101.05,75.91 101.05,74.8 101.61,74.24 101.61,72.44 101.36,72.19 101.36,71.03 101.03,70.7 101.03,65.36 100.9,65.23 100.9,62.08 100.04,61.22 100.04,60.88 v1(100.23,60.68)
  BOTTOM w0.076: U2030.C45 96.07,61.33 96.11,61.29 96.5,61.29 96.65,61.22 96.74,61.22 96.97,61.29 97.16,61.29 97.3,61.24 97.45,61.24 97.62,61.3 97.62,61.3 97.77,61.36
  BOTTOM w0.102: v1(100.23,60.68) 100.04,60.88 100.04,61.14 99.81,61.36 97.77,61.36 97.77,61.36 ; v1(49,101.84) 49.26,101.58 49.26,101.23 49.53,100.96 51.56,100.96 52.95,102.35 52.95,102.8 C554.2
INT_EDP_TXP1_C: length 3.9
  BOTTOM w0.102: CN29.17 51.85,106.64 51.71,106.5 51.71,106.27 52.9,105.08 52.9,104.28 C554.1
INT_EDP_TXP2: length 95
  IN3 w0.089: v1(51.19,101.85) 50.98,101.85 50.89,101.94 50.89,102.78 55.43,107.33 57.23,107.33 57.67,107.77 57.67,108.21 57.95,108.49 62.65,108.49 64.01,109.85 65.63,109.85 66.73,108.75 68.6,108.75 70.27,107.08 70.27,106.51 71.86,104.91 72.98,104.91 74.29,103.61 75.55,103.61 76.3,102.86 77.73,102.86 79.93,100.65 81.03,100.65 82.14,99.54 83.95,99.54 84.67,98.82 85.93,98.82 86.43,98.32 87.45,98.32 87.92,97.85 89.6,97.85 90.24,97.21 90.24,94.21 91.3,93.15 91.3,92.26 92.35,91.21 93,91.21 93.8,90.41 93.8,90.23 96.07,87.96 96.07,84.03 97.72,82.38 97.72,81.85 98.46,81.11 98.46,77.15 100.18,75.43 100.18,74.33 100.77,73.74 100.77,72.83 100.39,72.45 100.39,71.23 100.23,71.07 100.23,65.77 100.04,65.58 100.04,63.65 99.67,63.29 99.67,62.42 v1(99.55,62.31)
  BOTTOM w0.102: U2030.B45 97.05,61.83 99.7,61.83 99.85,61.98 99.85,62.2 99.74,62.31 v1(99.55,62.31) ; C1676.2 50.89,102.77 50.89,101.94 50.98,101.85 v1(51.19,101.85)
INT_EDP_TXP2_C: length 3.8
  BOTTOM w0.102: CN29.14 50.35,106.64 50.21,106.49 50.21,106.21 50.05,106.06 50.05,105.62 50.85,104.82 50.85,104.3 C1676.1
INT_EDP_TXP3: length 97
  IN3 w0.089: v1(98.27,62.25) 98.42,62.25 98.51,62.34 98.51,63.07 99.43,63.98 99.43,65.98 99.63,66.19 99.63,71.61 99.76,71.74 99.76,72.73 100.09,73.06 100.09,73.37 99.71,73.75 99.42,73.75 98.94,74.22 98.94,75.61 97.72,76.83 97.72,80.98 97.09,81.62 97.09,82.15 95.05,84.2 95.05,86.75 94.84,86.96 94.84,87.87 93.2,89.51 93.2,90.16 92.79,90.58 92.13,90.58 90.7,92.01 90.7,92.9 90.2,93.4 89.13,93.4 88.35,94.18 88.35,96.27 87.46,97.17 86.73,97.17 85.68,98.22 84.42,98.22 83.84,98.8 82.04,98.8 80.78,100.06 79.68,100.06 77.51,102.23 76.08,102.23 75.51,102.81 72.6,102.81 68.69,106.72 68.69,107.19 67.75,108.13 66.5,108.13 65.4,109.23 64.37,109.23 63.54,108.4 63.54,107.91 62.98,107.35 58.1,107.35 57.38,106.63 55.59,106.63 54.7,105.74 54.7,104.43 51.5,101.24 48.69,101.24 48.36,101.56 47.74,101.56 47.53,101.36 v1(47.53,101.28)
  BOTTOM w0.102: v1(98.27,62.25) 98.27,62.38 98.19,62.45 97.93,62.45 97.63,62.15 97.16,62.15 96.97,62.35 96.97,62.58 96.91,62.64 U2030.B47 ; v1(47.53,101.28) 47.53,101.36 47.78,101.6 48.15,101.6 48.81,102.26 48.81,102.73 C1677.2
INT_EDP_TXP3_C: length 3.5
  BOTTOM w0.102: CN29.11 48.85,106.63 48.71,106.49 48.71,105.42 48.81,105.32 48.81,104.31 C1677.1
INT_HDMICLK+_OUT: length 3.4
  TOP w0.102: R702.1 16.44,81.17 16.56,81.29 16.83,81.29 16.99,81.12 16.99,80.11 17.24,79.86 17.47,79.86 17.62,79.72 U23.10
INT_HDMICLK-_OUT: length 3.4
  TOP w0.102: U23.9 17.62,80.22 17.47,80.08 17.33,80.08 17.21,80.2 17.21,81.21 16.92,81.5 16.56,81.5 16.44,81.62 R703.1
INT_HDMITX0N_OUT: length 3.3
  TOP w0.102: U23.15 17.78,77.22 17.6,77.05 17.49,77.05 17.08,76.64 17.08,75.86 16.64,75.42 16.54,75.42 16.44,75.52 R697.1
INT_HDMITX0P_OUT: length 3.3
  TOP w0.102: R696.1 16.44,75.1 16.54,75.2 16.73,75.2 17.3,75.77 17.3,76.55 17.58,76.83 17.68,76.83 17.79,76.72 U23.16
INT_HDMITX1N_OUT: length 2.4
  TOP w0.102: R699.1 16.44,77.47 16.54,77.37 16.69,77.37 17.38,78.07 17.59,78.07 17.74,78.22 U23.13
INT_HDMITX1P_OUT: length 2.5
  TOP w0.102: U23.14 17.74,77.72 17.61,77.85 17.47,77.85 16.78,77.16 16.54,77.16 16.44,77.06 R698.1
INT_HDMITX2N_OUT: length 2.3
  TOP w0.102: U23.11 17.62,79.22 17.47,79.08 17.29,79.08 16.9,79.47 16.64,79.47 16.44,79.67 R701.1
INT_HDMITX2P_OUT: length 2.3
  TOP w0.102: R700.1 16.44,79.03 16.66,79.25 16.81,79.25 17.2,78.86 17.47,78.86 17.62,78.72 U23.12
INTRUDER#: length 21.1
  TOP w0.102: v4(80.12,44.29) 80.46,43.95 80.46,43.23 80.13,42.89 79.28,42.89 79.02,43.16 78.07,43.16 77.88,43.36 77.88,43.53 77.61,43.79 77.02,43.79 76.66,44.15 73.72,44.15 73.42,43.85 71.83,43.85 71.37,43.38 67.48,43.38 67.23,43.63 v1(66.37,43.63) 65.81,43.63 65.56,43.38 64.08,43.38 63.19,42.49 R2216.1
  BOTTOM w0.102: v4(80.12,44.29) 79.81,44.6 U2030.AP16
ISEN1N_CORE: length 28.1
  IN1 w0.089: v1(138.21,50.15) 137.25,51.1 136.18,51.1 135.27,52.01 133.88,52.01 132.63,53.26 132.63,54.69 129.72,57.6 129.72,58.58 129.55,58.75 127.12,58.75 125.67,60.2 125.67,62.19 v1(125.39,62.47)
  IN2 w0.203: v1(138.21,50.15) 138.36,49.99 138.36,47.74 v1(138.24,47.61)
  BOTTOM w0.203: v1(138.21,50.15) 138.21,50.37 138.55,50.71 PU7000.7 ; PR7074.2 v1(125.39,62.47) ; v1(138.24,47.61) 138.06,47.61 137.86,47.81 PC7025.2 138.2,48.15 138.24,48.11 PC7047.2 PR7075.2
ISEN1N_GT: length 60.7
  TOP w0.102: PR7100.2 132.9,56.76 133.1,56.96 PC7100.2 PC7097.2 133.53,58.71 135.46,58.71 v1(135.51,58.76)
  IN3 w0.089: v1(114.49,84.85) 113.65,84.01 113.65,83.18 114.55,82.28 115.6,82.28 117.76,80.13 121.35,80.13 122.62,81.4 126.6,81.4 128.56,79.44 128.56,77.42 130.44,75.55 130.44,70.68 133.15,67.97 133.15,63.08 135.02,61.2 135.02,60.03 134.79,59.81 134.79,59.09 135.13,58.76 v1(135.51,58.76)
  BOTTOM w0.102: v1(114.49,84.85) 113.65,84.01 113.65,83.48 PR7101.2 113.36,83.19 112.04,81.86 112.04,79.46 111.64,79.06 PR7097.2 ; v1(135.51,58.76) 135.53,58.78
  BOTTOM w0.203: 135.53,58.78 136.2,59.45 PC7030.2 136.54,59.12 137.54,59.12 137.75,58.91 PU7000.28
ISEN1N_SA: length 37.7
  TOP w0.203: PC7099.2 143.85,57.55 143.85,57.22 PC7079.2 144.19,56.58 v1(144.19,56.12) 144.19,55.57 PR7092.2
  IN3 w0.089: v1(144.19,56.12) 144.24,56.07 144.24,55.43 144.62,55.05 144.62,54.27 144.42,54.06 144.42,52.4 144.07,52.05 144.07,50.86 142.13,48.93 142.13,47.25 139.78,44.89 139.63,44.89 139.63,44.89 139,44.89 137.91,43.79 133.63,43.79 130.47,40.63 v1(130.12,40.63)
  BOTTOM w0.102: PR7089.2 129.39,38.86 129.6,39.06 129.6,40.11 v1(130.12,40.63) 130.95,41.46 131.63,41.46 132.42,42.26 PR7093.2
  BOTTOM w0.203: PC7029.2 143.3,55.95 143.3,55.27 143.09,55.07 PU7000.41
  BOTTOM w0.254: PC7029.2 144.01,56.3 v1(144.19,56.12)
ISEN1P_CORE: length 7.8
  BOTTOM w0.203: PR7076.2 PR7075.1 138.75,46.39 139.25,46.9 139.25,48.38 PC7047.1 138.61,49.03 137.82,49.03 136.97,49.88 v1(136.97,49.93) 136.97,50.42 137.35,50.8 PU7000.10
ISEN1P_GT: length 8.6
  TOP w0.102: PR7099.1 133.89,56.71 133.88,56.73 PC7100.1 PC7097.1 135.01,58.28 v1(135.34,57.95) 135.88,57.95 PR7098.2 137.65,59.3 v1(138.31,58.63)
  BOTTOM w0.203: v1(138.31,58.63) 138.15,58.47 PU7000.29
ISEN1P_SA: length 6.3
  TOP w0.102: v1(142.12,58.81) 142.77,58.81 PR7090.1
  TOP w0.203: v1(142.81,55.54) 143.04,55.3 PR7091.2 143.56,55.37 PC7079.1 143.56,57.06 PC7099.1 PR7090.1
  BOTTOM w0.203: PU7000.40 142.74,55.47 v1(142.81,55.54)
ISEN2N_CORE: length 23
  IN1 w0.089: v1(125.59,55.15) 128.15,55.15 132.16,51.15 133.81,51.15 135.29,49.67 137.13,49.67 139.3,47.5 v1(139.74,47.5)
  BOTTOM w0.102: v1(125.59,55.15) PR7083.2
  BOTTOM w0.203: PC7027.2 139.33,45.71 139.33,46.4 PR7085.1 139.82,47.18 139.74,47.26 v1(139.74,47.5) 139.74,47.79 139.76,47.81 PC7065.2 PR7066.1
ISEN2P_CORE: length 10.3
  IN2 w0.203: v1(140.42,48.75) 141.11,48.07 141.11,47.37 v1(140.45,46.71)
  BOTTOM w0.203: PR7065.2 141.03,46.3 PR7084.2 140.83,46.33 v1(140.45,46.71) 139.85,46.11 PR7085.2 ; PU7000.9 137.75,50.77 137.44,50.47 137.44,49.84 137.95,49.33 139.02,49.33 139.46,48.89 PC7065.1 139.96,48.89 140.09,48.75 v1(140.42,48.75)
ISOLATEB: length 5.3
  TOP w0.203: U24.20 47.03,105.2
  TOP w0.254: R509.2 49.69,103.2 R510.2 48.78,104.11 v1(48.04,104.11) 48.04,104.85 47.69,105.2 47.03,105.2
JTAG_TCK: length 6
  BOTTOM w0.102: U8.AE5 97.1,113.31 97.1,114.63 97.03,114.7 97.03,115.55 97.39,115.91 97.39,116.83 97.6,117.03 TP70.1
JTAG_TDI: length 6.2
  BOTTOM w0.102: TP72.1 98.94,117.92 97.86,116.83 97.86,113.92 97.95,113.83 97.95,113.31 U8.AE6
JTAG_TDO: length 6
  BOTTOM w0.102: TP73.1 99.45,117.56 98.94,117.56 98.09,116.71 98.09,114.18 98.43,113.83 U8.AF6
JTAG_TMS: length 3.8
  TOP w0.102: v2(98.05,112.41) 97.22,112.41 96.58,111.77 96.58,111.09 96.81,110.86 TP71.1
  BOTTOM w0.102: v2(98.05,112.41) U8.AD6
JTAG_TRST#: length 3.4
  BOTTOM w0.102: U8.AG4 96.81,114.51 96.81,117.77 R396.1
KB_BL_LED: length 14
  TOP w0.102: U37.113 190.85,29.11 190.36,28.62 190.36,25.81 191.58,24.59 v2(191.58,24.43)
  IN1 w0.089: v2(191.58,24.43) 191.61,24.47 193.49,24.47 193.8,24.16 193.8,23.62 194,23.42 194.13,23.42 194.59,22.95 195.25,22.95 196.66,21.55 v2(196.66,21.34)
  BOTTOM w0.102: Q31.2 195.95,21.24 196.05,21.34 v2(196.66,21.34)
KL_NO_EC: length 60.2
  TOP w0.102: PR9269.2 159.83,27.47 v1(160.08,27.72) ; U37.70 198.18,17.78 197.76,17.36 196.68,17.36 194.45,19.59 194.45,20.24 192.8,21.89 192.8,22.92 v2(192.72,23) ; v1(170.5,28.09) 170.5,27 170.04,26.54 170.04,25.61 171.51,24.14 171.51,22.64 174.93,19.22 174.93,18.32 175.35,17.89 PR9271.2
  IN2 w0.089: v1(160.08,27.72) 160.72,27.09 165.28,27.09 166.49,28.3 170.29,28.3 v1(170.5,28.09) 171.67,28.09 171.9,27.87 174.08,27.87 175.56,26.38 180,26.38 180.15,26.54 184.62,26.54 185,26.15 186.7,26.15 187.3,26.76 187.55,26.76 187.8,26.51 187.8,26.26 188.28,25.79 188.69,25.79 189.2,25.27 191.62,25.27 192.77,24.12 192.77,23.05 v2(192.72,23)
L_SPK+: length 106.7
  IN3 w1.016: 207.55,31.76 207.28,31.48 207.28,29.27 207.55,28.99 207.55,26.54 206.47,25.45 205.64,25.45 203.82,23.63 203.82,23.23 203.01,22.41 199.75,22.41 199.26,21.92 199.26,21.28 199.19,21.21 199.19,20.15 198.17,19.14 193.34,19.14 192.99,19.49 192.29,19.49 191.64,18.83 191.64,17.95 191.18,17.49 188.55,17.49 187.67,18.37 184.42,18.37 183.33,17.28 183.33,16.15 182.48,15.3 115.86,15.3
  BOTTOM w0.203: U20.42 208.65,32.82 208.88,32.6 208.93,32.6 209.05,32.47
  vias: v1(115.56,14.29) v1(116.19,14.29) v1(209.64,32.47) v1(210.32,32.47)
L_SPK+_1:
  vias: v1(115.45,23.1) v1(116.09,23.1)
L_SPK-: length 100.1
  IN3 w1.016: 119.16,14.03 184.45,14.03 186.58,16.17 191.76,16.17 192.81,17.22 193.16,17.22 193.78,17.84 195.51,17.84 196.1,17.26 198.32,17.26 199.05,17.98 200.37,17.98 206.09,23.7 206.51,23.7 208.82,26.01 208.82,29.04
  BOTTOM w0.203: 209.48,31.84 209.04,31.84 208.45,32.43 U20.43
  vias: v1(116.95,14.29) v1(117.59,14.29) v1(209.64,31.84) v1(210.3,31.84)
L_SPK-_1:
  vias: v1(116.85,23.1) v1(117.51,23.1)
LAD0_R: length 2.9
  BOTTOM w0.102: CN17.58 191.61,16.88 192.37,17.64 192.72,17.64 193.09,18.01 R673.1
LAD1: length 2.1
  BOTTOM w0.102: R2662.1 192.01,14.88 CN17.66
LAD2: length 1.9
  BOTTOM w0.102: R2663.1 192.48,14.38 CN17.68
LAD3: length 2
  BOTTOM w0.102: CN17.70 192.33,13.88 R2664.1
LAN_AMBLED#: length 3.4
  TOP w0.102: U24.27 44.73,108.15 45.02,108.44 45.27,108.44 45.63,108.8 46.21,108.8 46.72,109.31 TP74.1
LAN_LED1: length 4.5
  TOP w0.102: TP75.1 47.13,110.27 47.13,109.38 46.34,108.6 45.81,108.6 45.4,108.19 45.27,108.19 45.13,108.05 U24.26
LAN_LED2: length 3.6
  TOP w0.102: TP76.1 47.81,108.98 47.05,108.98 46.47,108.39 45.93,108.39 45.53,107.99 U24.25
LAN_MCTG0: length 3.3
  TOP w0.508: v1(37.46,110.37) 37.7,110.61 R516.2
  BOTTOM w0.508: U25.24 37.9,110.81 v1(37.46,110.37)
LAN_MCTG1: length 2.9
  TOP w0.508: v1(34.46,110.61) R517.2
  BOTTOM w0.508: U25.21 34.9,111.12 34.46,110.68 v1(34.46,110.61)
LAN_MCTG2: length 3
  TOP w0.508: R518.2 31.42,110.61 v1(31.4,110.59)
  BOTTOM w0.508: U25.18 31.9,111.09 v1(31.4,110.59)
LAN_MCTG3: length 2.9
  TOP w0.508: R519.2 v1(28.48,110.61)
  BOTTOM w0.508: U25.15 28.9,111.03 v1(28.48,110.61)
LAN_WAKE#: length 29.8
  TOP w0.079: 75.25,37.81 75.34,37.81 75.41,37.74 78.37,37.74 78.5,37.87 78.66,37.87 79.21,38.42 79.21,38.96 79.53,39.28 80.18,39.28 80.99,40.08 80.99,40.83 81.21,41.06 81.21,41.84 80.99,42.06 80.68,42.06 80.48,42.27 80.48,42.75 80.68,42.95 81.12,42.95 v4(81.48,43.32)
  TOP w0.102: 75.25,37.81 75.02,37.81 74.53,37.32 74.53,34.66 74.33,34.45 74.33,32.73 76.49,30.57 76.49,25.31 75.55,24.37 TP2033.1 R36.1
  BOTTOM w0.102: U2030.AM15 81.48,43.47 v4(81.48,43.32)
LAN_XTAL1: length 4.2
  TOP w0.102: R511.1 45.88,110.7 45.87,110.71 C638.2 45.17,111.94 45.17,112.79 Y4.1
LFRAME#_R: length 2.4
  BOTTOM w0.102: R675.1 192.71,16.93 191.66,15.88 CN17.62
LGATE1_CORE: length 10.4
  IN3 w0.508: v1(119.13,67.07) 119.13,66.55 120.42,65.26 121.32,65.26 121.91,65.85 124.67,65.85 v1(125.26,65.26)
  BOTTOM w0.254: v1(119.13,67.07) 118.81,67.07 118.46,67.42 PU7002.7
  BOTTOM w0.508: PQ7000.8 v1(125.26,65.26)
LGATE2_CORE: length 7.8
  IN3 w0.508: v1(133.6,50.34) 133.6,50.66 133.09,51.17 131.3,51.17 130.67,51.8 v1(130.01,51.8)
  BOTTOM w0.305: v1(133.6,50.34) 133.36,50.1 PU7001.7
  BOTTOM w0.508: v1(130.01,51.8) 129.55,51.8 129.04,51.29 PQ7001.8
LGATE_GT: length 9.4
  BOTTOM w0.254: 127.85,79.56 128.25,79.15 PU7003.7
  BOTTOM w0.508: 127.85,79.56 127,80.4 v1(126.3,80.4) 125.69,81.01 122.74,81.01 121.5,79.77 121.5,79.21 PQ7004.8
LGATE_SA: length 6.6
  IN3 w0.508: v1(138.46,40.03) 138.81,40.03 139.41,40.63 139.76,40.63 141.67,42.54 v1(141.67,43.49)
  BOTTOM w0.305: v1(141.67,43.49) 141.4,43.49 140.98,43.07 PU7004.7
LID#: length 377.8
  TOP w0.102: R25315.2 180.58,30.07 v2(180.58,30.34) ; v1(35.95,118.53) 35.57,118.53 34.96,119.14 34.96,119.58 33.95,120.59 HE1.1 ; v1(55.45,110.77) 55.57,110.65 R25370.2 55.48,110.1 54.54,111.04 D3.1
  IN1 w0.089: v1(24.55,102.45) 24.65,102.56 25.8,102.56 26.53,103.29 38.73,103.29 40.53,105.09 41.25,105.09 43.3,107.14 45.32,107.14 46,106.46 48.36,106.46 51.26,109.36 52.55,109.36 53.24,110.04 54.73,110.04 v1(55.45,110.77) ; v1(37.49,26.35) 37.55,26.28 37.55,23.86 38.31,23.1 45.15,23.1 46.18,22.06 46.18,20 46.98,19.2 46.98,17.57 46.21,16.8 46.21,14.53 45.15,13.47 v1(45.15,12.91)
  IN2 w0.089: v1(55.45,110.77) 56.13,111.44 60.45,111.44 60.96,110.93 60.96,110.59 61.6,109.96 65.3,109.96 72.21,103.05 74.21,103.05 78.37,98.89 84.94,98.89 85.15,98.68 86,98.68 86.49,99.16 87.5,99.16 88.27,99.93 88.27,100.67 88.53,100.93 90.18,100.93 90.81,100.3 90.81,92.22 92.17,90.86 93.72,90.86 96.08,88.51 96.73,88.51 98.65,86.58 98.65,85.59 99.07,85.18 99.64,85.18 103.08,81.74 103.08,79.28 103,79.21 103,77.11 103.38,76.74 103.38,69.73 104.65,68.45 105.05,68.45 106.21,67.29 106.95,67.29 107.08,67.43 112.81,67.43 114,66.23 114,62.52 113.64,62.16 113.64,54.56 115.67,52.54 115.67,51.05 117.26,49.47 121.35,49.47 122.33,48.49 122.33,42.42 125.15,39.6 125.15,38.52 124.48,37.85 124.48,36.14 127.75,32.87 130.31,32.87 132.86,30.31 132.86,28.55 133.39,28.02 133.39,26.7 134.11,25.98 142.1,25.98 143.05,26.93 143.05,27.88 143.4,28.23 144.32,28.23 146.64,30.55 154.3,30.55 155.65,31.9 164.52,31.9 165.17,31.25 167.95,31.25 168.62,30.57 172.15,30.57 172.76,29.96 177.13,29.96 177.84,30.68 180.19,30.68 180.52,30.34 v2(180.58,30.34)
  BOTTOM w0.102: v1(24.55,102.45) 24.67,102.32 24.67,101 24.45,100.77 24.45,99.27 25,98.72 25,96.94 29.93,92.01 29.93,87.16 30.69,86.4 31.2,86.4 31.79,85.81 31.79,84.26 32.93,83.12 32.93,79.29 34,78.22 34,72.84 33.41,72.26 33.41,71.79 33.64,71.56 33.64,69.87 32.52,68.75 32.52,58.48 35.01,55.99 35.01,52.95 34.35,52.29 34.35,51.81 33.54,51 33.54,50.45 34.35,49.64 34.35,39.36 33.79,38.79 33.79,36.22 36.31,33.7 36.31,31.99 38.03,30.26 38.03,28.84 38.37,28.51 38.37,26.73 37.98,26.35 v1(37.49,26.35) ; CN24.4 44.95,12.62 45.1,12.76 45.1,12.86 v1(45.15,12.91) ; v1(35.95,118.53) 35.95,117.84 37.57,116.22 C841.1 39.61,116.22 39.74,116.09 39.74,115.43 40.49,114.68 41.78,114.68 42.14,114.32 42.14,113.03 42.23,112.94 43.11,112.94 43.65,113.47 43.65,113.98 44.13,114.46 46.95,114.46 47.76,113.65 47.76,111.8 48.53,111.03 52.16,111.03 52.8,110.4 55.09,110.4 v1(55.45,110.77)
