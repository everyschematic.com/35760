# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Nets (continued)
MAINON: PQ16.2 PR120.1 PR265.2 PR6016.1 PR6028.1 PR6417.2 PR9268.2 PR9270.2 R890.1 U37.30
MAINON_ON_G: PQ6.2 PQ12.2 PQ14.2 PQ16.3 PQ19.2 PQ9050.2 PR116.2 PR118.1
MBCLK: PC11.1 PD4.1 PR12.2 PR17.1 R361.1 U37.110
MBDATA: PC10.1 PD3.1 PR13.2 PR19.1 R369.1 U37.111
MDI0+: U24.1 U25.9
MDI0+_1: CN8.1 U25.16
MDI0-: U24.2 U25.8
MDI0-_1: CN8.2 U25.17
MDI1+: U24.4 U25.12(TD4-)
MDI1+_1: CN8.3 U25.13
MDI1-: U24.5 U25.11
MDI1-_1: CN8.6 U25.14
MDI2+: U24.6 U25.2
MDI2+_1: CN8.4 U25.23
MDI2-: U24.7 U25.3
MDI2-_1: CN8.5 U25.22
MDI3+: U24.9 U25.6
MDI3+_1: CN8.7 U25.19
MDI3-: U24.10 U25.5
MDI3-_1: CN8.8 U25.20
ME_WR#: R2494.2 U37.109
MEM_VREF_CTL_QA: Q20.3 R411.1 R25283.1
MIC2-VREFO: R468.1 R471.1 U20.29
MINICAR_PME#: CN17.55 Q33.1(S) R651.2
MODEM_CLKREQ: R679.2 U36.1 U36.2 U2030.AK9
MODEM_CLKREQ_L: CN17.14 R678.1 U36.4
MPHY_EXT_PWR: R2289.1 U2030.AM10
MX0: C725.1 CN18.10 CN19.10 U37.58
MX1: C727.1 CN18.9 CN19.9 U37.59
MX2: C723.1 CN18.8 CN19.8 U37.60
MX3: C722.1 CN18.7 CN19.7 U37.61
MX4: C720.1 CN18.6 CN19.6 U37.62
MX5: C726.1 CN18.5 CN19.5 U37.63
MX6: C721.1 CN18.4 CN19.4 U37.64
MX7: C724.1 CN18.3 CN19.3 U37.65
MY0: C719.1 CN18.26 CN19.26 U37.36
MY1: C716.1 CN18.25 CN19.25 U37.37
MY2: C717.1 CN18.24 CN19.24 U37.38
MY3: C708.1 CN18.23 CN19.23 U37.39
MY4: C718.1 CN18.22 CN19.22 U37.40
MY5: C707.1 CN18.21 CN19.21 U37.41
MY6: C706.1 CN18.20 CN19.20 U37.42
MY7: C709.1 CN18.19 CN19.19 U37.43
MY8: C711.1 CN18.18 CN19.18 U37.44
MY9: C713.1 CN18.17 CN19.17 U37.45
MY10: C714.1 CN18.16 CN19.16 U37.46
MY11: C715.1 CN18.15 CN19.15 U37.51
MY12: C728.1 CN18.14 CN19.14 U37.52
MY13: C729.1 CN18.13 CN19.13 U37.53
MY14: C730.1 CN18.12 CN19.12 U37.54
MY15: C731.1 CN18.11 CN19.11 U37.55
MY16: C732.1 CN18.28 CN19.28 U37.56
MY17: C733.1 CN18.27 CN19.27 U37.57
N12E_SCL: R367.1 U8.C9
N12E_SDA: R368.1 U8.C8
NBSWON#: C6615.2 C20024.1 CN19.1 R720.2 R25313.1 R25314.1 SW1.1 SW1.2 U37.107
NGFF_SATA_DET: R134.1 R653.1 R2547.2
NV_PLLVDD: C457.2 C458.2 L7.2 L31.2 U8.L6
ODD_PRSNT#: C780.1 R640.2 R25475.1 U2030.AB2
ODD_PRSNT#_C: C779.1 CN15.8 R640.1 R641.1
PBA_FP_PWREN#: R609.1 U37.76
PBA_PWR: C749.2 Q32.1(S) R608.1 R25295.2
PBA_PWR_C: CN14.8 R614.2
PBA_PWR_R: C752.2 C753.2 Q32.3 R608.2 R614.1
PCBEEP_EC: D6543.2 U37.34
PCBEEP_EC_C: C843.2 C844.2 C846.2 R734.1 R735.1
PCH_ACPRESENT: R2515.1 R2516.2 U2030.AY15
PCH_AZ_CODEC_BITCLK: C587.2 C2573.2 R2496.1 U20.6
PCH_AZ_CODEC_RST#: Q21.1(S) R738.2 R2498.1
PCH_AZ_CODEC_SDIN0: U20.8 U2030.BA21
PCH_AZ_CODEC_SDOUT: R2495.1 U20.5
PCH_AZ_CODEC_SYNC: R2497.1 U20.10
PCH_BATLOW#: R2225.2 TP2040.1 U2030.AU13
PCH_BLON_C: Q6521.5 R440.2 R25365.2 R25366.2 R25369.1
PCH_BLON_EC: R25366.1 U37.88
PCH_DISP_ON: R445.2 U2030.U13
PCH_DPST_PWM: R443.1 R2489.2 U2030.R11
PCH_LVDS_BLON: R25365.1 U2030.R12
PCH_MBCLK0_R: Q2026.6 R2606.2 U2030.R7
PCH_MBDAT0_R: Q2026.3 R2605.2 U2030.R8
PCH_OPI_RCOMP: R2202.2 U2030.AU16
PCH_PWRBTN#: R2523.1 U2030.BA15
PCH_PWROK: R2257.2 R2505.1 R2507.1 U37.78
PCH_RSMRST#: R2502.1 R2503.2 R2504.2 U2030.AY17
PCH_SLP_A#: TP2032.1 U2030.AN16
PCH_SLP_LAN#: TP2038.1 U2030.AW15
PCH_SLP_S0_N: R38.1 R592.1 U2030.AT11
PCH_SLP_S5#: TP2079.1 U2030.AY16
PCH_SLP_SUS#: TP2035.1 U2030.AN15
PCH_SLP_WLAN#: TP2078.1 U2030.BB17
PCH_SPI1_CLK: C2606.1 R596.1 R2622.2 U2030.AV2
PCH_SPI1_CLK_R: R2616.1 U37.105
PCH_SPI1_SI: R597.1 R2611.2 U2030.AV3
PCH_SPI1_SI_R: R2617.1 R25303.1 U37.102
PCH_SPI1_SO: R583.1 R598.1 R2619.1 U2030.AW3
PCH_SPI1_SO_R: R2626.1 R25316.1 U37.103
PCH_SPI_CS0#: R2628.2 U2030.AU3 U2031.1
PCH_SPI_CS0#_R: R2628.1 R2631.2 U37.101
PCH_SPI_IO2: R2621.1 U2030.AW2
PCH_SPI_IO3: R2625.1 U2030.AU4
PCH_SUSPWRDNACK: R2608.1 U37.15
PCH_SUSPWRDNACK_C: R2608.2 R2609.2 U2030.AR13
PCH_TYPEC_UPFB#: Q6505.1(S) R2588.1 R25480.2 U2030.L6
PCH_VRALERT#: R2304.1 TP2051.1 U2030.AM11
PCI_PLTRST#: U2019.1 U2019.2 U2030.AN10
PCIE5_TXN: C2574.2 U2030.C19
PCIE5_TXP: C2576.2 U2030.D19
PCIE_CLKREQ_LAN#: Q6531.3 R2305.1 R25444.1 R25446.1
PCIE_CLKREQ_SSD#: CN16.52 R2285.1
PCIE_CLKREQ_VGA#: Q9.3 R226.1 R25487.1
PCIE_CLKREQ_WLAN#: Q63.3 R2307.1
PCIE_RCOMPN: R2217.2 U2030.F5
PCIE_RCOMPP: R2217.1 U2030.E5
PCIE_REQ_LAN#_R: Q6531.1(S) R25445.1 R25446.2 U24.12
PCIE_RXN9_LAN: C637.2 U2030.F16
PCIE_RXN10_WLAN: CN17.43 U2030.G18
PCIE_RXN13_SSD: R2652.1 U2030.E22
PCIE_RXN13_SSD_C: CN16.5 R2652.2
PCIE_RXN14_SSD: R2654.1 U2030.F25
PCIE_RXN14_SSD_C: CN16.17 R2654.2
PCIE_RXN15_SSD: R2656.1 U2030.E28
PCIE_RXN15_SSD_C: CN16.29 R2656.2
PCIE_RXN16_SSD: R646.1 U2030.E30
PCIE_RXN16_SSD_C: CN16.43 R646.2
PCIE_RXN_LAN_L: C637.1 U24.18
PCIE_RXP9_LAN: C640.2 U2030.E16
PCIE_RXP10_WLAN: CN17.41 U2030.F18
PCIE_RXP13_SSD: R2653.1 U2030.E23
PCIE_RXP13_SSD_C: CN16.7 R2653.2
PCIE_RXP14_SSD: R2655.1 U2030.E25
PCIE_RXP14_SSD_C: CN16.19 R2655.2
PCIE_RXP15_SSD: R2657.1 U2030.E27
PCIE_RXP15_SSD_C: CN16.31 R2657.2
PCIE_RXP16_SSD: R647.1 U2030.F30
PCIE_RXP16_SSD_C: CN16.41 R647.2
PCIE_RXP_LAN_L: C640.1 U24.17
PCIE_TXN9_LAN: C2574.1 U24.14
PCIE_TXN10_WLAN: C203.2 U2030.D20
PCIE_TXN10_WLAN_C: C203.1 CN17.37
PCIE_TXN13_SSD: C788.1 U2030.B23
PCIE_TXN13_SSD_C: C788.2 CN16.11
PCIE_TXN14_SSD: C790.1 U2030.D23
PCIE_TXN14_SSD_C: C790.2 CN16.23
PCIE_TXN15_SSD: C792.1 U2030.D24
PCIE_TXN15_SSD_C: C792.2 CN16.35
PCIE_TXN16_SSD: C794.1 U2030.A25
PCIE_TXN16_SSD_C: C794.2 CN16.47
PCIE_TXP9_LAN: C2576.1 U24.13
PCIE_TXP10_WLAN: C202.2 U2030.C20
PCIE_TXP10_WLAN_C: C202.1 CN17.35
PCIE_TXP13_SSD: C789.1 U2030.A23
PCIE_TXP13_SSD_C: C789.2 CN16.13
PCIE_TXP14_SSD: C791.1 U2030.C23
PCIE_TXP14_SSD_C: C791.2 CN16.25
PCIE_TXP15_SSD: C793.1 U2030.C24
PCIE_TXP15_SSD_C: C793.2 CN16.37
PCIE_TXP16_SSD: C795.1 U2030.B25
PCIE_TXP16_SSD_C: C795.2 CN16.49
PCIE_WAKE#: EC13.1 Q33.3 R513.1 R2519.1 U2030.BB15
PCIE_WAKE#_R: R513.2 U24.21
PD#: C595.1 D12.2 D13.2 R478.2 R479.1 U20.47
PEDET: CN16.69 Q34.2 R649.2 R654.2
PEG_RXN5: C358.2 U2030.H13
PEG_RXN5_C: C358.1 U8.AB9
PEG_RXN6: C384.2 U2030.G11
PEG_RXN6_C: C384.1 U8.AC10
PEG_RXN7: C6554.2 U2030.H16
PEG_RXN7_C: C6554.1 U8.AC11
PEG_RXN8: C6557.2 U2030.G15
PEG_RXN8_C: C6557.1 U8.AB12
PEG_RXP5: C370.2 U2030.G13
PEG_RXP5_C: C370.1 U8.AC9
PEG_RXP6: C382.2 U2030.F11
PEG_RXP6_C: C382.1 U8.AB10
PEG_RXP7: C6556.2 U2030.G16
PEG_RXP7_C: C6556.1 U8.AD11
PEG_RXP8: C6555.2 U2030.F15
PEG_RXP8_C: C6555.1 U8.AC12
PEG_TXN5: C192.1 U8.AG7
PEG_TXN5_C: C192.2 U2030.B17
PEG_TXN6: C194.1 U8.AE7
PEG_TXN6_C: C194.2 U2030.D16
PEG_TXN7: C196.1 U8.AF9
PEG_TXN7_C: C196.2 U2030.D17
PEG_TXN8: C198.1 U8.AG10
PEG_TXN8_C: C198.2 U2030.B19
PEG_TXP5: C193.1 U8.AG6
PEG_TXP5_C: C193.2 U2030.A17
PEG_TXP6: C195.1 U8.AF7
PEG_TXP6_C: C195.2 U2030.C16
PEG_TXP7: C197.1 U8.AE9
PEG_TXP7_C: C197.2 U2030.C17
PEG_TXP8: C199.1 U8.AG9
PEG_TXP8_C: C199.2 U2030.A19
PEGX_RST#: R296.1 R306.2 R384.2 R25521.1 U6505.4
PEX_CLKREQ#: Q9.1(S) R297.1 R25487.2 R25563.1 U8.AC6
PEX_PLLVDD: C20002.2 C20003.2 C20004.1 R25515.2 U8.AA14 U8.AA15
PEX_TERMP: R312.2 U8.AF25
PEX_TSTCLK: R307.2 U8.AF22
PEX_TSTCLK#: R307.1 U8.AE22
PHASE1_CORE: PC7105.1 PL7000.1 PQ7000.5 PQ7000.6 PQ7000.7 PR7072.2 PR7073.1 PU7002.2
PHASE2_CORE: PC7056.1 PL7001.1 PQ7001.5 PQ7001.6 PQ7001.7 PR7081.2 PR7082.1 PU7001.2
PHASE_GT: PC7101.1 PL7003.1 PQ7004.5 PQ7004.6 PQ7004.7 PR7095.2 PR7096.1 PU7003.2
PHASE_SA: PC7103.1 PL7002.1 PQ7002.1 PQ7002.2 PQ7002.3(S3) PQ7003.5 PR7087.2 PR7088.1 PU7004.2
PIRQA#: R580.1 R593.1 R2554.2 U2030.BB11
PLTRST#: C2363.2 R601.1 R648.2 R894.1 R2302.1 R2309.2 R2665.2 U24.19 U2019.4 U6504.2
PLTRST#_EC: C2374.1 R894.2 U37.22
PMON: PC18.2 PR23.1 PR25.1 PR7039.1
PP: R600.2 U33.4
PROC_POPIRCOMP: R2201.2 U2030.AT16
PROC_PWRGD: R2453.1 R2454.1 U2030.A68
PROCHOT_EC: C6610.2 Q6509.2 R25298.1 U37.17
PS_FB_CLAMP: R313.1 U8.F3
PTP_PWR_EN#: TP9019.1 U37.125
PULSAR_38P4M_REFCLK: CN17.64
PWM1_CORE: PR7105.1 PU7000.17
PWM2_CORE: PR7077.1 PU7000.16
PWM-VID: PR9015.1 R370.2 R25571.2
PWM_GT: PR7109.1 PU7000.22
PWM_SA: PR7113.1 PU7000.36
PWRLED#: CN35.22 U37.24
R_SPK+: R480.1 U20.45
R_SPK+_1: C601.1 CN36.1 R480.2
R_SPK-: R481.1 U20.44
R_SPK-_1: C602.1 CN36.2 R481.2
RAM_ID0: R2567.2 R2576.1 U2030.P2
RAM_ID1: R2565.2 R2574.1 U2030.P3
RAM_ID2: R2564.2 R2573.1 U2030.P4
RAM_ID3: R2566.2 R2575.1 U2030.P1
REGN6V: PC9.1 PR39.1 PU1.24
REQ_WLAN#: CN17.53 Q63.1(S) R652.2
RF_EN: CN17.56 R672.1 R25318.2
RGND_CORE: PC7008.1 PC7009.1 PR7046.2 PU7000.48
RGND_GT: PC7014.1 PC7015.1 PR7053.2 PU7000.25
RGND_SA: PC7022.1 PC7024.1 PR7062.2 PU7000.44
RING2: C591.2 CN35.6 CN35.7 CN35.8 R471.2 U20.17
ROM_CS: TP67.1 U8.D12
ROM_SCLK: R342.1 R352.2 U8.C12
ROM_SI: R341.1 R350.2 U8.B12
ROM_SO: R343.1 R351.2 U8.A12
RSET: R508.2 U24.31
RSMRST#: R2504.1 U37.112
RTC_RST#: C2419.1 J2000.1 Q2014.3 R2360.2 U2030.AM16
RTC_X1: C2596.2 R2553.1 U2030.AM18 Y2004.1
RTC_X2: C2595.1 R2553.2 U2030.AM20 Y2004.2
S5_ON: PR566.2 PR6015.2 PR6027.1 R25309.1 U37.100
SATA_LED#: CN16.10 TP2092.1
SATA_RXN0_C: C6592.1 R25352.2
SATA_RXN0_CN: C6592.2 C6596.2 HD1.8
SATA_RXN0_HDD: C6588.1 R25352.1 U2030.F20
SATA_RXN0_IN: C6588.2 U42.4
SATA_RXN1A_C: C782.1 CN15.5
SATA_RXN1A_ODD: C782.2 U2030.G21
SATA_RXN_OUT: C6596.1 U42.12
SATA_RXP0_C: C6593.1 R25353.2
SATA_RXP0_CN: C6593.2 C6597.2 HD1.7
SATA_RXP0_HDD: C6589.1 R25353.1 U2030.E20
SATA_RXP0_IN: C6589.2 U42.5
SATA_RXP1A_C: C781.1 CN15.6
SATA_RXP1A_ODD: C781.2 U2030.F21
SATA_RXP_OUT: C6597.1 U42.11
SATA_TXN0_C: C6591.1 R25351.2
SATA_TXN0_CN: C6591.2 C6595.2 HD1.10
SATA_TXN0_HDD: C6587.1 R25351.1 U2030.B21
SATA_TXN0_IN: C6587.2 U42.2
SATA_TXN1A_C: C784.1 CN15.2
SATA_TXN1A_ODD: C784.2 U2030.D21
SATA_TXN_OUT: C6595.1 U42.14
SATA_TXP0_C: C6590.1 R25350.2
SATA_TXP0_CN: C6590.2 C6594.2 HD1.11
SATA_TXP0_HDD: C6586.1 R25350.1 U2030.A21
SATA_TXP0_IN: C6586.2 U42.1
SATA_TXP1A_C: C783.1 CN15.3
SATA_TXP1A_ODD: C783.2 U2030.C21
SATA_TXP_OUT: C6594.1 U42.15
SATAGP0: R2543.2 U2030.H2
SATAGP1: R2545.2 U2030.H3
SD_1P8_RCOPM: R2207.2 U2030.AB7
SDVO_CLK: R494.2 R775.1 U23.7 U2030.L13
SDVO_DATA: R502.2 R777.1 U23.6 U2030.L12
SEL: R25276.1 R25277.2 R25280.2 U6502.6
SENSEA: R451.1 R452.1 R733.1 U20.13
SERIRQ: R2551.1 U37.5 U2030.AY11
SIO_EXT_SCI#: R2604.1 U37.23 U2030.N9
SIO_RCIN#: R2521.1 U37.4
SLEEVE: C590.2 CN35.9 CN35.10 CN35.11 R468.2 U20.18
SM_RCOMP_0: R2199.1 U2030.AR18
SM_RCOMP_1: R2197.2 U2030.AT18
SM_RCOMP_2: R2204.1 U2030.AU18
SMB1ALERT#: R2290.1 TP2050.1 U2030.AM7
SMB_ME1_CLK: R2538.2 U2030.W3
SMB_ME1_DAT: R2539.2 U2030.V3
SMB_RUN_CLK: JDIM2000.253 Q2026.1(S) R557.2 R591.1 R2610.1
SMB_RUN_DAT: JDIM2000.254 Q2026.4 R561.2 R590.1 R2614.1
SMBALERT#: R2571.2 U2030.R10
SML0ALERT#: R2592.2 U2030.W1
SP_PLLVDD: C459.2 C460.2 C461.1 C462.1 L8.2 L32.2 R329.2 U8.M6
SPI_CLK_8M: R2616.2 R2622.1 U2031.6
SPI_HOLD_IO3_ME: R2624.1 R2625.2 U2031.7
SPI_SI_8M: R2611.1 R2617.2 U2031.5
SPI_SO_8M: R2619.2 R2626.2 U2031.2
SPI_TPM_CS#: R586.1 R599.1 U2030.AU1
SPI_WP_IO2_ME: R2620.2 R2621.2 U2031.3
SRTC_RST#: C2418.1 Q2013.3 R2359.2 U2030.AN18
STRAP0: R344.1 R353.2 U8.D1
STRAP1: R345.1 R354.2 U8.D2
STRAP2: R346.1 R355.2 U8.E4
STRAP3: R347.1 R356.2 U8.E3
STRAP4: R348.1 R357.2 U8.D3
STRAP5: R349.1 R358.2 U8.C1
SUSACK#_R: TP2042.1 U2030.AP11
SUSB#: U37.119 U2014.1 U2030.AP15
SUSC#: U37.18 U2030.BA16
SUSCLK_32K: R670.2 U2030.BA17
SUSCLK_32KHZ: CN17.50 R670.1
SUSD: PC152.1 PQ11.2 PQ25.3 PR191.2
SUSLED#: CN35.21 U37.28
SUSON: PR266.2 PR9258.2 R25320.1 U37.120
SYS_HWPG: D60.1(CATHODE) PR6004.2 PR6022.2 U37.124
SYS_PEX_RST: R25517.2 R25521.2 U6504.4
SYS_PEX_RST_MON#: R25511.2 R25517.1 R25564.1 U8.E9 U6505.1
SYS_PWROK_R: R2511.2 R2524.1 U2030.B6
SYS_RESET#: R2533.1 U2030.B5
SYS_SHDN#: PR3022.2 PR6002.2 PR6009.1 PR6020.2 Q2025.3 U37.85
TEMP_MBAT#: PR8.1 PR14.2 PR18.1 U37.73
TESTMODE: R311.1 U8.AD9
THERM+: TP68.1 U8.F12(THERMDP)
THERM-: TP69.1 U8.E12
THRMTRIP#: Q2025.1(EMITTER) R2475.1 R2478.1
TP_I2C_CLK: R558.1 R25415.2 U2030.U6
TP_I2C_DATA: R560.1 R25413.2 U2030.U7
TP_INTH#_L: CN33.7 Q29.1(S) R25471.2 R25472.1
TP_SMB_CLK: C699.1 CN33.6 Q27.3 R559.1
TP_SMB_DATA: C698.1 CN33.5 Q27.6 R562.1
TPCLK: L23.1 R566.2 U37.89
TPCLK-1: C696.1 CN33.2 L23.2
TPD_EN: R572.2 R574.1 R895.2
TPD_INT#: R573.1 R25477.2 U2030.W4
TPD_INT#_EC: R25308.2 R25323.1 R25473.1
TPDAT-1: C697.1 CN33.3 L24.2
TPDATA: L24.1 R567.2 U37.90
TPM_LRESET#: R601.2 U33.17
TRA_V_DAC: C645.1 U25.1 U25.4 U25.7 U25.10
TS_EN: R436.2 R956.1
TS_EN_C: C1210.1 R956.2 U37.81
TS_EN_R: CN29.28 R436.1
TYPEC_SBU1: CN10.A8 D19.2 TP77.1
TYPEC_SBU2: CN10.B8 D18.2 TP78.1
UART2_CTS#: R2596.1 TP2083.1 U2030.AD4
UART2_RTS#: R2578.1 TP2081.1 U2030.AD3
UART2_RXD: R2579.1 TP2085.1 U2030.AD1
UART2_TXD: R2597.1 TP2086.1 U2030.AD2
UGATE1_CORE: PQ7000.1 PR7106.2
UGATE2_CORE: PQ7001.1 PR7078.2
UGATE_GT: PQ7004.1 PR7110.2
UGATE_SA: PQ7002.4 PR7114.2
ULT_EDP_HPD: C6616.2 R2558.1 R25467.1 U2030.L10
ULT_EDP_HPD_R: CN29.25 R25467.2
USB2_ID: R2561.1 U2030.AG3
USB2_VBUSSENSE: R2213.1 U2030.AG4
USB3_SS0RX+: C683.1 U6502.5
USB3_SS0RX-: C682.1 U6502.4
USB3_SS0TX+: C677.1 U6502.2
USB3_SS0TX-: C681.1 U6502.1
USB30_RX1+: C518.2 R422.2 U2030.G8
USB30_RX1+_C: CN2.6 R422.1 TP9058.1 U16.10
USB30_RX1-: C513.2 R421.2 U2030.H8
USB30_RX1-_C: CN2.5 R421.1 TP9055.1 U16.1
USB30_RX2+: C526.2 R428.2 U2030.H6
USB30_RX2+_C: CN3.6 R428.1 TP9070.1 U17.10
USB30_RX2-: C523.2 R427.2 U2030.J6
USB30_RX2-_C: CN3.5 R427.1 TP9067.1 U17.1
USB30_RX3+: C683.2 U2030.H10
USB30_RX3-: C682.2 U2030.J10
USB30_RX+_TYPEC1: CN10.B11 RV3.1 RV3.10(NC#4) U6502.7
USB30_RX+_TYPEC2: CN10.A11 RV2.1 RV2.10(NC#4) U6502.14
USB30_RX-_TYPEC1: CN10.B10 RV3.2 RV3.9 U6502.8
USB30_RX-_TYPEC2: CN10.A10 RV2.2 RV2.9 U6502.13
USB30_TX1+: C520.1 U2030.D13
USB30_TX1+_C: C520.2 R423.2
USB30_TX1+_C_R: C522.1 CN2.9 R423.1 TP9061.1 U16.6
USB30_TX1-: C519.1 U2030.C13
USB30_TX1-_C: C519.2 R424.2
USB30_TX1-_C_R: C521.1 CN2.8 R424.1 TP9059.1 U16.5
USB30_TX2+: C531.1 U2030.A13
USB30_TX2+_C: C531.2 R430.2
USB30_TX2+_C_R: C533.1 CN3.9 R430.1 TP9073.1 U17.6
USB30_TX2-: C530.1 U2030.B13
USB30_TX2-_C: C530.2 R429.2
USB30_TX2-_C_R: C532.1 CN3.8 R429.1 TP9071.1 U17.5
USB30_TX3+: C677.2 U2030.A15
USB30_TX3-: C681.2 U2030.B15
USB30_TX+_TYPEC1: C686.1 CN10.A2 RV2.5 RV2.6
USB30_TX+_TYPEC1_C: C686.2 U6502.10
USB30_TX+_TYPEC2: C684.1 CN10.B2 RV3.5 RV3.6
USB30_TX+_TYPEC2_C: C684.2 U6502.17
USB30_TX-_TYPEC1: C685.1 CN10.A3 RV2.4 RV2.7
USB30_TX-_TYPEC1_C: C685.2 U6502.11
USB30_TX-_TYPEC2: C680.1 CN10.B3 RV3.4 RV3.7
USB30_TX-_TYPEC2_C: C680.2 U6502.16
USB_BC_ON: U14.4 U37.97
USB_CHARGE_ON: R416.1 U14.5 U37.96
USB_CLT1: U14.6 U37.79
USB_OC0#: C2583.1 R2514.2 U14.13 U2030.A9
USB_OC1#: C2587.1 R2522.2 U15.3 U2030.C9
USB_OC2#: C2582.1 R2508.2 U18.3 U2030.D9
USB_OC3#: R25437.2 TP2091.1 U2030.B9
USBCOMP: R2227.1 U2030.AB6
USBON#: U15.4 U18.4 U37.99
USBP1+: R25593.1 R25595.1 U2030.AB10
USBP1+_C: R420.1 U14.10
USBP1+_C_R: R25593.2 R25597.1
USBP1+_C_R_N: CN2.3 R420.2 R25597.2 TP9053.1 U16.7
USBP1+_U14: R25595.2 U14.3
USBP1-: R25592.1 R25594.1 U2030.AB9
USBP1-_C: R419.1 U14.11
USBP1-_C_R: R25592.2 R25596.1
USBP1-_C_R_N: CN2.2 R419.2 R25596.2 TP9051.1 U16.4
USBP1-_U14: R25594.2 U14.2
USBP2+: R425.2 U2030.AJ3
USBP2+_C: CN3.3 R425.1 TP9065.1 U17.7
USBP2-: R426.2 U2030.AH3
USBP2-_C: CN3.2 R426.1 TP9064.1 U17.4
USBP3+_TPC: R25292.2 U2030.AD7
USBP3-_TPC: R25293.2 U2030.AD6
USBP4+_DB: CN35.16 U2030.AG2
USBP4-_DB: CN35.15 U2030.AG1
USBP5+_CAM: R25289.2 U2030.AF7
USBP5+_CAM_C: CN29.8 R25289.1
USBP5-_CAM: R25288.2 U2030.AF6
USBP5-_CAM_C: CN29.7 R25288.1
USBP6+_CR: CN35.19 U2030.AF9
USBP6-_CR: CN35.18 U2030.AF8
USBP7+_FP: CN14.7 EC7.2 U2030.AH2
USBP7-_FP: CN14.6 EC8.1 U2030.AH1
USBP8+_TS: R25291.2 U2030.AJ2
USBP8-_TS: R25290.2 U2030.AJ1
USBP8_TS+_C: CN29.5 R25291.1
USBP8_TS-_C: CN29.4 R25290.1
USBP10+_BT: CN17.3 U2030.AD10
USBP10-_BT: CN17.5 U2030.AD9
USBP_TYPC+_C: CN10.A6 CN10.B6 R25292.1 RV1.1
USBP_TYPC-_C: CN10.A7 CN10.B7 R25293.1 RV1.2
USBPWRD2: C527.2 C528.2 C529.2 C664.2 C665.1 CN35.36 CN35.37 CN35.38 CN35.39 CN35.40 U18.1(OUT)
VA: PC1.1 PC5.1 PC13.1 PC14.1 PD2.1 PD9002.1 PJ2.1 PQ1.5 PR31.1 PR235.1
VA2: PC2.1 PQ1.1 PQ1.2 PQ1.3(S3) PQ9054.1 PQ9054.2 PQ9054.3(S3) PR28.1
VADJ1: C558.1 CN29.27 R441.2 R442.1
VCORE_SENSE: PR7043.1 PR7044.1 R2493.2 U2030.E32
VCORESS_SENSE: PR7045.1 PR7046.1 R2492.1 U2030.E33
VGA_MBCLK: R2607.2 U2030.R9
VGA_MBDATA: R2591.2 U2030.W2
VGA_OVT#: Q15.1(S) R395.1 R25560.2
VGA_RST#: C364.1 R296.2 U8.AC7
VGA_VCCSENSE: PR9026.2 PR9028.2 U8.F2
VGA_VSSSENSE: PR9029.2 PR9031.2 U8.F1
VGPU_EN: TP2043.1 U2030.AN8
VL: PR3020.1 PR6025.2
VMA_CLK0: R25488.1 U8.D24 VRAM1.J12
VMA_CLK0#: R25488.2 U8.D25 VRAM1.J11
VMA_CLK1: R25489.1 U8.N22 VRAM2.J12
VMA_CLK1#: R25489.2 U8.M22 VRAM2.J11
VMA_DQ0: U8.E18 VRAM1.E2
VMA_DQ1: U8.F18 VRAM1.F2
VMA_DQ2: U8.E16 VRAM1.A2
VMA_DQ3: U8.F17 VRAM1.B2
VMA_DQ4: U8.D20 VRAM1.F4
VMA_DQ5: U8.D21 VRAM1.B4
VMA_DQ6: U8.F20 VRAM1.E4
VMA_DQ7: U8.E21 VRAM1.A4
VMA_DQ8: U8.E15 VRAM1.B11
VMA_DQ9: U8.D15 VRAM1.E13
VMA_DQ10: U8.F15 VRAM1.A13
VMA_DQ11: U8.F13 VRAM1.A11
VMA_DQ12: U8.C13 VRAM1.E11
VMA_DQ13: U8.B13 VRAM1.F11
VMA_DQ14: U8.E13 VRAM1.B13
VMA_DQ15: U8.D13 VRAM1.F13
VMA_DQ16: U8.B15 VRAM1.N11
VMA_DQ17: U8.C16 VRAM1.U11
VMA_DQ18: U8.A13 VRAM1.M11
VMA_DQ19: U8.A15 VRAM1.T11
VMA_DQ20: U8.B18 VRAM1.U13
VMA_DQ21: U8.A18 VRAM1.T13
VMA_DQ22: U8.A19 VRAM1.N13
VMA_DQ23: U8.C19 VRAM1.M13
VMA_DQ24: U8.B24 VRAM1.N4
VMA_DQ25: U8.C23 VRAM1.U4
VMA_DQ26: U8.A25 VRAM1.M4
VMA_DQ27: U8.A24 VRAM1.T4
VMA_DQ28: U8.A21 VRAM1.T2
VMA_DQ29: U8.B21 VRAM1.U2
VMA_DQ30: U8.C20 VRAM1.M2
VMA_DQ31: U8.C21 VRAM1.N2
VMA_DQ32: U8.R22 VRAM2.U11
VMA_DQ33: U8.R24 VRAM2.N11
VMA_DQ34: U8.T22 VRAM2.U13
VMA_DQ35: U8.R23 VRAM2.M11
VMA_DQ36: U8.N25 VRAM2.N13
VMA_DQ37: U8.N26 VRAM2.M13
VMA_DQ38: U8.N23 VRAM2.T11
VMA_DQ39: U8.N24 VRAM2.T13
VMA_DQ40: U8.V23 VRAM2.M4
VMA_DQ41: U8.V22 VRAM2.N4
VMA_DQ42: U8.T23 VRAM2.U4
VMA_DQ43: U8.U22 VRAM2.T4
VMA_DQ44: U8.Y24 VRAM2.N2
VMA_DQ45: U8.AA24 VRAM2.T2
VMA_DQ46: U8.Y22 VRAM2.M2
VMA_DQ47: U8.AA23 VRAM2.U2
VMA_DQ48: U8.AD27 VRAM2.F2
VMA_DQ49: U8.AB25 VRAM2.B2
VMA_DQ50: U8.AD26 VRAM2.E2
VMA_DQ51: U8.AC25 VRAM2.A2
VMA_DQ52: U8.AA27 VRAM2.B4
VMA_DQ53: U8.AA26 VRAM2.A4
VMA_DQ54: U8.W26 VRAM2.E4
VMA_DQ55: U8.Y25 VRAM2.F4
VMA_DQ56: U8.R26 VRAM2.B13
VMA_DQ57: U8.T25 VRAM2.A13
VMA_DQ58: U8.N27 VRAM2.F13
VMA_DQ59: U8.R27 VRAM2.E13
VMA_DQ60: U8.V26 VRAM2.A11
VMA_DQ61: U8.V27 VRAM2.B11
VMA_DQ62: U8.W27 VRAM2.F11
VMA_DQ63: U8.W25 VRAM2.E11
VMA_WCK01: U8.D18 VRAM1.D4
VMA_WCK01#: U8.C18 VRAM1.D5
VMA_WCK23: U8.D17 VRAM1.P4
VMA_WCK23#: U8.D16 VRAM1.P5
VMA_WCK45: U8.T24 VRAM2.P4
VMA_WCK45#: U8.U24 VRAM2.P5
VMA_WCK67: U8.V24 VRAM2.D4
VMA_WCK67#: U8.V25 VRAM2.D5
VR_READY: PR7067.2 PU7000.38
VR_SVID_ALERT#_VCORE: PR7002.2 PR7020.2 R2460.2 R2461.2
VRON: PR7025.2 R25311.1 U37.69
VSEN_CORE: PC7007.1 PC7008.2 PC7010.1 PR7044.2 PR7047.2 PU7000.47
VSEN_GT: PC7013.1 PC7014.2 PC7016.2 PR7051.2 PR7054.2 PU7000.27
VSEN_SA: PC7019.1 PC7020.1 PC7022.2 PR7058.2 PR7059.2
VSTBY_FSPI: R359.2 R25330.2 U37.106
WIGIG_LED: CN17.6 TP9029.1
WLAN_RST#: CN17.52 R2665.1
WLANPWR#: TP2090.1 U37.35
WRST#: C6571.1 D63.2 R25300.1 U37.14(WRST#)
XCLK_BIASREF: R2490.1 U2030.E42
XDP_BPM#0: TP2075.1 U2030.C55
XDP_BPM#1: TP2074.1 U2030.D55
XDP_BPM#2: TP2077.1 U2030.B54
XDP_BPM#3: TP2073.1 U2030.C56
XDP_PRDY#: TP2076.1 U2030.D56
XDP_PREQ#: TP2072.1 U2030.D61
XDP_TCK0: R2480.2 U2030.A59 U2030.B61
XDP_TCK1: R2485.2 U2030.B56
XDP_TDI_CPU: R2484.2 U2030.D59 U2030.D60
XDP_TDO_CPU: R2487.2 U2030.A56 U2030.A61
XDP_TMS_CPU: R2482.2 U2030.C59 U2030.C60
XDP_TRST#: R2481.2 U2030.B59 U2030.C61
XTAL1: R511.2 U24.28
XTAL2: R512.1 U24.29
XTAL24_IN: C2563.2 R2491.1 U2030.E37 Y2002.3
XTAL24_IN_E3: R2535.1 U2030.E3
XTAL24_IN_E3_R: C2591.1 R2534.1 R2535.2 Y2003.3
XTAL24_OUT: C2564.2 R2491.2 U2030.E35 Y2002.1
XTAL24_OUT_C7: R2530.1 U2030.C7
XTAL24_OUT_C7_R: C2589.1 R2530.2 R2534.2 Y2003.1
XTAL_SSIN: R331.1 U8.A10
N06325: Q29.3 R573.2 R25471.1 R25473.2
N108478: C2593.2 R2546.1 U2030.BA11
N109300: R2527.1 U2030.AY13
N109332: R2525.1 U2030.BA13
N109356: R2529.1 U2030.BB13
N109380: R2531.1 U2030.AY12
N112429: TP2080.1 U2030.B7
N112433: R2205.2 U2030.E13
N16824426: R323.2 R324.2 U11.2
N16946786: Q2024.1(S) R2486.1
N17002655: C572.2 U20.39
N17002661: C566.2 U20.37
N17002676: C567.1 U20.34
N17002678: C573.1 U20.19
N17002722: R453.2 R454.2 U20.48
N17002952: C578.1 U20.7
N17002968: R738.1 R739.1 R741.2 U20.11
N17002995: C846.1 R740.1 R742.2 U20.12
N17003129: C566.1 U20.35
N17003186: R450.1 U20.20
N17004316: D12.1(CATHODE) Q21.3
N17046941: PJ1.3 PR13.1
N17047007: PQ9054.5 PR1.1 PR3.1
N17047009: PR5.1 PU1.20
N17047028: PR6.1 PU1.19
N17047083: PJ1.5 PR14.1
N17047087: PC17.1 PL5.2 PQ2.1 PQ2.2 PQ2.3(S3) PR7.1 PR209.1 PR210.2
N17047112: PC1.2 PC2.2 PQ1.4 PQ9054.4 PR29.1
N17047335: PC19.1 PR33.2
N17047399: PC15.2 PR11.2
N17047425: PJ1.4 PR12.1
N17047601: PC17.2 PQ2.4 PR4.1
N17398787: PR30.2 PU1.5
N17424918: PR19.2 PU1.11
N17424920: PR17.2 PU1.12
N17424921: PR32.2 PU1.7
N17424925: PR25.2 PU1.9
N17424950: PR8.2 PR205.2 PU1.15
N17661815: PR26.2 PU1.8
N18020348: TP2029.1 U2030.AM23
N18021386: TP2030.1 U2030.AM22
N18022283: TP2027.1 U2030.K32
N18022286: TP2028.1 U2030.AK32
N18137715: TP2046.1 U2030.AU11
N18867651: PC6020.1 PC6021.1 PR9245.1 PU6001.8 PU6001.9
N18867812: PC6042.1 PC6043.1 PR9249.1 PU6002.8 PU6002.9
N18954271: R2458.1 U2030.C64
N18954889: TP2023.1 U2030.AP56
N18990234: R391.2 R395.2 R397.2 R399.2 R403.2 R404.2 R25490.2 R25584.1 R25585.1
N18994895: C2594.2 U2030.L1
N19018012: C2599.1 R2593.2 U2030.U11 U2030.U12(RSVD_U12)
N19138106: R321.2 U8.F22
N19138109: R322.2 U8.J22
N19521323: PQ6000.3 PR6006.1
N19521733: PQ6000.2 PR6012.1 PR9268.1 PR9269.1
N19549602: PQ6001.2 PR6024.1 PR9270.1 PR9271.1
N20915811: TP2036.1 U2030.AK13
N20946170: R2222.1 U2012.E9
N20946459: R2158.1 U2010.E9
N20946794: R2190.1 U2011.E9
N20947128: R2134.1 U2009.E9
N21263014: TP65.1 U8.E10
N21263017: TP66.1 U8.F10
N21450006: C2342.1 C2343.1 JDIM2000.255 R2269.1
N21450098: C2250.2 R2192.2
N21567140: R2547.1 U2030.G4
N22413276: PQ7.3 PQ10.2 PQ25.2 PR79.2 PR80.1
N22413302: PQ10.3 PR105.2
N22415444: PC219.1 PC220.1 PC222.1 PC224.1 PC227.1 PC230.1 PC231.1 PC233.1 PJ3005.2 PL12.2 PR9259.2
N22415652: PC82.1 PR99.2
N22415656: PC225.2 PR269.1 PR9259.1
N22415672: PC235.2 PR277.1
N23833251: HD1.2 HD1.3 HD1.4 R25504.2
N24359231: PC7056.2 PU7001.4
N24359390: PR7078.1 PU7001.3
N24444747: PR7017.2 PR7018.1 PR7021.2 PR7031.1
N24444757: PC7023.1 PR7063.2
N24445360: PC7005.1 PR7025.1 PU7000.37
N24445593: PR7066.2 PR7069.2 PU7000.8
N24445614: PR7016.2 PR7026.1 PR7030.1 PR7032.2
N24446268: PR7037.2 PR7038.1
N24459302: PR7073.2 PR7076.1
N24492000: PC7012.1 PR7049.1
N24507636: PC229.1 PC6230.1 PC6231.1 PJ3008.1 PL14.2 PR6414.2
N24507642: PC9097.1 PR283.1 PR6418.2 PU3003.6
N24507664: PC9097.2 PR6414.1 PR6418.1
N24507676: PC6229.2 PR6417.1 PU3003.1
N24507691: PR284.2 PU3003.5
N24515156: PC7018.1 PR7056.1
N24602110: PR7007.2 PR7013.2 PR7014.1
N24622727: PR7099.2 PR7100.1 PR7101.1
N24742093: PC9067.1 PC9068.1 PC9069.1 PJ9003.1 PQ9008.1 PQ9008.2 PQ9008.3(S3) PR9073.1
N24742096: PD9001.2 PQ9011.3 PR9075.2
N24742104: PQ9009.2 PQ9010.3 PQ9011.2 PR9074.2 PR9077.1
N24742107: PC9055.1 PC9056.1 PR9067.2 PU9002.13 PU9002.14(VOUT1#2)
N24742118: PR9078.1 PU9003.3
N24742123: PQ9009.3 PR9073.2
N24742126: PC9073.1 PQ9010.2 PR9079.1 PR9282.2 PU9003.4
N24742146: PC9071.1 PR9080.2
N24742181: PC9053.1 PC9054.1 PR9275.1 PR9281.1 PU9002.1 PU9002.2 PU9002.6 PU9002.7
N24742207: PC9063.1 PU9002.10
N24742208: PC9062.1 PU9002.12
N24742222: PC9060.1 PR9070.1 PR25541.2 PU9002.5
N24742230: PC9064.1 PR9072.2 PR9277.2 PU9002.3
N24995566: PC6228.1 PR3020.2 PU3002.5(VCC)
N24995570: PR3021.1 PU3002.1
N24995581: PR3022.1 PU3002.3
N25167244: JDIM2000.162 TP2031.1
N25167247: JDIM2000.165 TP2034.1
N25369936: Q27.1(S) R560.2 R561.1
N25369945: Q27.4 R557.1 R558.2
N25430953: PQ14.3 PR111.2
N25430988: PQ12.3 PR106.2
N25430994: PQ19.3 PR126.2
N25431520: PQ9050.3 PR9227.2
N25804343: PR9027.2 PR9030.2
N25817818: PQ9085.3 PR9099.2
N25817820: PQ9085.2 PQ9086.3 PR9100.2 PR9101.1
N25821251: PC9088.1 PR9092.2
N27391730: R2587.1 U2030.AY3
N27391896: R2457.1 U2030.AY71
N27752748: R450.2 R736.1 R737.1
N27760009: R2501.1 U2030.E8
N27761335: R2546.2 TP2084.1
N28053888: PR7006.1 PR7007.1
N28054550: PR7077.2 PU7001.5
N28087213: C646.2 R516.1 R517.1 R518.1 R519.1
N28088374: PC7004.1 PR7008.2
N28089786: PR7035.1 PR7040.1
N28089833: PR7036.2 PR7041.2
N28100067: CN33.8 R572.1
N28107941: PC7096.2 PR7095.1
N28108994: PR7096.2 PR7098.1
N28123718: PR7030.2 PR7033.1
N28123995: PR7031.2 PR7034.1
N28124269: PR7010.2 PR7017.1
N28124298: PR7009.2 PR7016.1
N28127437: PC7001.1 PR7001.1 PR7002.1 PR7003.1 PR7102.1
N28129355: PR7022.1 PR7027.1
N28129385: PR7023.1 PR7028.1
N28129414: PR7024.1 PR7029.1
N28159674: PR7091.1 PR7092.1 PR7093.1
N28160119: PC7078.2 PR7087.1
N28160139: PR7088.2 PR7090.2
N28379472: PC9025.1 PR9021.2 PR9023.1 PR9024.1
N28379477: PC9024.1 PR9019.1
N28380796: PR9017.1 TP9000.1
N28380828: PC9004.1 PR9000.2 PR9002.1
N28414264: PR9033.1 PR9274.1 PU9000.13
N28607521: PR9034.1 PU9000.22
N28712850: Q2025.2 R2486.2
N29093947: Q14.2 Q16.3 R386.1
N30319022: PC9080.1 PC9081.1 PC9082.1 PC9083.1 PC9084.1 PC9085.1 PC9086.1 PC9087.1 PJ9002.2 PL9002.2 PR9263.1
N30319317: PC9089.2 PR9094.1 PR9263.2
N30319351: PC9079.2 PR9089.1
N30442035: PC6040.1 PC6041.1 PR9248.2 PU6002.13 PU6002.14(VOUT1#2)
N30442060: PC6051.1 PR6023.1 PU6002.4
N30442062: PC6056.1 PU6002.12
N30442063: PC6057.1 PU6002.10
N30442080: PC6053.1 PR6028.2 PU6002.5
N30442084: PC6052.1 PR6027.2 PU6002.3
N30568314: PC6024.2 PR6010.1 PR6014.2 PU6000.12
N30568326: PC6024.1 PR6011.1
N30568424: PC6059.2 PR6030.1 PR6031.2 PU6003.9
N30568429: PC6059.1 PR6029.1
N30568472: PC6054.1 PR6025.1 PU6003.12
N30568498: PQ6001.3 PR6021.1
N30568535: PR6003.2 PR6004.1 PR6005.2 PR6007.1
N30795487: R2164.2 U2030.G65
N30795490: R2163.2 U2030.F65
N31069510: PC6018.1 PC6019.1 PR9244.2 PU6001.13 PU6001.14(VOUT1#2)
N31161958: PC6025.1 PR6013.2 PU6001.4
N31161974: PC6028.1 PU6001.12
N31161976: PC6029.1 PU6001.10
N31162017: PC6027.1 PR6016.2 PU6001.5
N31162025: PC6026.1 PR6015.1 PU6001.3
N31353058: PC561.1 PC562.1 PC563.1 PC9098.1 PJ9005.1 PL551.2 PR569.2
N31353100: PC551.2 PR551.2
N31375926: PQ7.2 PR9258.1 PR9272.1
N32194800: R2170.2 U2030.K52
N33618596: Q34.3 R653.2
N33652665: EC12.1 R655.2
N33761123: CN16.38 R645.1 R2660.1
N33761125: CN16.50 R648.1
N33761127: CN16.68(SUSCLK) TP81.1
N34044006: PR7109.2 PU7003.5
N34044116: PC7101.2 PU7003.4
N34044137: PR7110.1 PU7003.3
N34045443: PR7113.2 PU7004.5
N34045547: PC7103.2 PU7004.4
N34045574: PR7114.1 PU7004.3
N34047546: PR7105.2 PU7002.5
N34047656: PC7105.2 PU7002.4
N34047677: PR7106.1 PU7002.3
N36446693: C639.2 R512.2 Y4.3
N36964592: C750.2 Q32.2 R609.2
N36964655: R589.2 U32.7
N36977514: Q30.2 Q31.3 R579.2
N37139396: D22.2 R600.1
N37139525: R598.2 U33.24
N37139527: R597.2 U33.21
N37139529: R596.2 U33.19
N37139539: R593.2 U33.18
N37139543: R599.2 U33.20
N37139545: R592.2 U33.29
N37165848: L28.1 R448.2 R449.2
N37165855: R454.1 TP9023.1
N37165865: C843.1 U20.16
N37165875: R735.2 R25371.2
N37313384: C20005.2 R25519.1 R25520.1 U6504.5(VCC)
N37316052: Q9.2 R25522.2
N37317583: R329.1 U8.N6
N37318300: C20017.1 Q6550.3 Q6551.2 R25537.1
N37318343: C20016.2 Q6550.2 R25535.2
N37320415: R367.2 R368.2 R25551.2 R25553.2
N37320741: R363.2 R364.2 R366.2 R25552.2
N37360972: PC7046.2 PR7072.1
N37360977: PC7064.2 PR7081.1
N37361974: PC9012.1 PR9004.1
N37375256: R25570.1 U8.B4
N37375435: R25571.1 U8.E7
N37375540: R25560.1 U8.A6
N37377888: Q6512.2 R25574.2 R25575.2
N37379368: Q13.2 Q13.5 R25580.1 R25581.1
N37380003: R344.2 R345.2 R346.2 R347.2 R348.2 R349.2 R25579.2 R25588.2
N37380342: R341.2 R342.2 R343.2 R25577.1
N37568058: PQ9084.3 PR9103.2
N37598035: R507.1 U23.4
N37834251: R25587.2 U8.F6
N38517581: D6542.1 R25338.2 R25339.1
N38517589: Q6518.2 R25338.1
N38517597: Q6516.4 Q6518.3(E) R25340.2 R25341.2
N38517605: Q6519.3 R25341.1
N38517627: Q6515.3 R25342.2
N38517632: C6584.2 Q6519.5 Q6519.6 R6603.1
N38517638: C6583.2 Q6515.2 R25337.2
N38521997: CN18.1 D33.2 R720.1
N38674948: PR7082.2 PR7084.1
N38680042: D11.1(CATHODE) D6543.1(CATHODE) R25371.1
N38680880: Q6523.2 R576.2
N38756671: C6568.2 R25318.1 U37.66
N38756738: C1208.2 R960.1 U37.82
N38756749: TP9037.1 U37.87
N38756787: C6580.2 R895.1 U37.98
N38756834: Q81.3 R25321.1 SW2.3 SW2.4
N38757016: TP9038.1 U37.20
N38757336: C6563.1 R25308.1 U37.128
N38757406: C1044.1 Q81.2 R25310.2 SW3.3 SW3.4
N38758998: C6562.2 R402.1
N38759178: C1190.1 U37.12
N39168858: Q6533.3 R706.2 R707.2 R708.2 R709.2 R710.2 R711.2 R712.2 R713.2
N39255818: CN29.24 R25598.2
N39255859: CN29.29 R25599.2
N39395217: PD9002.3(COMMON ANODE) PR16.2
N39687060: PR262.1 PU26.23
N39687062: PC301.1 PR262.2
N39687064: PC301.2 PL30.1 PR261.1 PR9264.2 PU26.9 PU26.10 PU26.11 PU26.12 PU26.32
N39687102: PC293.1 PC294.1 PC295.1 PC296.1 PC297.1 PC305.1 PC306.1 PJ7001.1 PL30.2 PR9266.1 PU26.30
N39687293: PC300.2 PR9264.1
N39687315: PC267.2 PR263.2 PR9266.2
N39687335: PC283.1 PR265.1 PU26.4
N39687341: PR261.2 PU26.8
N39687373: PC276.1 PR266.1 PR9273.1 PU26.5
N39687445: PC267.1 PR253.2 PR263.1 PU26.1
N39687482: PC304.1 PR9267.2 PU26.2
N39687516: PC298.1 PR254.1 PU26.29
N39688806: PR267.1 PU26.6
N39785725: HD1.1 R25483.1 R25485.1
N40437801: TP9033.1 U8.V7
N40437812: TP9032.1 U8.W7
N40437815: TP9031.1 U8.W6
N40437818: TP9030.1 U8.Y6
N40911013: R405.2 VRAM1.J13(ZQ)
N40911015: R406.2 VRAM2.J13(ZQ)
N41141585: TP9041.1 U37.16
N48650493: Q15.2 R382.1 R384.1
N60242660: C2103.2 R2142.1
N360811430: TP9040.1 U37.48
N360811590: TP9039.1 U37.31

Pads without a net: CN1 3 4; CN13 3; CN14 1 2 3 4; CN16 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN17 8 12 16 20 38 40 42 44 46 48; CN29 38; CN35 25 26 28 33 34 35; CN37 13 14; HOLE22 1; NOREF 1; NOREF#5 1; NOREF#6 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; PQ7000 2; PQ7001 2; PQ7004 2; PQ9000 2; PQ9001 2; PU16 7; PU3004 5; PU7000 14 15 19 20 21; PU9004 7; Q6554 3 4 5; U8 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B6 B19 C2 C3 C7 C14 D4 D10 D11 D23 E6 F4 F5 F7 F19 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 P25 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T27 U3 U4 U6 V1 V2 V3 V4 V5 V6 W1 W2 W3 W4 W5 W22 Y3 Y4; U14 9; U20 14 15 23 24; U23 3 23 24; U32 2 3; U33 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 30 31 32; U37 77; U2009 T7; U2010 T7; U2011 T7; U2012 T7; U2015 1; U2029 1; U2030 A3 A4 A6 A7 A11 A26 A27 A29 A31 A33 A36 A38 A50 A52 A65 A69 AB3 AB4 AB62 AC1 AC2 AC3 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG62 AH7 AH8 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK10 AK12 AK62 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AN13 AN46 AN55 AP1 AP2 AP3 AP4 AP13 AP46 AP53 AP55 AR56 AT5 AT15 AU2 AU5 AU56 AW1 AW7 AW17 AW20 AW42 AW48 AW56 AW68 AW69 AW70 AW71 AY1 AY2 AY4 AY5 AY7 AY8 AY20 AY21 AY42 AY56 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B50 B67 B69 B70 BA3 BA4 BA7 BA8 BA9 BA68 BA70 BB2 BB3 BB4 BB5 BB7 BB9 BB68 BB69 C2 C4 C8 C11 C12 C15 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C41 C50 C51 C52 C54 C67 C68 C70 C71 D1 D3 D4 D5 D8 D12 D15 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D41 D50 D51 D52 D54 D65 D67 D68 D71 E1 E2 E10 E48 E61 E63 E66 E68 F6 F10 F46 F48 F50 F52 F60 F61 F63 F66 F70 F71 G1 G2 G3 G46 G50 G61 G68 G69 G70 G71 H1 H11 H63 H69 H70 J4 J5 J68 J71 K45 K46 M1 M2 M3 M4 N1 N2 N3 N11 N12 P62 U1 U2 U3 U4 U8 U9 V1 V2 V62; VRAM1 A5 A10 U5 U10; VRAM2 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3326 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 1966 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 70 vias
v4: diameter 0.483, hole 0.254, TOP to BOTTOM, 394 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_S:
  vias: v1(25.05,97.71)
1V8_MAIN_EN_N17: length 15.5
  TOP w0.102: v2(99.68,96.63) 99.6,96.56 99.6,93.95 99.33,93.67 99.33,92.59 98.53,91.79 94.84,91.79 93.79,92.84 90.59,92.84 R374.1
  BOTTOM w0.102: U8.F9 100.47,96.63 v2(99.68,96.63)
3V_1V8_MAIN_EN: length 197.8
  TOP w0.102: v1(74.2,116.47) 74.48,116.19 74.52,116.19 PR9012.2 ; v1(21.98,88.53) 21.98,88.18 PR9072.1 ; v2(90.32,92.52) 90.08,92.52 89.83,92.77 R374.2 89.75,93.24 88.93,93.24 88.58,93.59 R403.1 ; PR25541.1 25.59,89.14 v1(25.84,89.39)
  IN1 w0.089: v1(21.98,88.53) 22.54,87.97 24.42,87.97 v1(25.84,89.39) 26.3,89.85 26.3,92.16 24.26,94.21 22.48,94.21 21.55,95.14 21.55,96.73 20.76,97.52 20.76,100.11 21.75,101.09 25.79,101.09 26.96,102.26 40.38,102.26 40.64,102.51 42.45,102.51 42.9,102.96 45.21,102.96 46.45,104.2 48.22,104.2 48.6,104.58 52.33,104.58 53.04,103.87 56.14,103.87 57.21,104.94 61.9,104.94 63.34,103.5 65.35,103.5 65.6,103.26 68.37,103.26 70.23,101.4 76.29,101.4 76.58,101.68 77.19,101.68 78.41,100.46 84.79,100.46 85.51,101.18 86.42,101.18 87.08,100.52 v2(88.65,100.52) 88.65,100.92 88.82,101.09 89.31,101.09 89.67,101.44 89.67,108.71 90.4,109.44 90.4,115.61 91.27,116.49 v1(91.27,116.99) 91.27,117.09 84.93,123.43 73.7,123.43 72.8,122.53 72.8,117.16 73.2,116.76 73.91,116.76 v1(74.2,116.47)
  IN2 w0.089: v2(90.32,92.52) 90.62,92.82 90.62,98.83 89.52,99.93 89.14,99.93 88.65,100.43 v2(88.65,100.52) ; v1(126.35,122.44) 125.92,122.44 124.95,123.4 117.64,123.4 116.43,124.62 108.35,124.62 107.29,123.56 107.29,122.8 105.99,121.49 105.99,120.48 104.95,119.44 99.87,119.44 99.14,118.71 97.9,118.71 96.17,116.98 95.18,116.98 94.69,116.49 91.77,116.49 v1(91.27,116.99)
  BOTTOM w0.102: v1(126.35,122.44) 126.71,122.44 PQ9083.2 127.71,120.18 PR9105.1 ; R25561.2 90.37,92.57 v2(90.32,92.52)
3V_MAIN_EN_N16: length 5.3
  BOTTOM w0.102: U8.A3 95.9,93.03 95.36,92.48 94.01,92.48 93.53,92.97 91.62,92.97 R25561.1
3V_MAIN_PWGD: length 28.9
  TOP w0.102: v1(75.72,115.26) 76.28,115.26 76.56,115.55 76.56,116.15 PR9278.1
  IN1 w0.089: v2(86.85,102.75) 84.49,102.75 84.34,102.6 79.6,102.6 78.07,104.13 v1(77.33,104.13)
  BOTTOM w0.102: R25538.2 87.91,103.31 R25539.1 87.27,103.17 v2(86.85,102.75) Q6551.3 ; PR9282.1 77.35,104.15 v1(77.33,104.13) 77,104.13 76.49,104.64 76.49,107.5 77.94,108.95 77.94,110.81 75.96,112.79 75.96,115.02 v1(75.72,115.26)
5V_HSMBCK: length 1.3
  TOP w0.102: D14.1 23.96,68.68 R490.1
5V_HSMBDT: length 1.5
  TOP w0.102: D14.2 24.46,69.98 23.98,69.5 R491.1
8813VID: length 2.7
  TOP w0.254: PU9000.5 73.23,113.28 73.06,113.45 PR9015.2 71.89,113.78 71.82,113.85 PR9017.2
8813VOUT1: length 4.6
  TOP w0.254: v1(70.57,109.59) 70.93,109.59 71.37,110.03 PU9000.11
  BOTTOM w0.254: PR9028.1 69.63,108.21 69.87,108.45 PC9027.1 69.87,109.89 PC9028.1 70.25,109.91 v1(70.57,109.59)
8813VREF: length 6.7
  TOP w0.203: PC9023.1 69.95,112.93 70.26,112.62 70.26,111.87 v1(70.6,111.54)
  TOP w0.254: PU9000.8 71.32,111.53 71.3,111.55 71.07,111.55 71.06,111.54 v1(70.6,111.54)
  BOTTOM w0.254: PR9033.2 v1(71.59,109.95) 71.35,110.2 PR9021.1 70.91,110.96 70.6,111.27 v1(70.6,111.54)
+1.2VSUS: length 134.4
  TOP w0.102: U2012.E7 v2(43.47,39.48)
  TOP w0.254: v2(45.32,37.55) 45.32,37.88 45.47,38.03 U2012.B9 ; v2(33.97,72.15) 33.97,72.6 U2010.T9 ; v2(38.15,45.23) 38.27,45.11 U2012.L1 ; v2(34.25,36.71) 34.25,37.85 34.27,37.87 U2012.T9 ; U2010.R1 35.44,79.67 v2(35.44,79.68) ; U2009.D9 43.49,85.78 v2(43.49,85.77) ; v2(38.08,79.85) 38.27,79.66 U2010.L1 ; U2012.L9 39.04,37.51 v2(39.04,37.26) ; U2010.J2 39.47,78.1 v2(39.42,78.1) ; 39.43,59.01 39.33,59.01 38.27,57.95 U2011.L1 ; U2010.J1 39.83,79.3 v2(39.43,78.9) ; U2011.B9 45.79,51.17 v2(45.79,51.04) 45.82,51.04 U2011.A9
  TOP w0.305: U2011.G1 41.47,58.28 v2(41.61,58.42) ; U2012.B3 v2(45.87,43.48) ; U2012.C1 44.67,44.75 v2(44.33,45.09) 44.28,45.09 U2012.D1 ; U2012.G7 41.49,39.88 v2(41.89,39.47) 42.27,39.1 U2012.F8 ; U2011.B3 45.49,56.29 v2(45.86,56.66) ; U2010.F2 U2010.E2 v2(43.47,78.1) ; U2010.C1 v2(44.27,78.9) U2010.D1 ; v2(41.73,93.15) 41.47,92.89 U2009.G1 ; v2(43.47,43.48) U2012.E2 42.94,44.01 42.4,44.01 U2012.F2 ; U2010.E7 v2(42.65,74.08) U2010.F8 ; U2011.F2 42.42,56.94 42.92,56.94 U2011.E2 v2(43.47,56.69) ; U2009.E7 43.07,87.71 v2(42.67,87.31) 42.32,86.96 U2009.F8 v2(41.87,87.36) U2009.G7 ; U2011.E7 43.07,53.04 v2(42.67,52.64) 42.32,52.29 U2011.F8 ; v2(34.05,50.89) 34.05,51.27 U2011.T9 ; U2011.G7 v2(41.87,52.69) ; v2(42.6,46.29) 42.6,46.15 41.47,45.02 U2012.G1 ; U2009.F2 42.29,91.76 v2(42.68,92.14) U2009.E2 ; U2010.G1 41.47,79.93 v2(41.62,80.09) ; U2012.D9 43.87,38.27 v2(43.46,37.86) ; U2011.J1 39.88,57.89 v2(40.27,57.49) U2011.J2 ; U2012.A9 46.64,37.91 v2(46.64,37.82) ; v2(45.86,91.37) 45.66,91.17 45.47,90.98 U2009.B3 ; U2010.G7 41.49,74.5 v2(41.89,74.09) ; U2011.D9 v2(43.48,51.1) ; U2009.C1 v2(44.27,92.16) U2009.D1 ; U2009.T9 34.12,86.16 v2(33.82,85.85) ; U2012.J1 U2012.J2 39.82,43.88 39.42,43.48 v2(39.42,43.48) ; U2010.A1 v2(45.87,78.9) ; U2011.G9 v2(41.88,51.08) ; U2010.B3 v2(45.87,78.1) ; U2010.G9 41.7,72.66 v2(41.85,72.51)
  TOP w0.508: R2220.2 v1(36.98,32.68)
  BOTTOM w0.132: U2030.BB41 75.08,58.55 73.45,58.55 v2(73.4,58.49)
  BOTTOM w0.178: v2(74.07,64.62) 74.1,64.58 74.77,64.58 U2030.BB51 ; U2030.BB32 75.14,53.5 75.06,53.5 73.03,53.5 v2(72.85,53.33) ; U2030.BB47 74.94,62.13 74.93,62.14 73.95,62.14 v2(73.92,62.1)
  BOTTOM w0.254: JDIM2000.118 51.46,66.95 v2(51.65,67.14) 51.65,68.06 51.25,68.46 JDIM2000.112 ; 48.42,54.09 48.75,54.09 49.12,54.46 JDIM2000.160 ; v2(55.28,35.15) 55.28,34.82 55.9,34.2 JDIM2000.241 ; v2(51.54,61.2) 51.29,60.95 JDIM2000.142 ; v2(48.47,57.26) 48.67,57.46 JDIM2000.148 ; 59.76,67.2 JDIM2000.117 ; JDIM2000.33 57.47,88.21 57.32,88.35 56.62,88.35 v2(55.43,89.53) ; v2(51.56,65.58) 51.44,65.46 JDIM2000.124 ; JDIM2000.75 59.85,77.7 59.88,77.74 ; v2(48.88,62.22) 49.12,62.46 JDIM2000.136 ; 59.76,61.2 JDIM2000.141 ; JDIM2000.163 59.94,53.7 v2(59.96,53.73) 59.96,54.28 59.53,54.7 JDIM2000.159 ; JDIM2000.96 51.45,72.46 v2(51.57,72.58) ; JDIM2000.220 52.93,39.45 53.44,39.97 v2(53.44,40.5) ; JDIM2000.154 49.27,55.95 48.96,56.27 v2(48.96,56.81) ; v2(56.3,55.74) 57.05,55.74 57.52,56.2 JDIM2000.153 ; 59.87,62.7 JDIM2000.135 ; 59.88,68.7 JDIM2000.111 ; v2(48.56,93.27) 48.74,93.45 JDIM2000.12 ; 59.79,64.2 JDIM2000.129 ; v2(51.57,63.95) JDIM2000.130 ; R2526.1 65.37,30.53 65.37,29.65 62.57,26.86 56.24,26.86 55.53,26.15 53.4,26.15 52.3,27.25 52.3,27.81 51.42,28.69 48.09,28.69 47.48,29.3 47.48,31.28 47.79,31.58 47.79,32.57 ; 59.79,65.7 JDIM2000.123 ; v2(54.62,45.17) 54.62,44.97 54.89,44.71 JDIM2000.199 ; 59.65,58.71 59.65,57.9 59.46,57.7 JDIM2000.147 ; JDIM2000.54 51.36,82.95 51.52,82.8 52.04,82.8 52.31,83.07 v2(52.31,83.3) ; JDIM2000.178 48.61,49.95
  BOTTOM w0.305: v4(77.53,59.84) 77.53,59.71 77.73,59.51 U2030.AU42 ; v2(78.16,49.78) 77.86,49.47 U2030.AU23 ; v4(78.19,52.52) 78.19,52.39 U2030.AU28 ; U2030.BB23 75.03,48.41 73.96,48.41 v1(73.79,48.25) ; U2030.AU35 77.54,56.04 v4(77.54,56.18)
  vias: v1(52.92,112.53) v1(53.53,112.76) v1(53.96,112.28) v1(54.29,112.84) v1(54.7,112.33) v1(55.13,112.84) v1(64.83,96.79) v1(64.91,97.42) v1(65.24,98) v1(65.16,96.23) v1(65.52,96.79) v1(65.57,97.42) v1(69.48,117) v1(70.12,117.03) v2(33.53,61.53) v2(34.3,93.51) v2(34.6,61.53) v2(35.43,58.29) v2(35.48,45.12) v2(38.32,93.3) v2(38.69,72.47) v2(39.49,92.14) v2(39.49,85.77) v2(39.48,85.12) v2(39.48,73.29) v2(39.49,51.07) v2(39.5,50.42) v2(39.87,36.84) v2(40.91,34.66) v2(41.58,70) v2(41.79,34.64) v2(41.88,85.74) v2(41.9,37.87) v2(42.22,70) v2(43.46,72.48) v2(44.27,57.51) v2(45.59,35.89) v2(45.59,35.06) v2(45.66,72.29) v2(45.79,85.71) v2(45.87,92.16) v2(45.87,57.49) v2(45.87,44.28) v2(46.42,93.2) v2(46.77,83.98) v2(46.77,82.36) v2(46.87,92.49) v2(47,93.2) v2(47.36,83.98) v2(47.36,82.36) v2(47.46,92.49) v2(47.59,93.2) v2(47.94,83.98) v2(47.94,82.36) v2(48.53,83.98) v2(48.53,82.36) v2(58.51,59.88) v2(59.2,59.88) v2(59.78,82.31) v2(59.88,80.15) v2(59.92,76.36) v2(59.93,60.51) v2(59.9,59.88) v2(59.98,77.23) v2(60.49,82.31) v2(60.51,80.15) v2(60.62,77.23) v2(60.56,76.36) v2(60.59,60.51) v2(61.3,77.23) v2(61.3,76.34)
+1.5V: length 205.8
  TOP w0.508: v1(153.38,16.57) 161.53,16.57 162.24,17.28 162.24,19.93 163,20.69 163.26,20.69 ; v1(66.94,21.3) 66.94,21.65 66.56,22.03 R2280.2 ; R462.2 205.53,25.18 206.79,25.18 Q21.2 209.46,24.67 211.37,24.67 212.19,25.49 v1(212.78,25.49) 213.08,25.19 214.03,25.19 214.16,25.28 214.32,25.41 214.55,25.55 214.56,25.55 214.73,25.66 214.87,25.72 214.88,25.72 215.05,25.82 215.31,25.9 215.35,25.92 215.66,26.22 215.66,29.28 213.81,31.13 v1(213.81,31.52) R449.1
  IN2 w0.508: v1(212.78,25.49) 212.55,25.49 211.1,24.04 209.3,24.04 207.78,22.52 207.78,20.63 208.69,19.72 209.42,19.72 209.94,19.2 209.94,18.15 209.07,17.28 209.07,14.27 207.63,12.84 207.63,12.31 205.81,10.48 199,10.48 197.65,11.83 197.44,11.83 196.55,12.72 195.36,12.72 195.04,12.4 195.04,12.16 194.71,11.83 193.53,11.83 193.18,12.18 193.18,13.02 191.8,14.4 186.82,14.4 186.59,14.17 183.54,14.17 183.31,14.4 182.16,14.4 181.36,15.2 153.97,15.2 153.38,15.79 v1(153.38,16.57) 152.6,16.57 151.2,17.97 146.87,17.97 145.98,17.08 145.98,16.34 145.16,15.52 120.52,15.52 118.15,17.89 100.45,17.89 99.74,18.6 99.74,18.6 99.58,18.76 99.58,19.43 96.72,22.29 95.46,22.29 95.46,22.29 93.14,22.29 91.74,23.68 91.27,23.68 91.18,23.78 82.94,23.78 81.01,21.86 67.55,21.86 67.02,21.32 66.97,21.32 v1(66.94,21.3)
+1.05V_LAN:
  vias: v1(40.87,103.02) v1(40.96,106.21) v1(41.51,103.03) v1(42.38,104.02) v1(43.11,110.63) v1(43.11,109.97) v1(43.75,110.15) v1(49.39,105.83)
+1.05V_LAN_REGOUT:
  vias: v1(39.97,114.49) v1(40.45,114.06) v1(40.91,113.6) v1(46.82,107.96) v1(47.26,108.57) v1(47.48,107.96) v1(47.73,107.27)
+1.8V: length 294.1
  TOP w0.381: R448.1 212.04,31.47 v1(212.2,31.63) ; R25590.1 25.17,20.8 v1(25.45,21.08)
  TOP w0.508: v1(27.82,32.35) 28.09,32.61 PQ9.1
  IN1 w0.381: v1(212.2,31.63) 212.61,31.63 212.99,31.25 212.99,30.71 212.61,30.33 212.34,30.33 210.67,28.66 208.38,28.66 207.87,29.17 203.85,29.17 203.11,28.43
  IN1 w0.508: v1(21.3,31.23) 21.12,31.05 21.12,23 21.35,22.77 21.35,20.23 v1(21.45,20.13)
  IN2 w0.508: v1(11.36,22.87) 11.36,22.85 12.2,22.01 12.94,22.01 13.6,21.35 13.6,20.74 v1(14.02,20.32) 15.16,20.32 15.89,21.05 17.19,21.05 17.51,20.73 20.85,20.73 v1(21.45,20.13) 22.1,19.48 22.82,19.48 23.3,19.96 23.3,20.34 23.81,20.85 25.22,20.85 v1(25.45,21.08) 26.34,20.19 27.56,20.19 28.45,21.08 30.96,21.08 31.49,21.61 33.86,21.61 34.53,22.29 42.4,22.29 43.29,23.18 45.58,23.18 45.96,22.8 48.11,22.8 49.17,21.73 52.07,21.73 53.67,20.13 67.45,20.13 68.18,20.86 80.92,20.86 83.2,23.14 90.91,23.14 91.01,23.05 91.48,23.05 92.88,21.65 96.46,21.65 98.95,19.17 98.95,18.49 99.48,17.96 99.48,17.96 102.18,15.26 111.14,15.26 111.96,16.08 119.06,16.08 120.26,14.88 145.42,14.88 146.62,16.08 146.62,16.82 147.14,17.33 150.94,17.33 153.71,14.57 181.1,14.57 181.9,13.77 183.04,13.77 183.28,13.53 186.85,13.53 187.08,13.77 189.28,13.77 190.08,12.97 190.08,11.67 190.56,11.19 197.39,11.19 198.73,9.85 215.64,9.85 217.33,11.54 217.33,14.17 215.62,15.89 215.62,16.5 213.54,18.58 211.46,18.58 209.68,20.36 208.96,20.36 208.42,20.9 208.42,22.26 209.56,23.4 212.21,23.4 215,26.2 215,29.83 213.19,31.63 v1(212.2,31.63) ; v1(27.82,32.35) 26.58,32.35 26.22,31.99 22.06,31.99 v1(21.3,31.23)
  BOTTOM w0.381: R733.2 198.1,29.75 198.53,29.33 198.63,29.33 198.86,29.1 198.86,28.9 v2(199.09,28.67)
  BOTTOM w0.508: R25332.1 13.51,19.55 14.02,20.06 v1(14.02,20.32) ; PR9227.1 v1(11.36,22.87)
+1.8V_DEEP_SUS: length 54.6
  IN3 w0.254: v1(152.44,21.53) 152.97,22.06 153.52,22.06 154.42,21.16 158.52,21.16 159.2,21.83 160.18,21.83 161.94,23.58 162.85,23.58 163.64,22.8 166.99,22.8 167.32,23.13 169.2,23.13 169.66,22.67 172.65,22.67 174.2,24.22 175.78,24.22 176.39,24.83 176.39,25.84 176.77,26.23 178.9,26.23 181.03,24.1 181.7,24.1 183.62,26.01 186.11,26.01 187.16,27.06 188.88,27.06 189.63,26.31 193.24,26.31 193.49,26.06 194.82,26.06 195.15,26.39 195.15,26.8 195.46,27.11 v2(195.46,27.16)
  BOTTOM w0.254: v2(195.46,27.16) 195.46,25.51 195.06,25.11 195.06,24.75 ; R664.1 195.72,24.09 195.06,24.75 ; 195.06,24.75 194.85,24.55 R180.1
+1.8V_S5: length 137.6
  TOP w0.508: v1(83.93,28.46) 84.06,28.59 R2299.2 ; R2298.2 87.92,26.64 v2(87.92,26.4) ; R2593.1 101.64,29.65 102.04,29.25 v1(102.04,29.11) ; R9041.1 27.12,23.13 v1(26.4,23.86)
  IN1 w0.508: v1(27.82,31.56) 27.52,31.56 26.89,30.92 26.89,29.19 27.11,28.97 27.11,24.57 v1(26.4,23.86)
  IN2 w0.508: v1(32.4,32.02) 32.38,32 32.38,31.04 33.16,30.26 39.97,30.26 40.49,29.74 46.93,29.74 47.97,30.77 49.36,30.77 49.51,30.62 54.4,30.62 55.28,31.51 56.7,31.51 59.24,28.97 60.18,28.97 60.97,29.75 61.53,29.75 61.87,29.41 62.71,29.41 63.1,29.02 64.37,29.02 67.7,32.35 68.44,32.35 68.74,32.04 69.35,32.04 69.98,32.67 75.86,32.67 76.4,32.13 78.03,32.13 79.84,30.32 80.8,30.32 82.13,28.99 83.4,28.99 v1(83.93,28.46) 84.66,29.19 90,29.19 90.54,29.73 91.15,29.73 91.51,29.36 93.27,29.36 93.64,29.73 95.87,29.73 96.15,29.45 99.45,29.45
  IN3 w0.508: v1(25.67,42.23) 24.78,43.11 24.78,54.13 25.07,54.42 25.07,59.15 25.74,59.82 25.74,72.82 23.75,74.81 23.75,77.75 22.9,78.6 22.9,79.37 21.93,80.34 v1(21.93,82.16)
  BOTTOM w0.508: v1(83.93,28.46) 83.93,28.13 85.66,26.4 v2(87.92,26.4) ; R9048.1 v1(20.33,28.91)
  vias: v1(18.46,89.3) v1(19.12,89.29) v1(32.04,33.59) v1(32.4,32.7)
+1.8V_SW: length 23
  IN1 w0.508: v1(14.55,23.07) 14.55,23.75 14.87,24.07 v1(14.87,24.88) 15.35,25.36 18.4,25.36 v1(19.75,24.01) 19.75,22.03 18.4,20.69 17.41,20.69 16.88,20.15 16.88,18.22 v1(16.66,18.01)
  BOTTOM w0.203: U6502.12 16.53,22.24 16.33,22.03 15.78,22.03 15.2,22.62
  BOTTOM w0.508: v1(14.87,24.88) 14.87,25.51 15.26,25.9 R25278.2 ; R25276.2 18.34,18.55 18.49,18.41 R25273.2 18.49,17.75 18.04,17.31 17.43,17.31 16.75,17.99 16.69,17.99 v1(16.66,18.01)
+1.35V_GFX: length 37.3
  TOP w0.305: C480.2 132.05,113.42 131.44,113.42 v2(131.41,113.4)
  TOP w0.356: C478.2 138.48,86.81 138.48,86.33 v2(138.61,86.21) ; C483.2 128.16,87.12 v2(128.2,87.16)
  TOP w0.381: C494.2 131.38,92.58 v2(131.41,92.61) ; v2(128.22,90.22) 128.2,90.24 C502.1
  TOP w0.457: v2(129.98,109.46) 129.97,109.45 C495.2 ; C440.2 122.5,93.2 v1(122.49,93.2) 122.48,93.2 C438.2 121.23,93.2 v1(121.22,93.2) 121.09,93.08 R318.1
  IN3 w0.381: 129.98,108.44 v2(129.98,109.46)
  BOTTOM w0.254: U8.E23 112.1,96.66 v2(112.1,96.73) ; U8.H24 v2(113.73,98.37) ; U8.H26 114.96,98.74 115.71,98.74 116.14,99.17 v2(116.14,99.25) ; U8.E26 v2(114.52,96.7)
  BOTTOM w0.305: v2(116.14,100.87) 116.14,101.08 115.81,101.41 115.09,101.41 U8.L26 ; v2(114.51,93.41) 114.51,93.41 U8.B26 ; v2(112.94,100.86) U8.L24
  BOTTOM w0.33: VRAM2.B12 127.81,107.41 v2(127.41,107.81) ; VRAM1.P1 129.41,83.4 v2(129.01,83.01) ; v2(139.41,84.61) 139.02,85 VRAM1.B3 ; VRAM1.R5 128.61,86.61 128.2,87.01 v2(128.2,87.16) ; VRAM1.P3 129.42,85 v2(129.81,85.38) ; VRAM2.D12 129.01,107.8 v2(129.01,107.81) 129.41,108.2 VRAM2.D11 129.41,108.21 129.01,108.61 v2(129.01,108.62) 128.99,108.62 VRAM2.C10 ; v2(129.01,105.41) 129.41,105.8 VRAM2.D14 ; VRAM1.N5 130.21,87.01 v2(130.01,87.21) ; v2(127.41,83.01) 127.81,83.4 VRAM1.T1 ; VRAM1.L4 131.42,85.41 v2(131.41,85.41) 131.01,85 VRAM1.M3 ; v2(128.2,85.38) 127.82,85 VRAM1.T3 ; VRAM2.B14 127.81,105.8 v2(127.41,105.41)
  BOTTOM w0.356: v2(104.65,96.64) 105.03,97.01 U8.F14 ; VRAM1.H12 134.21,92.21 v2(134.61,92.61) ; v2(129.98,109.46) 130.21,109.23 VRAM2.E10 ; v2(139.41,91.81) 139.02,92.2 VRAM1.B12 ; VRAM2.H12 VRAM2.G13 VRAM2.F12 131.01,107.4 v2(131.41,107.81) 131.81,108.2 VRAM2.G11 ; VRAM2.M14 135.81,105.8 v2(135.41,105.41) 135.02,105.8 VRAM2.L14 ; VRAM2.L13 VRAM2.M12 ; VRAM2.K12 134.21,107.41 v2(134.61,107.81)
  BOTTOM w0.381: v2(114.52,95.01) 114.14,94.63 U8.C25
  BOTTOM w0.457: v1(121.22,93.2) v1(122.49,93.2) 122.5,93.2 125.91,93.2
  vias: v1(124.52,118.83) v1(124.52,118.17) v1(125.16,118.83) v1(125.44,119.42) v1(125.46,120.08) v1(125.94,118.96) v1(126.58,118.96) v1(127.24,118.96) v1(129.98,101.33) v1(130.62,101.33) v1(131.25,101.33) v1(131.89,101.33) v1(140.55,82.46) v1(140.55,81.8) v1(140.52,81.16) v1(141.21,84.77) v1(141.21,84.06) v1(141.21,83.43) v1(141.24,82.76) v1(141.24,82.05) v1(141.24,81.42) v1(141.9,83.91) v1(141.9,83.22) v1(141.9,82.59) v1(141.92,81.9) v1(141.92,81.22) v2(103.77,97.43) v2(104.65,97.46) v2(107.35,98.21) v2(108.75,97.52) v2(109.49,97.47) v2(110.35,99.05) v2(111.31,107.43) v2(111.28,105.83) v2(111.28,105.03) v2(111.29,104.24) v2(111.29,100.83) v2(111.29,100.01) v2(111.29,99.19) v2(111.36,101.66) v2(127.41,114.99) v2(128.21,116.61) v2(128.21,93.41) v2(128.21,91.81) v2(129.01,116.61) v2(129.01,94.21) v2(129.81,114.21) v2(129.81,91.81) v2(130.61,114.99) v2(130.63,112.62) v2(130.61,90.22) v2(131.41,115.81) v2(131.41,114.99) v2(131.41,106.16) v2(131.41,105.41) v2(131.41,94.21) v2(131.41,93.41) v2(131.41,91.01) v2(131.41,86.21) v2(131.41,83.81) v2(131.41,83.01) v2(132.21,114.99) v2(132.21,91.81) v2(132.21,83.01) v2(133.01,83.81) v2(133.01,83.01) v2(133.81,87.01) v2(134.61,115.81) v2(134.61,91.81) v2(134.61,86.21) v2(134.61,85.41) v2(134.61,83.81) v2(134.61,83.01) v2(135.41,115.81) v2(135.41,114.21) v2(135.41,94.21) v2(135.41,83.01) v2(136.21,112.61) v2(136.21,109.41) v2(136.21,107.8) v2(136.21,92.61) v2(136.21,91.01) v2(136.21,87.01) v2(137.01,116.61) v2(137.01,106.16) v2(137.01,94.21) v2(137.01,92.61) v2(137.01,85.41) v2(137.01,83.01) v2(137.81,114.21) v2(137.81,113.41) v2(137.81,108.61) v2(137.81,107.81) v2(137.81,91.01) v2(137.81,90.21) v2(138.61,116.61) v2(138.61,108.61) v2(138.61,106.21) v2(138.61,105.41) v2(138.61,83.81) v2(138.61,83.01) v2(139.41,114.21) v2(139.41,107.01) v2(139.41,94.21) v2(140.21,86.21)
+1V8_MAIN_EN_G: length 9.2
  TOP w0.254: PQ9084.2 v1(126.38,123.45) ; PQ9084.2 120.97,123.23 120.27,123.23 PR9104.1 ; PQ9084.2 121.18,124.52 PR9102.2
  BOTTOM w0.254: PQ9083.3 126.68,123.14 v1(126.38,123.45)
+1V_S5: length 77.1
  TOP w0.508: v1(121.27,58.2) 121.27,59.27 118.6,61.94 118.6,64.07 PQ11.3
  IN1 w0.254: v1(99.89,59.35) 99.3,58.76 99.3,56.55 v1(98.77,56.01)
  IN1 w0.508: v1(121.27,58.2) 121.27,58.12 118.53,55.38 116.62,55.38 114.59,53.35 110.93,53.35 v1(110.25,52.67)
  IN2 w0.508: v1(109.21,42.73) 110.12,42.73 110.48,43.09 110.48,46.22 110.7,46.45 110.7,51.4 110.25,51.85 v1(110.25,52.67)
  IN3 w0.254: v1(97.55,43.31) 96.79,43.31 96,44.1 95.13,44.1 94.68,44.55 94.68,44.81 94.19,45.29 93.03,45.29 92.44,45.87 92.44,49.84 92.82,50.22 92.82,52.88 93.38,53.44 94.37,53.44 95.08,54.15 96.56,54.15 97.45,55.05 97.5,55.09 98.54,55.09 98.77,55.32 v1(98.77,56.01)
  BOTTOM w0.254: v4(89.8,44.14) 89.75,44.14 U2030.P15 ; U2030.K15 91.65,43.52 v4(91.53,43.52) 91.24,43.81 U2030.L15 ; U2030.N20 90.58,47.39 v4(90.72,47.39) 91.05,47.71 U2030.L21 ; v4(90.72,44.14) 90.58,44.14 U2030.N15 ; U2030.N16 90.42,44.63 90.56,44.63 v4(90.72,44.79) 90.4,45.11 U2030.N17 ; U2030.P18 89.75,46.09 v4(89.8,46.09) ; v1(89.11,35.47) 89.11,35.9 U2030.T1 ; U2030.N18 90.4,45.76 v4(90.72,46.09) ; v4(90.72,46.74) 90.77,46.74 U2030.L19 ; U2030.A14 97.23,43.31 v1(97.55,43.31) ; v1(97.83,40.97) 97.82,40.98 97.75,41.05 97.09,41.05 U2030.A10 ; R2490.2 v1(99.89,59.35) ; v4(89.8,44.79) 89.75,44.79 U2030.P16
  BOTTOM w0.305: v4(91.52,45.39) 91.66,45.39 U2030.K17 ; U2030.AB20 85.98,47.06 v4(85.66,46.74) ; U2030.V15 87.86,43.81 v4(88.16,44.11) ; U2030.AF19 84.23,46.25 84.14,46.25 v4(83.97,46.09) 84.3,45.76 U2030.AF18 ; U2030.AF21 U2030.AF20 84.39,47.06 84.27,47.06 v4(83.96,46.75) ; v4(85.66,46.74) 85.85,46.55 85.96,46.43 86.05,46.43 U2030.AB19 86.25,46.23 86.44,46.23 U2030.Y18 ; v4(85.66,46.74) 85.66,45.52 U2030.AB17 ; v4(83.11,48.08) 83.05,48.13 82.5,48.13 82.3,47.94 82.3,47.49 U2030.AK20 ; v4(91.52,46.04) 91.9,46.41 U2030.K19
  vias: v1(104.14,38.61) v1(104.1,37.96) v1(104.26,39.59) v1(104.65,39.02) v1(104.68,37.45) v1(104.77,38.22) v1(105.14,39.43) v1(105.25,38.65) v1(105.24,37.79) v1(105.25,37.15) v4(88.17,48.11) v4(88.17,47.37)
