# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_GFX_+1V8_GFX_MAIN on IN3 (solid shape): outline of 376 points within 97.85,119.85 123.81,125.87
+3V_LAN on TOP (solid shape): 42.81,108.01 42.81,107.05 42.76,107 42.66,107 42.58,107.07 41.72,107.07 41.3,107.49 41.3,108.38 41.48,108.56 42.26,108.56
+3V_LAN on TOP (solid shape): 43.62,103.75 43.62,102.78 43.7,102.7 43.7,102.6 43.93,102.37 43.93,102.22 44.13,102.02 44.13,100.39 44.05,100.32 43.67,100.32 43.57,100.42 43.57,101.97 43.45,102.09 43.45,103.75 43.47,103.77 43.6,103.77
+3V_LAN on TOP (solid shape): 49.6,112.12 49.6,110.66 49.6,110.65 49.6,108.23 49.53,108.15 49.08,108.15 48.7,107.77 48.7,107.1 47.92,106.31 47.1,106.31 47.08,106.31 47.06,106.32 45.8,106.32 45.76,106.36 45.76,106.44 45.81,106.49 46.75,106.49 46.87,106.62 47.61,106.62 48.26,107.26 48.26,108.23 48.45,108.42 48.45,108.75 48.7,109 48.7,109.99 48.64,110.06 48.08,110.06 47.81,110.32 47.81,112.25 47.95,112.39 49.33,112.39
+3V_LAN on IN3 (solid shape): 49.03,110.4 49.03,109.82 48.65,109.43 47.23,109.43 45.78,107.99 45.78,107.48 46.84,106.42 46.84,105.08 46.82,105.07 46.82,104.51 44.31,101.99 43.68,101.99 43.43,102.24 43.43,102.41 46.08,105.06 46.08,106.14 45.2,107.02 41.74,107.02 41.57,107.2 41.57,107.7 42.2,108.33 45,108.33 47.35,110.68 48.75,110.68
+3V_LDO_EC on TOP (solid shape): 195.3,33.12 195.33,33.05 195.3,32.98 195.23,32.87 195.21,32.75 195.29,32.53 195.5,32.42 195.52,32.42 195.54,32.39 195.54,31.84 195.44,31.74 195.11,31.74 195.07,31.75 195.06,31.79 194.91,31.94 194.91,32.52 194.56,32.86 194.55,32.88 194.55,32.9 194.55,32.93 194.22,33.26 193.89,32.93 193.9,32.85 193.93,32.77 193.93,32.26 193.81,32.14 193.38,32.14 193.35,32.16 193.33,32.19 193.33,33.16 193.78,33.62 194.8,33.62
+3V_LDO_EC on BOTTOM (solid shape): 193.84,33.13 193.84,32.75 193.7,32.61 193.34,32.61 193.23,32.5 193.23,31.79 193.38,31.63 194.32,31.63 194.47,31.79 195.38,31.79 195.42,31.77 195.44,31.74 195.44,31.55 195.85,31.13 195.85,30.95 195.86,30.89 195.89,30.83 195.9,30.81 195.9,30.42 195.91,30.38 195.9,30.34 195.77,30.21 195.29,30.21 195.28,30.22 195.2,30.22 194.96,30.45 194.94,30.56 195.03,30.63 195.35,31.15 194.74,31.17 194.66,31.13 194.57,31.17 194.41,31.31 194.2,31.33 194.19,31.33 193.87,31.33 193.76,31.33 193.69,31.34 193.61,31.33 193.25,31.33 193.13,31.33 192.82,31.63 192.82,32.73 193.31,33.21 193.76,33.21
+3V_MAIN_1V8_AON on TOP (solid shape): 98.69,123.71 98.69,123.33 98.46,123.1 98.05,123.1 97.55,122.6 97.55,122.4 97.42,122.27 97.2,122.27 97.1,122.36 97.09,122.36 96.66,122.8 96.66,123.45 97.22,124.01 98.39,124.01
+3V_MAIN_1V8_AON on TOP (solid shape): 27.62,100.54 27.62,98.64 27.01,98.03 26.99,98.03 26.83,97.88 26.4,97.88 26.25,98.03 26.25,99.43 25.94,99.73 24.6,99.73 24.5,99.83 24.5,101.05 24.67,101.23 26.94,101.23
+3V_MAIN_1V8_AON on TOP (solid shape): 68.95,115.45 68.95,115.07 68.3,114.43 68.08,114.43 67.97,114.48 67.85,114.5 67.58,114.39 67.47,114.12 67.49,114.01 67.54,113.91 67.55,113.84 67.52,113.78 67.42,113.65 67.38,113.49 67.41,113.34 67.5,113.22 67.51,113.18 67.94,112.76 67.96,112.72 67.97,112.67 67.79,112.5 67.38,112.5 66.81,113.07 66.81,114.44 67.98,115.61 68.79,115.61
+3V_MAIN_1V8_AON on BOTTOM (solid shape): 67.5,113.09 67.63,113.09 67.93,112.79 67.93,108.14 68.53,107.54 68.53,103.3 68.31,103.08 68.31,102.22 68.03,101.94 67.79,101.94 67.02,101.94 66.89,102.07 66.89,102.6 67.26,102.97 67.27,102.97 67.35,103.02 67.37,103.1 67.37,104.9 67.37,104.99 67.19,105.17 67.19,105.22 67.2,105.23 67.23,105.32 67.25,105.41 67.23,105.51 67.19,105.6 67.19,105.99 67.23,106.08 67.25,106.18 67.23,106.28 67.2,106.36 67.19,106.37 67.19,106.49 66.36,107.33 66.36,112.64 66.97,113.24 66.97,113.24 67.04,113.32 67.27,113.32
+3V_MAIN_1V8_AON on IN1 (solid shape): outline of 140 points within 56.64,101.46 68.26,104.26
+3V_MAIN_1V8_AON on IN1 (solid shape): outline of 541 points within 26.33,99.05 44.05,102.09
+3V_MAIN_1V8_AON on IN2 (solid shape): 71.92,116.9 71.92,116.25 71.23,115.57 70.28,115.57 70.23,115.62 69.52,115.62 69.24,115.67 69.02,115.5 68.13,114.62 67.7,114.62 67.37,114.29 67.37,113.17 67.52,113.02 67.68,113.02 67.79,112.9 67.79,112.5 67.68,112.39 66.68,112.39 66.43,112.64 66.43,115.15 68.02,116.74 69.24,116.74 69.48,116.65 69.72,116.74 69.91,116.74 70.11,116.67 70.31,116.73 70.32,116.74 70.38,116.74 71.08,117.44 71.39,117.44
+3V_MAIN_1V8_AON on IN2 (solid shape): outline of 510 points within 88.81,117.09 100.04,124.09
+3V_PCH_ME on TOP (solid shape): 163.89,32.7 163.89,31.48 164.15,31.23 164.78,31.23 165.03,30.97 165.03,30.21 164.91,30.09 164.26,30.09 164.23,30.11 164.23,30.12 164.11,30.32 163.88,30.4 163.66,30.32 163.53,30.12 163.53,30.1 163.31,29.88 162.72,29.88 162.68,29.9 162.67,29.93 162.67,30.9 162.11,31.46 162.11,32.09 161.86,32.35 161.86,32.85 162.01,33.01 163.59,33.01
+3V_PCH_ME on BOTTOM (solid shape): 163.56,34.48 163.56,34.46 163.67,34.21 163.92,34.1 163.94,34.1 164.38,33.66 164.38,31.31 163.92,30.85 161.82,30.85 161.79,30.85 161.19,30.85 161.15,30.85 160.55,30.85 160.52,30.85 159.92,30.85 159.88,30.85 159.68,30.85 159.55,30.72 159.55,30.62 159.52,30.54 159.52,30.47 159.52,30.42 159.53,30.36 159.52,30.34 159.37,30.19 159.08,30.19 158.99,30.23 158.98,30.33 159,30.39 159.01,30.47 158.9,30.74 158.63,30.85 158.5,30.82 158.38,30.75 158.31,30.73 158.24,30.75 158.21,30.78 158.17,30.81 158.15,30.82 158.14,30.85 158.14,32.08 158.47,32.41 159.42,32.41 159.63,32.63 162.49,32.63 162.88,33.01 162.88,34.53 163,34.66 163.38,34.66
+3V_RTC on TOP (solid shape): 62.67,42.28 62.67,41.79 62.57,41.69 62.01,41.69 61.73,41.41 61.73,40.52 61.56,40.35 60.72,40.35 60.51,40.55 60.51,41.72 61.15,42.35 62.6,42.35
+3V_RTC on TOP (solid shape): 51.73,26.71 51.73,26.68 52.44,26.68 52.61,26.5 52.61,25.92 52.46,25.77 51.5,25.77 51.4,25.67 51.4,25.06 51.12,24.78 50.51,24.78 50.35,24.93 50.35,26.86 50.53,27.04 51.4,27.04
+3V_RTC on IN2 (solid shape): 40.79,107.96 40.81,107.96 40.83,107.94 40.88,107.89 40.94,107.85 41.01,107.78 41.01,106.77 40.8,106.56 40.34,106.56 40.3,106.56 39.77,106.56 39.71,106.58 39.66,106.58 39.61,106.58 39.56,106.56 39.01,106.56 38.95,106.58 38.9,106.58 38.85,106.58 38.79,106.56 38.34,106.56 37.96,106.95 37.96,107.29 38.63,107.96
+3V_RTC on IN2 (solid shape): outline of 631 points within 19.04,26.05 37.32,29.68
+3V_S5 on TOP (solid shape): 49.92,113.88 49.92,113.55 49.74,113.37 49.73,113.37 49.5,113.26 49.39,113.03 49.39,113.02 49.36,112.99 47.76,112.99 47.66,112.89 47.66,112.79 47.41,112.53 47.26,112.53 47.08,112.71 47.08,113.8 47.45,114.17 49.63,114.17
+3V_S5 on TOP (solid shape): 87.54,29.17 87.57,29.16 87.59,29.12 87.59,27.95 86.7,27.06 86.7,26.71 86.69,26.69 86.69,24.17 86.48,23.96 83.42,23.96 83.25,24.14 83.25,26.43 83.37,26.55 83.48,26.55 83.51,26.54 83.53,26.5 83.53,25.67 84.24,24.96 84.24,24.5 84.34,24.4 85.48,24.4 85.74,24.65 85.74,27.72 86.6,28.59 86.8,28.59 86.8,29.09 86.88,29.17
+3V_S5 on TOP (solid shape): 46.11,29.55 46.11,27.47 45.85,27.22 44.64,27.22 44.49,27.37 44.49,27.75 44.61,27.88 45.22,27.88 45.38,28.03 45.38,28.89 45.41,28.97 45.43,29.07 45.42,29.16 45.38,29.24 45.38,29.25 45.38,29.3 45.22,29.45 43.81,29.45 43.81,29.45 43.39,29.45 43.04,29.81 42.12,29.81 42.07,29.86 42.07,30.06 42.09,30.09 42.12,30.11 43.01,30.11 43.01,30.11 43.1,30.2 44.86,30.2 44.87,30.21 45.17,30.21 45.45,30.21
+3V_S5 on TOP (solid shape): 91.98,31.97 92.15,31.97 93.04,31.07 93.04,30.68 93.04,30.67 93.04,30.32 92.68,29.96 92.67,29.95 92.61,29.91 92.56,29.85 92.56,29.84 92.47,29.75 92.47,29.29 92.12,28.94 92.08,28.88 92.07,28.8 92.07,28.5 92.08,28.43 92.13,28.35 92.14,28.33 92.14,28.17 91.27,27.31 91.27,26.25 91.07,26.05 90.39,26.05 90.33,26.1 90.33,26.38 90.21,26.68 89.9,26.81 89.77,26.79 89.65,26.73 89.55,26.72 89.5,26.81 89.5,28.99 90.01,29.5 90.01,30.01 90.02,30.04 90.06,30.06 90.54,30.06 90.61,29.98 90.61,29.53 90.36,29.27 90.36,28.13 90.38,28.11 90.66,28.11 90.7,28.1 90.74,28.1 91.02,28.1 91.16,28.16 91.22,28.3 91.22,28.4 91.22,28.42 91.23,28.43 91.36,28.56 91.36,28.59 91.48,28.7 91.48,28.73 91.61,28.86 91.61,29.39 91.78,29.57 91.78,29.83 92.22,30.27 92.23,30.27 92.44,30.39 92.52,30.62 92.52,30.66 92.51,30.71 92.51,30.9 92.51,30.91 92.37,31.28 91.98,31.29 91.71,31.29 91.63,31.37 91.63,31.88 91.73,31.98 91.97,31.98
+3V_S5 on TOP (solid shape): 163.82,29.12 163.82,28.66 163.88,28.59 163.91,28.53 163.95,28.49 163.99,28.4 164.07,28.37 164.11,28.37 164.83,27.64 164.84,27.6 164.94,27.34 165.26,27.18 165.29,27.11 165.29,26.58 165.28,26.57 165.28,25.68 164.84,25.23 164.82,25.23 164.6,25.1 164.51,24.85 164.5,24.8 163.69,23.99 163.69,23.38 161.17,20.86 159.31,20.86 159.28,20.88 159.27,20.96 159.27,21.24 159.2,21.4 159.04,21.47 158.94,21.47 158.9,21.48 158.89,21.52 158.89,21.86 158.9,21.87 158.9,22.45 159.07,22.62 160.46,22.62 160.55,22.7 160.55,24.07 160.75,24.27 160.79,24.27 160.8,24.27 162.32,24.27 163.58,25.52 163.66,25.52 163.82,25.58 163.89,25.74 163.89,25.89 163.89,25.89 163.89,26.91 163.24,27.56 163.23,27.59 163.25,27.66 163.26,27.72 163.15,27.99 162.88,28.1 162.82,28.1 162.74,28.08 162.71,28.09 162.49,28.31 162.49,28.5 162.52,28.59 162.52,28.63 162.52,28.97 162.67,29.12 162.67,29.3 162.68,29.33 162.72,29.35 163.59,29.35
+3V_S5 on TOP (solid shape): outline of 106 points within 66.36,15.71 77.01,21.53
+3V_S5 on TOP (solid shape): outline of 363 points within 98.29,22.24 108.27,36.08
+3V_S5 on BOTTOM (solid shape): 64.79,124.73 64.79,123.16 64.79,123.13 64.63,122.97 64.3,122.97 63.78,123.49 63.78,124.38 63.78,124.97 63.84,125.03 64.49,125.03
+3V_S5 on BOTTOM (solid shape): 94.88,26.93 94.88,25.55 94.47,25.15 91.79,25.15 91.6,25.34 91.6,25.79 91.8,25.99 93.84,25.99 94.07,26.21 94.07,26.9 94.19,27.03 94.78,27.03
+3V_S5 on BOTTOM (solid shape): 68.95,22.82 68.95,20.71 69.07,20.59 69.07,20.55 69.1,20.48 69.17,20.45 69.21,20.45 69.23,20.43 69.4,20.43 69.56,20.28 69.56,19.9 69.35,19.7 68.67,19.7 67.98,20.38 67.98,22.92 68.21,23.15 68.62,23.15
+3V_S5 on BOTTOM (solid shape): 101.77,40.27 101.84,40.27 103.09,40.27 103.34,40.02 103.34,38.9 103.32,38.86 103.29,38.85 103.23,38.85 102.54,39.54 101.84,39.54 101.77,39.53 101.7,39.51 101.61,39.52 101.56,39.6 101.56,40.19 101.66,40.3 101.7,40.3
+3V_S5 on BOTTOM (solid shape): 103.11,38.14 103.49,38.14 103.53,38.12 103.54,38.09 103.54,37.63 102.96,37.05 102.42,37.05 102.4,37.07 102.4,37.17 102.39,37.26 102.35,37.35 102.35,37.57 102.43,37.85 102.28,38.1 102.25,38.13 102.25,38.64 102.32,38.72 102.53,38.72
+3V_S5 on BOTTOM (solid shape): 196.3,16.09 196.3,15.61 195.97,15.28 195.97,13.93 196.23,13.67 196.23,13.67 196.26,13.63 196.26,12.77 196.1,12.61 194.79,12.61 194.73,12.67 194.73,12.86 194.73,12.86 194.73,15.51 194.76,15.58 194.83,15.61 194.85,15.61 195.1,15.71 195.21,15.96 195.19,16.07 195.15,16.16 195.14,16.26 195.23,16.32 196.07,16.32
+3V_S5 on BOTTOM (solid shape): 103.24,35.71 104.63,34.32 104.63,33.18 103.72,32.27 102.73,32.27 102.66,32.34 102.66,33.83 102.7,33.85 102.74,33.85 102.8,33.85 103.15,34.21 102.8,34.56 102.74,34.56 102.66,34.58 102.63,34.66 102.63,35.59 102.75,35.71
+3V_S5 on BOTTOM (solid shape): 160.25,23.06 160.26,23.04 160.27,23 160.31,22.91 160.4,22.87 160.44,22.87 160.46,22.85 161.35,22.85 161.38,22.87 161.49,22.87 161.56,22.9 161.61,22.96 161.61,22.98 161.64,23 161.97,23.33 162.19,23.33 162.4,23.12 162.4,22.94 162.4,22.92 162.31,22.78 162.28,22.64 162.28,22.63 162.31,22.5 162.38,22.39 162.39,22.36 162.38,22.32 162.37,22.31 162.37,22.08 162.11,21.83 160.79,21.83 159.95,21.83 159.65,22.13 158.94,22.13 158.58,22.49 158.58,23.48 158.79,23.68 159.62,23.68
+3V_S5 on BOTTOM (solid shape): 83.68,30.62 83.68,30.26 83.53,30.11 83.53,29.88 83.51,29.85 83.48,29.83 83.42,29.83 83.37,29.84 83.17,29.84 83.1,29.81 83.07,29.74 83.07,29.36 83.1,29.29 83.17,29.26 83.37,29.26 83.44,29.29 83.47,29.36 83.47,29.47 83.49,29.51 83.52,29.53 83.58,29.53 83.61,29.52 83.62,29.5 83.93,29.32 84.24,29.5 84.26,29.52 84.29,29.53 84.34,29.53 85.04,28.83 86.28,28.83 86.55,28.56 86.55,28.43 86.7,28.28 87.06,28.28 87.18,28.41 87.18,28.84 87.34,28.99 87.34,30.36 87.39,30.42 87.79,30.42 87.9,30.31 87.9,29.22 88.35,28.76 88.35,27.04 88.28,26.96 85.79,26.96 84.29,28.46 84.29,28.48 84.18,28.72 83.93,28.82 83.8,28.79 83.68,28.71 82.64,28.71 82.26,29.09 82.26,29.4 82.21,29.45 82.21,29.93 82.36,30.09 82.41,30.09 82.47,30.1 82.55,30.14 82.57,30.15 82.64,30.15 82.65,30.16 82.79,30.16 83.35,30.72 83.58,30.72
+3V_S5 on BOTTOM (solid shape): outline of 149 points within 30.19,22.14 46.11,27.85
+3V_S5 on IN1 (solid shape): 35.16,32.9 35.16,32.87 35.16,32.86 35.14,32.73 35.16,32.6 35.16,32.59 35.16,32.47 37.83,29.81 39.18,29.81 40.25,28.73 40.91,28.07 40.96,28.03 45.93,28.03 46.19,27.77 46.19,27.36 45.91,27.09 43.63,27.09 43.61,27.09 43.59,27.11 43.29,27.25 43,27.11 42.98,27.09 42.96,27.09 40.63,27.09 40.59,27.11 40.58,27.11 40.44,27.21 40.25,27.24 40.23,27.25 38.87,28.61 38.82,28.61 38.8,28.63 37.38,28.63 35.56,30.46 35.5,30.46 33.84,32.12 33.84,33.01 33.84,33.06 34.3,33.51 34.56,33.51
+3V_S5 on IN1 (solid shape): outline of 192 points within 61.76,19.9 69.68,28.93
+3V_S5 on IN2 (solid shape): 64.83,123.48 64.83,122.46 64.36,121.99 64.36,117.34 64.34,117.3 64.3,117.25 64.26,117.2 63,115.94 59.97,115.94 58.67,114.64 52.23,114.64 51.91,114.31 50.68,114.31 50.25,113.88 50.09,113.88 49.77,113.56 49.72,113.5 49.69,113.43 49.67,113.41 49.64,113.4 49.24,113.4 48.27,112.43 48.25,112.43 47.99,112.18 47.31,112.18 46.82,112.66 46.82,113.98 46.62,114.18 42.53,114.18 42.35,114.01 42.35,111.64 41.97,111.26 40.5,111.26 40.32,111.44 40.32,112.71 40.47,112.86 41.16,112.86 41.31,113.02 41.31,114.57 42,115.25 47.15,115.25 47.28,115.12 51.5,115.12 51.8,115.43 58.3,115.43 59.66,116.79 62.63,116.79 63.59,117.74 63.59,122.43 63.61,122.47 63.62,122.48 63.73,122.61 63.77,122.77 63.74,122.9 63.64,123.09 63.67,123.16 64.15,123.63 64.68,123.63
+3V_S5 on SVCC (solid shape): outline of 151 points within 32.07,13.83 198.18,30.34
+3V_S5 on IN3 (solid shape): 41.03,112.36 41.03,111.47 40.8,111.24 40.6,111.24 40.47,111.11 40.47,110.45 40.32,110.3 39.94,110.3 39.74,110.5 39.74,112.23 39.99,112.48 40.91,112.48
+3V_S5 on IN3 (solid shape): 35.15,32.9 35.16,32.87 35.16,32.85 35.14,32.79 35.14,32.73 35.16,32.61 35.22,32.5 35.22,31.94 35.11,31.84 34.63,31.84 32.32,34.15 32.32,34.43 32.83,34.94 33.11,34.94
+3V_SSD on TOP (solid shape): 25.89,6.46 25.89,5.5 25.64,5.24 25.06,5.24 24.9,5.09 24.9,4.41 24.83,4.33 24.83,3.57 24.65,3.39 24.56,3.39 24.55,3.39 24.42,3.42 24.29,3.39 24.28,3.39 24.22,3.39 23.53,2.7 21.78,2.7 21.56,2.92 21.56,3.59 21.79,4.06 21.8,4.58 21.8,5.5 22.57,6.26 23.71,6.26 24.17,6.72 25.64,6.72
+3V_SSD on TOP (solid shape): 35.49,4.37 35.62,4.29 35.77,4.26 35.93,4.26 36.09,4.29 36.23,4.38 36.24,4.38 36.37,4.29 36.54,4.26 36.7,4.29 36.84,4.38 36.99,4.38 37.01,4.37 37.11,4.32 37.22,4.3 37.34,4.32 37.45,4.38 39.15,4.38 39.43,4.1 39.43,3.29 39.08,2.93 38.39,2.93 38.13,3.19 38.14,3.26 38.03,3.53 37.76,3.64 37.49,3.54 37.34,3.2 37.33,3.13 37.32,3.11 36.92,2.7 35.04,2.7 34.95,2.79 34.95,4.21 35.05,4.31 35.1,4.31 35.14,4.3 35.25,4.32 35.36,4.37 35.37,4.38 35.47,4.38
+3V_SSD on BOTTOM (solid shape): outline of 856 points within 21.54,2.95 39.89,7.07
+3V_WLAN_P on TOP (solid shape): 173.1,18.41 173.1,17.77 172.78,17.44 172.39,17.44 172.36,17.44 172.33,17.43 172.27,17.42 172.21,17.44 172.1,17.51 171.97,17.54 171.76,17.47 171.63,17.29 171.61,17.24 171.61,17.03 171.44,16.86 171.25,16.86 170.93,17.18 170.47,17.18 170.23,17.42 169.37,17.42 169.28,17.51 169.28,18.2 169.35,18.27 169.84,18.27 169.99,18.12 170.67,18.12 170.83,18.27 171.97,18.27 172.3,18.6 172.91,18.6
+3V_WLAN_P on BOTTOM (solid shape): outline of 95 points within 189.85,25.89 194.96,31.61
+3V_WLAN_P on BOTTOM (solid shape): outline of 160 points within 189.83,10.88 197.43,13.52
+3V_WLAN_P on IN1 (solid shape): 201.72,13.65 201.72,12.2 200.7,11.18 199.42,11.18 198.82,11.79 195.29,11.79 195.08,11.99 195.08,12.26 198.99,12.26 198.99,12.2 199.01,12.15 199.03,12.1 199.05,12.05 199.09,12 199.13,11.96 199.17,11.93 199.22,11.91 199.28,11.89 199.33,11.88 199.39,11.88 199.44,11.88 199.5,11.9 199.55,11.92 199.59,11.95 199.64,11.98 199.67,12.02 199.71,12.07 199.73,12.12 199.75,12.17 199.75,12.23 199.75,12.29 199.75,12.34 199.73,12.39 199.71,12.44 199.67,12.49 199.64,12.53 199.59,12.57 199.55,12.6 199.5,12.62 199.44,12.63 199.39,12.64 199.33,12.64 199.28,12.63 199.22,12.61 199.17,12.58 199.13,12.55 199.09,12.51 199.05,12.47 199.03,12.42 199.01,12.37 198.99,12.31 198.99,12.26 195.08,12.26 195.08,12.74 195.39,13.04 198.68,13.04 199.57,13.93 201.44,13.93
+3V_WLAN_P on IN2 (solid shape): outline of 597 points within 193.53,12.78 204.46,29.73
+3V_WLAN_P on IN3 (solid shape): outline of 126 points within 170.98,16.74 197.04,20.98
+3VLCD_CON on TOP (solid shape): 63.34,106.4 63.68,106.4 64.25,105.83 64.25,105.07 64.04,104.86 62.67,104.86 62.62,104.91 62.62,105.85 62.53,105.94 62.29,105.94 62.19,106.03 62.03,106.03 61.96,106.1 61.96,106.34 62.09,106.46 63.28,106.46
+3VLCD_CON on TOP (solid shape): outline of 106 points within 82.33,95.41 84.81,101.71
+3VLCD_CON on BOTTOM (solid shape): 83.89,95.82 83.89,94.98 83.69,94.78 82.26,94.78 82.1,94.93 82.1,95.24 81.19,96.15 80.83,96.15 80.48,95.79 80.38,95.79 80.38,96.18 81.03,96.83 82.88,96.83
+3VLCD_CON on IN1 (solid shape): 64.43,106.54 64.43,106.06 64.68,105.8 65.52,105.8 66.53,104.79 69.61,104.79 71.54,102.86 75.27,102.86 75.89,103.48 78.14,103.48 79.38,102.25 84.02,102.25 84.19,102.07 84.19,101.34 83.9,101.05 78.71,101.05 77.41,102.35 76.46,102.35 76.04,101.94 71.2,101.94 69.33,103.8 65.82,103.8 65.58,104.04 65.28,104.04 64.82,104.51 64.39,104.51 64.3,104.55 64.2,104.56 64.09,104.54 63.99,104.49 63.32,104.49 61.96,105.85 61.96,106.51 62.11,106.67 64.3,106.67
+3VLCD_CON_R on TOP (solid shape): 61.3,107.44 61.3,106.77 61.71,106.36 61.71,105.95 61.88,105.78 62.09,105.78 62.11,105.76 62.11,104.98 62.04,104.91 61.35,104.91 61.18,105.08 61.18,105.09 60.99,105.28 60.65,105.28 59.93,106 59.93,107.08 60.36,107.51 61.23,107.51
+3VLCD_CON_R on BOTTOM (solid shape): 60.45,107.53 60.49,107.51 60.5,107.48 60.5,106.71 60.7,106.71 60.7,107.48 60.71,107.51 60.75,107.53 60.95,107.53 60.99,107.51 61,107.48 61,106.71 61.2,106.71 61.2,107.48 61.21,107.51 61.25,107.53 61.45,107.53 61.48,107.5 61.48,106.64 61.81,106.31 61.81,105.37 61.63,105.19 60.23,105.19 60.16,105.27 60.16,105.78 59.96,105.98 59.96,106.29 60.21,106.54 60.21,107.5 60.23,107.53
+3VLCD_CON_R_C on TOP (solid shape): 61.69,108.22 62.44,108.22 62.7,108.22 62.75,108.16 62.75,106.84 62.62,106.72 61.98,106.72 61.88,106.72 61.81,106.79 61.81,107.45 61.63,107.63 61.63,107.63 61.55,107.71 61.09,107.71 60.95,107.86 60.95,108.11 61.05,108.22 61.66,108.22
+3VLCD_CON_R_C on BOTTOM (solid shape): 62.77,108.55 62.77,107.89 62.62,107.73 62.06,107.73 61.99,107.66 61.99,106.74 61.96,106.72 61.73,106.72 61.71,106.74 61.71,107.58 61.58,107.71 61.07,107.71 60.92,107.86 60.92,108.55 61,108.62 62.7,108.62
+3VPCU on TOP (solid shape): 20.25,95.59 20.25,94.77 20.07,94.58 18.48,94.58 18.34,94.44 17.78,94.44 17.68,94.54 17.68,95.56 17.81,95.69 20.16,95.69
+3VPCU on TOP (solid shape): 136.28,26.86 136.28,26.58 134.3,24.59 134.3,22.39 134.29,22.36 134.09,22.2 134.02,21.98 134.04,21.87 134.08,21.77 134.09,21.76 134.09,21.72 133.54,21.17 133.54,20.48 133.44,20.38 133.06,20.38 132.57,20.86 132.57,24.85 133.13,25.41 134.15,25.41 135.18,26.44 135.18,26.79 134.99,26.98 134.88,26.98 134.87,26.99 134.77,27.03 134.67,27.05 134.63,27.05 134.59,27.04 134.56,27.04 134.54,27.05 134.45,27.14 134.45,27.62 134.59,27.76 135.38,27.76
+3VPCU on TOP (solid shape): outline of 84 points within 147.73,27.34 157.31,34.91
+3VPCU on BOTTOM (solid shape): 46.1,12.29 46.1,11.36 46.11,11.36 46.14,11.33 46.14,11.31 46.54,10.91 47.23,10.91 47.43,10.7 47.43,9.73 47.18,9.47 45.85,9.47 45.3,10.02 45.3,11.36 45.8,11.36 45.8,12.25 45.6,12.25 45.6,11.36 45.3,11.36 45.3,12.31 45.35,12.36 46.04,12.36
+3VPCU on IN3 (solid shape): 19.01,95.49 19.01,94.26 18.72,93.97 18.05,93.97 17.77,94.24 17.77,95.45 18.02,95.69 18.8,95.69
+3VPCU on IN3 (solid shape): outline of 532 points within 135.32,26.02 153.81,29.27
+3VPCU_EC on IN2 (solid shape): 189.62,32.9 189.67,32.85 189.72,32.8 190.93,31.6 190.93,31.29 190.82,31.18 190.56,31.18 189.28,32.45 189.19,32.57 189.07,32.66 188.89,32.85 188.1,32.85 187.55,32.31 186.85,32.31 186.73,32.43 186.73,32.96 186.9,33.13 187.27,33.13 187.61,33.48 189.05,33.48
+3VSPI on BOTTOM (solid shape): 122.03,20.57 122.03,19.14 122.43,18.74 122.43,17.12 122.16,16.85 122.03,16.85 121.98,16.9 121.98,17.02 122.01,17.08 122.01,17.92 121.98,17.95 121.98,18.25 121.35,18.88 121.35,20.71 121.55,20.92 121.68,20.92
+5V on TOP (solid shape): 18.76,32.47 18.76,30.54 18.6,30.39 17.69,30.39 16.95,29.65 16.39,29.65 16.06,29.98 16.06,32.34 16.38,32.66 18.57,32.66
+5V on TOP (solid shape): 62.65,101.92 62.65,98.46 62.55,98.36 61.89,98.36 61.81,98.44 61.81,100.09 61.68,100.21 61.43,100.21 61.3,100.34 61.3,100.52 61.48,100.7 61.48,101.89 61.78,102.2 62.37,102.2
+5V on TOP (solid shape): outline of 347 points within 202.86,24.9 215.15,32.5
+5V on BOTTOM (solid shape): 210.5,20.09 213.2,20.09 213.34,19.84 213.5,19.6 213.5,19.35 213.38,19.23 212.96,19.23 212.92,19.27 211.84,19.27 211.5,18.93 211.5,17.74 211.34,17.58 209.55,17.58 209.55,18 209.51,18.09 209.42,18.13 208.93,18.13 208.41,18.66 208.41,19.09 209.42,20.1 210.49,20.1
+5V on BOTTOM (solid shape): 123.55,18.7 123.58,18.71 123.61,18.71 123.63,18.7 123.66,18.7 125.03,18.7 125.06,18.69 125.08,18.68 125.77,17.99 125.77,16.09 125.58,15.9 125.3,15.9 125.28,15.89 123.76,15.89 123.75,15.9 123.39,15.9 123.3,15.95 123.3,16.05 123.34,16.14 123.35,16.24 123.34,16.34 123.3,16.43 123.3,16.44 123.3,16.48 123.5,16.68 123.5,18.65
+5V on BOTTOM (solid shape): 198.64,18.93 199.58,18.93 199.71,18.81 199.71,17.89 198.74,16.93 198.74,15.47 198.71,15.46 198.46,15.13 198.69,14.79 198.71,14.79 198.74,14.74 198.74,13.98 198.6,13.84 197.85,13.84 197.69,14 197.69,15.24 197.5,15.43 197.5,17.18 197.39,17.28 197.39,17.69 197.44,17.77 197.53,17.78 197.58,17.77 197.64,17.77 198.02,18.15 197.64,18.53 197.58,18.52 197.53,18.51 197.44,18.53 197.39,18.61 197.39,18.68 197.95,19.24 198.33,19.24
+5V on IN2 (solid shape): outline of 418 points within 203.8,24.72 214.21,30.55
+5V on SVCC (solid shape): outline of 1730 points within 2.03,2.03 217.77,91.81
+5V_FAN on TOP (solid shape): 176.67,29.17 176.67,28.69 176.6,28.62 176.6,26.64 176.49,26.53 175.92,26.53 175.81,26.58 175.69,26.59 175.33,26.59 175.27,26.66 175.27,27.34 175.41,27.48 175.41,29.02 175.64,29.25 176.59,29.25
+5V_FAN on BOTTOM (solid shape): 177.73,28.13 177.73,26.68 177.78,26.63 177.78,26.35 177.62,26.19 177.35,26.19 177.12,26.41 175.72,26.41 175.45,26.69 175.45,27.93 175.78,28.26 177.61,28.26
+5V_HDMIC on TOP (solid shape): outline of 121 points within 11.16,79.82 16.11,86.47
+5V_HDMIC on IN3 (solid shape): outline of 184 points within 11.13,79.72 16.15,86.17
+5V_KB on BOTTOM (solid shape): outline of 463 points within 196.23,10.63 205.17,20.86
+5V_PVDD on TOP (solid shape): 209.05,33.39 209.05,33.18 209.31,32.93 209.31,32.66 209.26,32.47 209.31,32.28 209.31,32.03 209.26,31.84 209.31,31.65 209.31,31.32 209.3,31.31 209.28,31.18 209.3,31.05 209.31,31.04 209.31,30.62 209.25,30.51 209.23,30.39 209.31,30.15 209.53,30.02 209.54,30.01 209.59,29.97 209.98,29.97 210.12,29.83 210.12,28.87 209.94,28.69 208.11,28.69 208.06,28.74 208.06,28.89 208.09,28.91 208.09,32.93 208.65,33.49 208.95,33.49
+5V_S5 on TOP (solid shape): 21.3,40.96 21.3,39 20.81,38.52 20.13,38.52 20.03,38.62 20.03,41.11 20.08,41.16 21.09,41.16
+5V_S5 on TOP (solid shape): outline of 330 points within 16.52,13.6 28.87,21.83
+5V_S5 on BOTTOM (solid shape): 21.73,39.71 21.73,39.36 21.93,39.15 21.93,38.67 21.81,38.54 20.74,38.54 20.71,38.52 20,38.52 19.9,38.62 19.9,40.3 20,40.4 21.04,40.4
+5V_S5 on BOTTOM (solid shape): 206.15,22.33 206.15,21.49 205.67,21.02 203.31,21.02 203.11,21.22 203.11,22.36 203.25,22.5 204.09,22.5 204.18,22.59 205.89,22.59
+5V_S5 on BOTTOM (solid shape): outline of 117 points within 25.85,13.42 30.57,19.54
+5V_S5 on SVCC (solid shape): outline of 1607 points within 17.41,13.83 207.83,123.43
+5VA on TOP (solid shape): outline of 179 points within 198.31,31.09 201.99,36.05
+5VA on BOTTOM (solid shape): 201.36,37.2 201.36,36.85 200.85,36.34 200.82,36.31 200.59,36.08 200.57,36.08 200.14,35.65 200.14,35.09 199.81,34.76 199.75,34.75 199.7,34.73 198.31,34.73 198.05,34.99 198.05,35.67 198.56,36.18 198.56,36.82 198.69,36.94 200.09,36.94 200.47,37.32 201.23,37.32
+5VODD on BOTTOM (solid shape): outline of 376 points within 122.98,16.6 133.01,21.55
+5VPCU on TOP (solid shape): 32.22,20.58 33.06,20.58 33.49,20.15 33.49,15.68 33.03,15.23 30.29,15.23 30.03,15.48 30.03,16.29 31.56,17.82 31.56,20.43 31.72,20.6 32.2,20.6
+5VPCU on TOP (solid shape): 122.26,40.88 122.41,40.73 122.41,40.37 122.2,40.16 121.99,40.16 121.24,39.4 120.01,39.4 119.9,39.52 119.9,40.09 120.05,40.25 120.84,40.25 121.47,40.88 122.2,40.88
+5VPCU on TOP (solid shape): 24.75,30.52 24.75,28.95 24.49,28.69 24.27,28.69 24.15,28.57 24.15,28.07 23.96,27.88 23.61,27.88 23.51,27.97 23.01,27.97 22.95,27.96 22.65,27.96 22.59,28 22.59,28.12 22.61,28.15 22.64,28.17 23.36,28.17 23.36,28.36 22.64,28.36 22.61,28.38 22.59,28.42 22.59,28.57 22.59,29.63 22.85,29.88 23.2,29.88 23.96,30.64 24.62,30.64
+5VPCU on TOP (solid shape): 23.01,26.56 23.95,26.56 24.17,26.34 24.17,24.98 24.12,24.93 24.12,23.73 24.17,23.68 24.17,23.58 23.96,23.38 23.96,22.21 23.81,22.06 23.38,22.06 23.11,22.32 23.1,22.35 23.1,22.48 23.11,22.5 23.12,22.52 23.27,22.82 23.12,23.13 23.11,23.14 23.1,23.17 23.1,23.24 23.11,23.26 23.23,23.41 23.27,23.58 23.23,23.76 23.11,23.9 23.07,23.96 23.08,24.03 23.11,24.12 23.13,24.22 23.01,24.49 22.74,24.6 22.62,24.58 22.51,24.52 22.49,24.51 22.45,24.51 22.41,24.55 22.24,24.55 22.06,24.73 22.06,24.98 22.36,25.28 22.36,25.67 22.62,25.92 22.62,26.12 22.63,26.15 22.67,26.17 23.36,26.17 23.36,26.36 22.67,26.36 22.63,26.38 22.62,26.42 22.62,26.52 22.63,26.55 22.67,26.57 22.95,26.57
+5VPCU on TOP (solid shape): 24.83,49.41 24.83,43.6 23.2,41.97 21.68,41.97 21.3,42.35 21.17,42.45 21.01,42.48 20.86,42.45 20.73,42.35 17.59,42.35 16.78,43.17 16.78,46.16 17.18,46.57 17.18,47.03 17.23,47.12 17.32,47.13 17.39,47.11 17.46,47.1 17.72,47.21 17.84,47.46 17.84,47.51 19.52,47.51 19.53,47.5 19.53,47.28 19.52,47.27 19.47,47.15 19.45,47.03 19.45,46.09 19.25,45.9 19.25,44.75 19.83,44.17 19.98,44.17 19.98,44.12 20.11,43.82 20.41,43.7 20.53,43.72 20.64,43.76 20.86,43.7 21.09,43.76 21.19,43.72 21.31,43.7 21.56,43.7 21.68,43.64 21.8,43.62 21.86,43.63 21.93,43.61 21.97,43.55 22.1,43.35 22.34,43.27 22.61,43.38 22.72,43.65 22.71,43.74 22.68,43.82 22.67,43.9 22.71,43.95 22.79,44.03 22.86,44.13 22.9,44.13 23.96,45.2 23.96,49.49 24.08,49.6 24.64,49.6
+5VPCU on BOTTOM (solid shape): 76.87,100.16 76.87,99.63 77.07,99.43 77.07,97.55 76.92,97.4 76.57,97.4 76.36,97.6 76.36,100.24 76.49,100.37 76.67,100.37
+5VPCU on BOTTOM (solid shape): 25.61,29.55 25.61,28.15 25.82,27.95 26.2,27.95 26.31,27.84 26.31,27.61 26.1,27.39 23.61,27.39 22.77,28.23 22.77,29.7 23.71,30.64 24.52,30.64
+5VPCU on IN3 (solid shape): outline of 3083 points within 15.45,11.25 32.36,47.46
+V3A_LX on BOTTOM (solid shape): 148.4,34.96 148.4,34.65 148.34,34.56 148.3,34.46 148.27,34.43 148.27,34.12 148.5,33.9 150.34,33.9 150.48,33.75 150.48,30.47 150.37,30.35 147.92,30.35 147.68,30.12 146.86,30.12 146.02,29.28 146.02,28.63 145.88,28.49 145.26,28.49 145.25,28.51 145.25,29.83 145.83,30.42 145.83,31.43 146.02,31.62 147.19,31.62 147.51,31.94 147.51,34.94 147.61,35.04 148.32,35.04
+V3A_OUT on TOP (solid shape): 158.86,35.99 158.86,35.09 158.23,34.45 158.12,34.45 158.11,34.47 157.99,34.53 157.86,34.56 157.72,34.53 157.6,34.45 157.44,34.45 157.31,34.33 157.31,33.09 157.13,32.91 157.13,32.51 157.02,32.4 150.61,32.4 149.13,33.87 149.13,34.48 149.26,34.61 150.07,34.61 150.25,34.78 150.25,35.65 150.53,35.93 151.23,35.93 151.52,35.92 151.81,35.93 154.49,35.93 154.93,35.5 157.44,35.5 158.06,36.12 158.74,36.12
+V3A_OUT on BOTTOM (solid shape): 155.8,35.83 159.36,35.83 159.44,35.74 159.44,35.22 159.44,35.22 159.44,34.86 159.32,34.73 158.39,34.73 158.24,34.58 157.52,34.58 157.52,34.59 157.27,34.34 157.27,30.54 157.1,30.37 157.09,30.36 157.07,30.36 152.7,30.36 152.13,30.92 152.13,32.28 150.46,33.95 150.39,34.03 149.23,34.03 149.07,34.19 149.07,35.46 149.28,35.66 151.01,35.66 151.17,35.64 151.62,35.66 153.31,35.66 153.47,35.83 153.87,35.83 154.1,36.06 155.56,36.06
+V5P5A_LX on BOTTOM (solid shape): 43.45,19.95 43.45,18.77 43.3,18.62 42.05,18.62 41.28,17.84 41.28,15.76 41.26,15.73 41.23,15.71 38.92,15.71 38.91,15.71 38.91,18.13 38.63,18.41 38.44,18.41 38.19,18.66 38.19,18.98 38.43,19.22 40.06,19.22 40.92,20.09 43.32,20.09
+V5P5A_OUT on TOP (solid shape): 36.51,20.43 36.51,19.42 36.7,19.22 37.11,19.22 37.21,19.12 37.21,18.76 37.06,18.6 37.06,17.7 37.29,17.47 37.29,16.58 36.94,16.23 36.94,15.53 36.7,15.29 34.41,15.29 34.1,15.61 34.1,20.56 34.22,20.68 36.26,20.68
+V5P5A_OUT on BOTTOM (solid shape): 35.64,19.23 37.62,19.23 37.87,18.99 37.87,15.94 35.91,13.99 35.91,13.04 35.6,12.73 34.85,12.73 34.83,12.73 34.82,12.74 34.58,12.98 34.57,12.98 34.54,13.02 34.54,13.55 34.29,13.8 33.43,13.8 33.12,14.11 32.57,14.11 32.43,14.25 32.43,14.79 32.6,14.96 32.6,16.88 32.35,17.14 31.75,17.14 31.18,17.7 31.18,19.34 31.35,19.51 35.37,19.51
+VCC_CORE on TOP (solid shape): outline of 2003 points within 80.53,50.54 120.83,67.12
+VCC_CORE on BOTTOM (solid shape): outline of 649 points within 80.34,53.73 83.5,59.26
+VCC_CORE on BOTTOM (solid shape): outline of 2592 points within 90.98,48.3 124.19,67.6
+VCC_CORE on IN2 (solid shape): outline of 3355 points within 82,50.89 114.16,65.95
+VCC_CORE on SVCC (solid shape): outline of 87 points within 82.23,51.68 120.08,66.28
+VCCDSW on IN3 (solid shape): outline of 632 points within 73.36,36.56 86.16,46.03
+VCCGT on TOP (solid shape): outline of 3565 points within 80.5,64.04 106.08,86.9
+VCCGT on BOTTOM (solid shape): outline of 1585 points within 69.48,65.58 110.3,90.33
+VCCGT on IN2 (solid shape): outline of 4051 points within 80.57,65.85 100.21,87.04
+VCCGT on SVCC (solid shape): 90.76,83.95 90.93,83.84 91.12,83.81 98.4,83.81 101.87,80.34 102,80.18 102.2,80.12 102.24,80.13 102.3,80.12 102.59,80.12 103.21,79.51 103.37,79.4 103.57,79.36 104.75,79.36 105.09,79.02 105.09,76.4 100.29,71.59 100.18,71.43 100.14,71.23 100.14,65.86 99.8,65.52 94.59,65.52 94.29,65.69 93.99,65.52 93.96,65.52 93.67,65.67 93.39,65.52 86.57,65.52 86.52,65.52 86.46,65.52 83.58,65.52 83.29,65.81 83.35,65.91 83.37,66.03 83.3,66.24 83.12,66.36 83.12,66.43 83.38,66.77 83.12,67.12 83.12,67.16 83.34,67.49 83.12,67.81 83.12,68.36 83.54,68.78 83.59,68.77 83.63,68.77 83.89,68.87 83.99,69.12 83.99,69.17 83.98,69.21 84.59,69.82 85,69.91 85.09,70.32 86.53,71.76 86.64,71.93 86.68,72.12 86.68,75.68 86.63,75.88 86.52,76.05 87.62,77.15 87.67,77.23 87.69,77.33 87.69,81.27 87.67,81.36 87.62,81.45 81.04,88.02 81.04,88.11 81.18,88.25 86.47,88.25
+VCCGT_+VCORE on TOP (solid shape): outline of 1148 points within 87.57,61.09 107.18,71.69
+VCCGT_+VCORE on BOTTOM (solid shape): outline of 376 points within 91.15,60.58 93.1,65.49
+VCCGTX_1 on TOP (solid shape): 83.93,69.4 83.93,68.9 83.29,68.26 83,68.26 82.6,67.86 82.6,65.81 82.56,65.73 82.46,65.72 82.26,65.73 82.08,65.63 82.01,65.61 81.94,65.64 81.86,65.71 81.85,65.74 81.85,65.76 81.74,66.12 81.37,66.21 81.29,66.23 81.24,66.29 81.1,66.53 80.84,66.6 80.78,66.59 80.72,66.57 80.63,66.58 80.58,66.66 80.58,66.75 80.62,66.83 80.7,66.85 81.17,67.2 80.7,67.56 80.62,67.58 80.58,67.66 80.58,69.1 80.83,69.35 82.24,69.35 82.46,69.57 83.07,69.57 83.07,69.58 83.76,69.58
+VCCGTX_1 on BOTTOM (solid shape): outline of 368 points within 80.74,65.16 83.84,69.62
+VCCGTX_1 on IN1 (solid shape): outline of 1707 points within 72.88,65.97 83.88,77.77
+VCCGTX_+VCORE on TOP (solid shape): outline of 92 points within 80.41,61 88.94,69.61
+VCCGTX_+VCORE on BOTTOM (solid shape): outline of 605 points within 80.52,59.1 83.51,67.85
+VCCHDA on SVCC (solid shape): 82.61,46.92 82.61,45.5 82.27,45.16 81.97,44.92 82.04,44.55 82.02,44.53 81.99,44.49 81.98,44.44 81.98,43.29 81.99,43.24 82.02,43.2 82.23,42.99 82.23,42.9 81.96,42.72 81.85,42.4 81.85,39.37 81.71,39.23 76.77,39.23 76.72,39.22 76.68,39.19 76.67,39.18 76.24,39.11 76.17,38.68 74.78,37.29 74.75,37.25 74.74,37.2 74.74,36.23 73.54,35.04 73.39,35.04 72.71,35.73 72.71,36.32 72.98,36.5 73.09,36.82 73.08,36.88 73.07,36.95 77.08,40.95 77.13,41.04 77.15,41.13 77.15,41.92 77.4,42.16 77.49,42.12 77.58,42.11 77.83,42.21 77.93,42.45 77.89,42.61 77.79,42.73 77.79,43.25 77.81,43.31 77.81,43.38 77.81,43.44 77.79,43.51 77.79,44.05 77.82,44.09 77.84,44.13 78.64,44.93 78.74,44.87 78.86,44.85 79.04,44.9 79.17,45.06 79.29,44.9 79.49,44.84 79.69,44.9 79.81,45.07 80.07,45.07 80.17,45.09 80.25,45.15 80.87,45.77 81.11,45.87 81.21,46.11 81.39,46.29 81.45,46.37 81.47,46.47 81.47,46.72 81.7,47.04 81.47,47.37 81.47,47.38 81.61,47.52 81.99,47.52 82.01,47.52
+VCCIO on TOP (solid shape): 82.13,61.99 82.13,61.4 81.9,61.17 81.9,60.63 81.72,60.45 81.6,60.45 81.34,60.2 81.34,59.87 81.14,59.67 80.84,59.67 80.68,59.82 80.68,60.06 80.68,60.06 80.68,60.11 80.72,60.15 80.88,60.15 81.32,60.58 81.32,61.72 81.66,62.06 82.05,62.06
+VCCIO on TOP (solid shape): 81.37,53.34 81.72,53.34 81.82,53.24 81.82,52.96 81.93,52.86 83.1,52.86 83.6,52.36 84.34,52.36 84.39,52.31 84.39,51.89 84.29,51.79 83.34,51.79 83.23,51.68 82.81,51.68 82.51,51.97 82.41,51.97 82.35,51.98 82.31,51.98 82.26,51.98 82.2,51.97 82.08,51.97 81.93,51.82 81.92,51.56 81.82,51.46 81.39,51.46 81.27,51.59 81.27,51.75 80.9,52.11 80.74,52.11 80.53,52.33 80.53,53.55 80.71,53.73 80.98,53.73
+VCCIO on TOP (solid shape): outline of 200 points within 103.21,40.78 108.67,44
+VCCIO on BOTTOM (solid shape): 139.2,31.56 139.2,30.83 139.58,30.46 139.77,30.46 139.86,30.36 139.86,29.98 139.76,29.88 139.41,29.88 139.2,30.09 139.08,30.09 138.83,30.34 138.49,30.34 138.11,30.72 138.11,31.08 138.19,31.15 138.44,31.15 138.52,31.23 138.52,31.56 138.67,31.71 139.05,31.71
+VCCIO on BOTTOM (solid shape): 98.11,81.78 98.11,81.55 98.38,81.27 98.39,81.27 98.56,81.1 98.92,81.1 98.94,81.1 99.08,80.99 99.22,80.96 99.32,80.98 99.42,81.02 99.45,81.02 99.48,81.01 99.53,80.96 99.59,80.88 99.66,80.83 99.73,80.76 99.73,80.05 99.6,79.92 99.38,79.92 99.25,80.05 99.25,80.55 99.1,80.7 97.98,80.7 97.88,80.8 97.88,81.13 97.57,81.43 97.57,81.79 97.7,81.92 97.97,81.92
+VCCIO on BOTTOM (solid shape): 105.75,35 105.75,33.54 105.84,33.45 105.84,33.43 105.82,33.34 105.81,33.27 105.92,33 106.19,32.89 106.35,32.92 106.5,33.04 106.52,33.04 107.03,33.04 107.1,32.98 107.1,32.17 106.74,31.81 106.74,31.78 106.09,31.12 105.73,30.76 105.16,30.76 105.04,30.88 105.04,32.38 104.91,32.51 104.91,35.01 104.96,35.06 105.68,35.06
+VCCIO on BOTTOM (solid shape): outline of 173 points within 80.55,51.89 83.23,53.65
+VCCIO on IN2 (solid shape): 138.72,60.57 138.72,59.96 137.98,59.22 137.45,59.22 136.49,58.25 136.49,56.51 136.48,56.5 136.46,56.37 136.48,56.24 136.49,56.24 136.49,54.61 136.47,54.54 136.45,54.44 135.55,53.53 133.26,53.53 131.35,55.43 131.35,56.91 131.43,56.98 131.86,56.98 131.96,56.88 131.96,56.54 131.96,56.51 131.95,56.5 131.81,56.22 131.95,55.94 131.96,55.92 131.96,55.89 133.79,54.06 134.42,54.06 134.48,54.05 134.53,54.05 134.58,54.05 134.64,54.06 134.99,54.06 135.98,55.05 135.98,58.43 137.61,60.06 137.63,60.07 137.68,60.06 137.73,60.06 138,60.17 138.11,60.44 138.11,60.48 138.1,60.52 138.1,60.54 138.11,60.57 138.29,60.74 138.54,60.74
+VCCIO on IN2 (solid shape): outline of 3646 points within 80.46,41.24 109.89,60.18
+VCCPLL on BOTTOM (solid shape): 92.19,48.88 92.19,48.65 92.09,48.55 92.09,46.95 92.04,46.9 91.87,46.9 91.65,47.12 91.65,48.59 91.65,48.59 91.65,48.88 91.76,48.98 92.09,48.98
+VCCPRTCPRIM_3P3 on IN3 (solid shape): outline of 992 points within 73.72,37.16 82.46,45.85
+VCCSA on TOP (solid shape): 91.91,52.83 91.91,51.08 91.9,51.06 91.83,50.98 91.83,50.73 91.83,50.55 91.85,50.52 91.86,50.5 91.86,50.37 92.16,50.07 92.16,49.81 91.93,49.58 90.41,49.58 89.74,50.26 87.83,50.26 87.69,50.41 87.62,50.41 86.68,50.41 86.52,50.56 84.92,50.56 84.65,50.28 84.65,49.74 84.49,49.58 84.09,49.58 83.96,49.72 83.85,49.82 83.6,49.82 83.49,49.72 83.45,49.67 83.36,49.58 83.2,49.58 83.19,49.57 83.03,49.57 82.84,49.39 82.84,49.31 82.71,49.19 82.46,49.19 82.28,49.19 82.15,49.31 82.15,50.81 82.31,50.96 82.48,50.96 82.67,50.78 83.07,50.78 83.11,50.78 83.15,50.8 83.18,50.81 83.85,50.81 83.88,50.8 83.92,50.78 83.96,50.78 84.26,50.78 84.42,50.84 84.49,50.99 84.49,51.01 84.72,51.24 84.72,52.01 84.85,52.13 86.75,52.13 86.88,52.01 89.6,52.01 89.65,52.06 91.17,52.06 91.39,52.27 91.39,52.32 91.4,52.34 91.4,52.89 91.48,52.96 91.78,52.96
+VCCSA on TOP (solid shape): outline of 111 points within 109.59,41.62 120,44.31
+VCCSA on BOTTOM (solid shape): 82.88,50.67 82.88,49.27 82.79,49.18 82.49,49.18 82.45,49.19 82.41,49.19 82.37,49.19 82.33,49.18 81.95,49.18 81.89,49.24 81.89,50.31 81.89,50.31 81.89,50.58 82.31,50.99 82.56,50.99
+VCCSA on BOTTOM (solid shape): 120.57,44.29 120.58,44.26 120.56,44.18 120.55,44.11 120.66,43.84 120.93,43.73 121.17,43.81 121.3,44.02 121.31,44.03 121.33,44.06 123.02,44.06 123.4,43.67 123.94,43.67 124.12,43.5 124.12,42.85 124.11,42.84 124.09,42.71 124.11,42.58 124.12,42.57 124.12,42.53 124.2,42.44 124.25,42.4 124.74,41.9 124.74,41.05 124.92,40.88 127.32,40.88 127.82,40.37 127.82,37.32 127.58,37.09 127.57,37.07 127.55,37.07 123.51,37.07 123.27,37.31 123.24,37.38 123.27,37.46 123.38,37.59 123.42,37.76 123.42,37.81 123.34,37.98 123.2,38.1 123.18,38.11 123.15,38.16 123.15,39.66 123.18,39.73 123.26,39.76 123.28,39.76 123.55,39.87 123.66,40.14 123.64,40.28 123.57,40.39 123.54,40.46 123.57,40.53 123.64,40.65 123.67,40.79 123.56,41.06 123.29,41.17 123.26,41.17 123.18,41.2 123.15,41.27 123.15,41.57 122.39,42.33 121.93,42.33 121.91,42.35 121.85,42.35 121.68,42.53 118.4,42.53 117.56,42.53 116.34,42.53 115.78,41.97 114.68,41.97 114.53,41.82 112.61,41.82 112.2,42.23 112.2,44.23 112.63,44.66 120.2,44.66
+VCCSA on BOTTOM (solid shape): outline of 421 points within 91.38,48.86 93.93,53.13
+VCCSA on SVCC (solid shape): outline of 91 points within 81.98,37.96 125.03,53.92
+VDD33_12 on TOP (solid shape): 101.87,98.46 101.87,98.09 102.42,97.53 102.42,97.27 102.21,97.05 102.19,97.04 102.1,97.03 102.03,97.01 101.43,97.01 101.2,96.97 101.05,96.79 101.04,96.78 101.02,96.76 100.74,96.76 100.72,96.76 100.63,96.82 100.54,96.84 100.24,96.84 100.21,96.84 100.19,96.84 100.17,96.85 100.14,96.89 100.14,98.05 100.14,98.41 100.26,98.54 101.79,98.54
+VDD33_12 on IN2 (solid shape): outline of 189 points within 100.77,94.86 102.82,98.03
+VDDQ on TOP (solid shape): 50.07,55.59 50.07,55.1 49.97,55 49.29,55 48.75,54.47 47.97,54.47 47.86,54.57 47.86,55.56 48.09,55.79 49.87,55.79
+VDDQ on TOP (solid shape): 48.68,96.19 48.68,95.03 48.53,94.88 47.66,94.88 47.46,95.08 47.46,96.35 47.6,96.49 48.37,96.49
+VDDQ on TOP (solid shape): outline of 267 points within 50.89,93.43 62.65,97.45
+VDDQ on BOTTOM (solid shape): 67.89,125.83 67.89,124.66 67.68,124.45 67.42,124.45 67.19,124.22 67.19,123.81 67.12,123.73 66.71,123.73 66.66,123.79 66.66,124.8 67.04,125.19 67.06,125.19 67.28,125.32 67.37,125.56 67.36,125.67 67.32,125.76 67.31,125.87 67.4,125.92 67.8,125.92
+VDDQ on IN1 (solid shape): 48.65,96.28 49.82,96.28 50.07,96.02 50.07,95.49 49.57,94.98 47.53,94.98 47.13,95.39 47.13,95.96 47.68,96.51 48.42,96.51
+VDDQ on IN1 (solid shape): 49.85,55.82 49.85,55.77 49.84,55.76 49.75,55.57 49.71,55.36 49.71,55.08 49.7,55.06 49.26,54.62 48.27,54.62 47.89,55 47.89,55.4 48.3,55.81 48.3,55.85 48.7,56.25 49.41,56.25
+VDDQ_VTT on TOP (solid shape): 50.94,32.57 50.94,31.74 50.81,31.61 50.38,31.61 50.25,31.48 50.25,29.73 50.46,29.53 50.86,29.53 50.99,29.4 50.99,29.02 50.84,28.87 49.31,28.87 48.86,29.32 48.4,29.32 48.02,29.7 48.02,30.57 48.7,31.25 48.7,32.04 49.39,32.73 50.79,32.73
+VDDQ_VTT on TOP (solid shape): 38.3,102.59 38.75,102.59 39.5,101.84 39.5,101.13 40.13,100.49 42.15,100.49 42.23,100.42 42.23,100.09 42.15,100.01 40.63,100.01 40.07,99.45 40.07,97.7 39.69,97.32 38.29,97.32 38.16,97.45 38.16,97.73 38.26,97.83 39.25,97.83 39.53,98.11 39.53,99.1 39.15,99.48 37.55,99.48 37.48,99.55 37.48,100.19 38.31,101.03 38.31,101.81 38.16,101.97 30.34,101.97 30.03,101.66 30.03,100.82 30.9,99.96 30.9,99.71 30.75,99.55 30.14,99.55 29.91,99.33 29.91,98.11 30.16,97.85 33.74,97.85 33.82,97.78 33.82,97.4 33.77,97.34 30.52,97.34 29.63,96.46 29.63,87.13 29.61,87.12 29.61,85.95 29.35,85.69 28.33,85.69 27.95,86.07 27.95,87.18 28.51,87.74 28.51,93.97 28.03,94.45 28.03,97.37 28.8,98.14 28.8,100.63 28.94,100.77 28.94,101.76 29.78,102.6 38.29,102.6
+VDDQ_VTT on TOP (solid shape): 69.61,119.53 69.61,118.43 69.43,118.25 69.2,118.25 69.17,118.26 69.15,118.28 69.07,118.38 68.95,118.45 68.94,118.46 68.76,118.64 68.76,119.23 68.63,119.35 67.68,119.35 67.46,119.14 66.58,119.14 66.53,119.19 66.46,119.19 66.46,119.2 65.69,119.2 65.67,119.21 65.67,119.35 65.69,119.39 65.72,119.4 66.46,119.4 66.48,119.42 66.83,119.42 66.85,119.41 66.99,119.3 67.14,119.26 67.4,119.37 67.5,119.62 67.42,119.85 67.21,119.97 67.2,119.97 67.17,120 67.02,120 66.97,119.95 66.53,119.95 66.48,120 65.72,120 65.69,120.02 65.67,120.05 65.67,120.15 65.69,120.19 65.72,120.2 66.46,120.2 66.46,120.2 66.86,120.2 67.02,120.36 67.2,120.36 67.21,120.35 67.29,120.32 67.37,120.31 67.58,120.38 67.71,120.55 67.71,120.57 67.74,120.59 68.55,120.59
+VDDQ_VTT on BOTTOM (solid shape): 49.37,30.09 49.37,30.08 51.11,30.08 51.12,30.06 51.13,30.04 51.13,29.88 51.11,29.84 51.08,29.83 49.37,29.83 49.35,29.81 49.26,29.81 49.14,29.69 48.13,29.69 48.04,29.78 48.04,30.36 48.19,30.52 48.94,30.52
+VDDQ_VTT on BOTTOM (solid shape): outline of 205 points within 17.45,85.87 28.61,96.58
+VDDQ_VTT on IN2 (solid shape): 20.05,97.4 20.05,96.76 19.14,95.85 18.1,95.85 17.97,95.97 17.97,96.48 18.63,97.14 18.65,97.15 18.68,97.15 18.73,97.14 18.78,97.14 19.04,97.24 19.16,97.48 19.16,97.5 19.19,97.52 19.92,97.52
+VDDQ_VTT on IN2 (solid shape): 69.72,119.35 69.72,118.64 69.35,118.27 69.18,118.27 69.16,118.28 69,118.43 68.81,118.48 68.68,118.45 68.56,118.38 68.52,118.36 68.49,118.38 68.13,118.73 68.13,119.39 68.36,119.62 69.45,119.62
+VDDQ_VTT on IN2 (solid shape): outline of 362 points within 38.62,108.86 52.13,113.63
+VDDQC on TOP (solid shape): 80.43,59.96 80.43,59.72 80.73,59.41 82.05,59.41 82.13,59.34 82.13,59.11 82.12,59.1 82.09,59.02 82.08,58.93 82.08,58.91 81.82,58.65 80.86,58.65 80.54,58.98 80.53,58.99 80.44,59.15 80.28,59.25 80.26,59.25 80.23,59.29 80.12,59.29 79.96,59.45 79.96,59.99 80,60.03 80.36,60.03
+VIN on TOP (solid shape): 72.58,125.77 72.58,124.9 72.58,124.9 72.58,122.49 72.88,122.19 72.88,121.35 73.91,120.32 73.91,119.02 73.77,118.88 72.99,118.88 72.9,118.97 72.9,119.48 71.47,120.9 71.47,123.4 69.96,124.91 69.96,125.69 70.11,125.84 72.51,125.84
+VIN on TOP (solid shape): 65.31,121.19 65.34,121.19 65.36,121.17 65.37,121.14 65.37,118.55 65.7,118.22 65.7,116.98 65.6,116.88 64.33,116.88 64.16,117.05 64.16,117.51 65.37,117.51 65.37,118.3 65.17,118.3 65.17,117.51 64.97,117.51 64.97,118.29 64.77,118.29 64.77,117.51 64.57,117.51 64.57,118.29 64.37,118.29 64.37,117.51 64.16,117.51 64.16,118.41 64.3,118.55 64.3,121.14 64.31,121.17 64.32,121.19 64.35,121.19
+VIN on TOP (solid shape): outline of 4924 points within 52.27,14.03 141.82,118.05
+VIN on BOTTOM (solid shape): 131.76,48.12 131.76,44.82 131.63,44.69 129.98,44.69 129.86,44.82 129.86,45.84 129.71,45.98 127.39,45.98 127.19,45.78 127.19,44.89 127.39,44.69 128.03,44.69 128.1,44.61 128.1,44 128.03,43.93 123.51,43.93 122.36,45.07 122.36,47.36 122.49,47.48 129.6,47.48 130.44,48.32 131.56,48.32
+VIN on BOTTOM (solid shape): 79.17,105.48 83.74,105.48 83.88,105.35 83.88,104.41 83.75,104.28 82.1,104.28 81.8,103.97 81.8,103.34 82.05,103.08 84.11,103.08 84.21,102.98 84.21,101.93 84.11,101.83 78.79,101.83 78.76,101.86 78.76,104.49 78.2,105.05 77.75,105.05 77.44,105.36 77.39,105.4 77.34,105.43 77.32,105.43 77.3,105.46 77.3,105.8 77.32,105.84 77.35,105.85 78.8,105.85
+VIN on BOTTOM (solid shape): 125.66,78.4 125.66,77.1 123.05,74.48 123.05,74.26 123.56,73.75 123.56,73.57 122.72,72.73 122.72,72.17 123.86,71.03 127.11,71.03 127.16,71.08 127.21,71.08 127.47,71.33 127.47,73.16 127.76,73.46 133.79,73.46 133.91,73.34 133.91,72.48 133.74,72.31 133.12,72.31 133.01,72.2 133.01,69.66 132.7,69.35 129.91,69.35 129.6,69.66 123.79,69.66 123.72,69.72 122.67,69.72 122.59,69.8 122.59,70.47 122.41,70.65 121.93,70.65 121.45,70.17 120.74,70.17 119.29,71.61 117.55,71.61 117.28,71.35 116.99,71.35 116.44,71.89 116.44,72.07 116.46,72.08 116.46,72.24 117.23,73.01 117.69,73.01 118.02,72.68 119.24,72.68 120.1,73.54 123.68,77.12 123.68,78.09 124.67,79.08 124.98,79.08
+VIN on BOTTOM (solid shape): 138.68,69.07 138.68,68.15 138.75,68.08 139,68.08 139.1,67.98 139.1,65.42 139.08,65.39 138.95,65.39 138.7,65.14 138.7,65.08 138.68,65.08 138.68,64.29 138.81,64.16 139.19,64.16 139.71,63.64 139.73,63.61 139.76,63.57 139.79,63.55 139.82,63.53 139.9,63.45 140.28,63.45 140.4,63.33 140.4,62.9 140.09,62.6 139.13,62.6 139,62.47 139,61.99 138.87,61.86 137.25,61.86 136.31,60.92 135.98,60.92 135.82,61.07 135.82,61.4 136.84,62.42 136.84,63.38 137.75,64.29 138.43,64.29 138.43,65.08 138.18,65.08 138.18,64.29 137.93,64.29 137.93,64.3 137.93,65.11 137.81,65.24 137.81,67.93 137.81,67.96 137.83,67.97 137.86,67.98 138.26,67.98 138.43,68.15 138.43,69.09 138.44,69.1 138.66,69.1
+VIN on BOTTOM (solid shape): outline of 199 points within 113.03,30.88 145.64,40.5
+VIN on BOTTOM (solid shape): outline of 302 points within 43.71,14.03 80.71,18.94
+VIN on BOTTOM (solid shape): outline of 477 points within 54.52,113.04 72.86,125.97
+VIN_BLIGHT on TOP (solid shape): 65,109.75 65,109.24 64.86,109.1 64.86,108.6 65.04,108.42 65.59,108.42 65.67,108.34 65.67,107.07 65.61,107.01 65.56,107.01 65.54,107 65.32,107 65.04,107.28 63.86,107.28 63.71,107.43 63.71,107.91 63.72,107.91 63.72,109.33 63.31,109.74 63.31,109.99 63.99,110.68 64.07,110.68
+VIN_BLIGHT on BOTTOM (solid shape): 64.77,108.66 64.77,107.64 63.75,106.62 63.25,106.62 63.21,106.63 63.2,106.67 63.2,107.54 63,107.54 63,106.67 62.99,106.63 62.95,106.62 62.75,106.62 62.69,106.68 62.7,106.71 62.7,107.54 62.69,107.57 62.68,107.6 62.7,107.63 63,107.94 63,108.67 63.18,108.85 64.58,108.85
DVDD_IO on TOP (solid shape): outline of 120 points within 202.5,24.28 204.89,28.66
GND on TOP (solid shape): 19.62,55.46 19.62,54.22 19.54,54.14 18.91,54.14 18.87,54.18 18.87,55.47 18.91,55.51 19.57,55.51
GND on TOP (solid shape): 20.89,49.26 20.89,47.99 20.76,47.87 19.49,47.87 19.37,47.99 19.37,49.26 19.49,49.39 20.76,49.39
GND on TOP (solid shape): 22.54,80.12 22.54,76.82 22.41,76.69 19.11,76.69 18.98,76.82 18.98,80.12 19.11,80.25 22.41,80.25
GND on TOP (solid shape): 23.81,93.84 23.81,93.33 23.68,93.2 21.4,93.2 21.27,93.33 21.27,93.84 21.4,93.97 23.68,93.97
GND on TOP (solid shape): 29.6,52.96 29.6,51.31 29.28,50.99 28.01,50.99 27.87,51.13 27.87,52.92 28.03,53.08 29.48,53.08
GND on TOP (solid shape): 36.41,24.37 36.41,23.13 36.16,22.87 34.68,22.87 34.56,23 34.56,24.52 34.58,24.55 36.23,24.55
GND on TOP (solid shape): 45.45,106.62 45.45,104.15 45.38,104.08 42.91,104.08 42.81,104.18 42.81,106.64 42.89,106.72 45.35,106.72
GND on TOP (solid shape): 75.22,111.9 75.22,109.66 75.07,109.51 72.76,109.51 72.68,109.59 72.68,111.92 72.78,112.03 75.09,112.03
GND on TOP (solid shape): 82.94,107.33 82.94,106.39 82.84,106.29 79.94,106.29 79.61,106.62 79.61,108.27 79.77,108.42 81.85,108.42
GND on TOP (solid shape): 123.38,118.14 123.38,116.95 122.64,116.22 122.18,116.22 122.02,116.38 122.02,118.29 122.07,118.35 123.17,118.35
GND on TOP (solid shape): 127.49,22.21 127.49,18.76 127.39,18.66 123.99,18.66 123.89,18.76 123.89,22.21 123.99,22.31 127.39,22.31
GND on TOP (solid shape): 142.68,117.79 142.68,116.6 142.56,116.47 141.82,116.47 141.67,116.62 141.67,117.74 141.8,117.87 142.6,117.87
GND on TOP (solid shape): 161.76,18.66 161.76,17.89 161.63,17.77 156.2,17.77 156.12,17.84 156.12,18.66 156.2,18.73 161.68,18.73
GND on TOP (solid shape): 211.77,17.41 211.77,15.33 211.64,15.2 209.61,15.2 209.51,15.3 209.51,17.46 209.59,17.54 211.64,17.54
GND on TOP (solid shape): 46.73,33.38 46.73,32.49 46.59,32.34 45.15,32.34 45.04,32.46 45.04,33.3 45.22,33.49 46.62,33.49
GND on TOP (solid shape): 20.61,99.02 20.61,96.73 20.53,96.66 19.11,96.66 19.09,96.68 18.76,96.68 18.55,96.89 18.55,99.02 18.86,99.33 20.31,99.33
GND on TOP (solid shape): 30.49,20.46 30.49,19.95 30.29,19.75 28.97,19.75 28.31,20.41 27.9,20.41 27.9,21.07 29.88,21.07
GND on TOP (solid shape): 42.26,33.41 42.26,32.46 42.18,32.37 39.51,32.37 39.33,32.55 39.33,32.85 39.15,33.03 39.15,33.44 39.28,33.57 42.11,33.57
GND on TOP (solid shape): 48.88,48.12 50.73,48.12 50.91,47.94 50.91,47.46 50.79,47.33 48.32,47.33 47.43,48.22 47.43,48.68 47.69,48.93 48.07,48.93
GND on TOP (solid shape): 50.13,54.52 50.13,52.26 49.92,52.06 49.59,52.06 49.16,51.62 48.65,51.62 48.5,51.78 48.5,53.73 49.39,54.62 50.02,54.62
GND on TOP (solid shape): 137.53,74.18 142.58,74.18 142.71,74.05 142.71,72.99 142.15,72.43 138.12,72.43 136.33,74.21 136.33,74.46 136.49,74.61 137.09,74.61
GND on TOP (solid shape): 113.17,120.76 113.17,119.7 112.96,119.49 112.96,118.1 112.71,117.84 110.81,117.84 110.42,118.22 110.42,120.64 110.68,120.89 113.04,120.89
GND on TOP (solid shape): 116.73,124.2 116.73,122.34 117.07,122 117.07,121.13 116.99,121.05 116.16,121.05 115.5,121.72 115.5,124.2 115.59,124.29 116.65,124.29
GND on TOP (solid shape): 25.11,22.82 25.94,22.82 26.02,22.74 26.49,22.74 26.6,22.64 26.6,22.19 26.24,21.83 25.08,21.83 24.14,22.77 24.14,23.23 24.22,23.3 24.62,23.3
GND on TOP (solid shape): 29.53,49.44 29.53,47.05 29.44,46.97 29.03,46.97 28.92,47.08 28.92,47.97 28.66,48.22 28.04,48.22 27.93,48.33 27.93,49.38 28.1,49.54 29.42,49.54
GND on TOP (solid shape): 29.5,85.05 29.5,83.58 29.37,83.45 28.99,83.45 28.87,83.58 28.87,83.78 28.71,83.93 28.28,83.93 28.19,84.02 28.19,84.95 28.41,85.17 29.38,85.17
GND on TOP (solid shape): 64.48,104.47 64.48,104.09 63.85,103.46 63.85,103.43 63.82,103.39 63.82,103.03 63.69,102.91 63.36,102.91 63.18,103.08 63.18,104.53 63.31,104.66 64.3,104.66
