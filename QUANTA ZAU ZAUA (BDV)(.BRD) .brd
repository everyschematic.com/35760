# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ55: length 63.3
  TOP w0.102: U2012.H8 41.12,39.53 41.12,40.03 41.71,40.62 v2(44.33,40.62)
  IN3 w0.089: v2(44.33,40.62) 44.41,40.7 45.53,40.7 45.7,40.53 45.7,40.42 45.54,40.26 45.54,40.15 45.62,40.07 45.73,40.07 45.89,40.23 46,40.23 46.08,40.15 46.08,40.04 45.85,39.81 45.85,39.7 45.92,39.62 46.03,39.62 46.26,39.85 46.37,39.85 46.45,39.77 46.45,39.66 45.87,39.08 45.87,38.94 45.95,38.86 46.03,38.86 46.64,39.47 46.75,39.47 46.83,39.4 46.83,39.28 46.78,39.23 46.78,39.12 46.86,39.04 46.97,39.04 47.08,39.15 47.18,39.15 47.38,38.95 47.38,38.79 47.06,38.47 47.06,38.36 47.15,38.26 47.31,38.26 47.61,38.57 47.76,38.57 47.85,38.48 47.85,38.33 47.31,37.78 47.31,37.23 47.67,36.87 55.1,36.87 55.37,36.6 58.9,36.6 59.66,35.84 60.22,35.84 61.02,36.63 61.02,37.82 62.03,38.82 62.03,39.65 63.03,40.65 63.03,41.57 63.43,41.97 63.88,41.97 63.96,41.89 63.96,41.21 64.04,41.13 64.15,41.13 64.23,41.21 64.23,41.89 64.31,41.97 64.42,41.97 64.49,41.89 64.49,41.21 64.57,41.13 64.68,41.13 64.76,41.21 64.76,41.89 64.84,41.97 64.95,41.97 65.03,41.89 65.03,41.21 65.11,41.13 65.22,41.13 65.29,41.21 65.29,41.89 65.37,41.97 71.28,41.97 72.39,43.08 72.39,44.48 75.84,47.93 75.84,48.78 76.34,49.28 79.55,49.28 79.64,49.36 79.64,49.52 79.56,49.59 79.36,49.59 79.26,49.69 79.26,50.42 v2(79.51,50.66)
  BOTTOM w0.114: U2030.AP25 v2(79.51,50.66)
M_B_DQ56: length 61.6
  TOP w0.102: U2012.D3 44.2,43.08 44.54,42.75 44.72,42.75 45.12,42.34 45.9,42.34 47.73,40.52 47.73,37.11 v2(47.09,36.47)
  IN3 w0.089: v2(78.18,47.96) 78.18,48.25 78.08,48.35 77.43,48.35 77.19,48.12 77.19,48.05 75.49,46.34 75.49,45.4 74.59,44.5 74.2,44.5 73.63,43.93 73.63,43.35 73.71,43.26 74.13,43.26 74.21,43.18 74.21,43.07 74.15,43 73.71,43 73.64,42.92 73.64,42.81 73.71,42.73 74.13,42.73 74.21,42.64 74.21,42.53 74.15,42.46 73.71,42.46 73.64,42.39 73.64,42.28 73.71,42.2 74.09,42.2 74.16,42.12 74.16,42.01 74.08,41.93 73.71,41.93 73.64,41.85 73.64,41.56 71.99,39.92 70.62,39.92 70.52,40.02 70.52,40.12 70.7,40.3 70.7,40.42 70.6,40.52 70.47,40.52 70.29,40.35 70.19,40.35 70.12,40.42 70.12,40.6 70.04,40.68 68.78,40.68 68.02,39.91 64.02,39.91 63.25,39.15 63.25,38.32 62.24,37.31 62.24,36.13 59.82,33.72 58.64,33.72 57.78,34.58 57.45,34.58 57.38,34.66 57.38,34.78 57.3,34.86 57.19,34.86 57.11,34.78 57.11,34.66 57.03,34.58 56.92,34.58 56.84,34.66 56.84,34.78 56.76,34.86 56.65,34.86 56.58,34.78 56.58,34.66 56.5,34.58 56.39,34.58 56.31,34.66 56.31,34.78 56.23,34.86 56.12,34.86 56.04,34.78 56.04,34.66 55.96,34.58 55.85,34.58 55.78,34.66 55.78,34.78 55.7,34.86 55.59,34.86 55.51,34.78 55.51,34.66 55.43,34.58 55.15,34.58 54.8,34.94 54.5,34.94 54.42,35.01 54.42,35.53 54.35,35.61 54.24,35.61 54.16,35.53 54.16,34.99 54.08,34.91 53.97,34.91 53.89,34.99 53.89,35.53 53.81,35.61 53.7,35.61 53.62,35.53 53.62,34.99 53.55,34.91 53.43,34.91 53.36,34.99 53.36,35.53 53.28,35.61 53.17,35.61 53.09,35.53 53.09,34.99 53.01,34.91 50.89,34.91 50.8,34.83 47.61,34.83 47.3,35.13 47.3,36.26 v2(47.09,36.47)
  BOTTOM w0.114: U2030.AT22 v2(78.18,47.96)
M_B_DQ57: length 61.2
  TOP w0.102: U2012.C3 45.2,42.55 46.18,42.55 48.03,40.7 48.03,36.74 46.79,35.5 46.79,35.21 v2(46.79,35.21)
  IN3 w0.089: v2(77.57,47.93) 77.37,47.93 75.69,46.25 75.69,45.28 74.46,44.06 74.46,41.95 72.18,39.67 70.52,39.67 69.76,40.43 68.88,40.43 68.12,39.67 65.56,39.67 65.47,39.58 65.47,39.45 65.4,39.38 65.29,39.38 65.21,39.46 65.21,39.58 65.12,39.67 64.6,39.67 64.53,39.6 64.53,39.02 64.45,38.95 64.33,38.95 64.27,39 64.27,39.58 64.2,39.66 64.11,39.66 63.49,39.05 63.49,38.22 62.48,37.21 62.48,36.03 59.92,33.48 58.54,33.48 57.68,34.34 54.96,34.34 54.85,34.45 54.85,34.54 54.77,34.63 54.64,34.63 54.57,34.56 54.57,34.42 54.49,34.34 54.38,34.34 54.05,34.67 51.03,34.67 50.79,34.43 50.64,34.43 50.53,34.54 50.44,34.54 50.35,34.45 50.35,34.12 50.29,34.06 50.13,34.06 50.06,34.12 50.06,34.5 49.99,34.57 49.84,34.57 49.78,34.51 49.78,34.12 49.69,34.04 49.58,34.04 49.5,34.11 49.5,34.49 49.43,34.57 49.32,34.57 49.24,34.49 49.24,34.12 49.16,34.04 49.05,34.04 48.97,34.12 48.97,34.49 48.89,34.57 48.78,34.57 48.7,34.49 48.7,34.13 48.63,34.06 48.52,34.06 48.44,34.13 48.44,34.49 48.36,34.57 48.25,34.57 48.17,34.49 48.17,34 48.1,33.93 47.99,33.93 47.9,34.01 47.9,34.49 47.83,34.57 47.72,34.57 47.64,34.49 47.64,34.16 47.56,34.08 47.45,34.08 47.37,34.16 47.37,34.72 47.29,34.8 47.18,34.8 47.1,34.73 47.1,34.16 47.03,34.08 46.89,34.08 46.79,34.18 v2(46.79,35.21)
  BOTTOM w0.114: U2030.AU22 v2(77.57,47.93)
M_B_DQ58: length 59.3
  TOP w0.102: U2012.B8 45.47,38.83 45.93,38.37 v2(45.93,37.82)
  IN3 w0.089: v2(45.93,37.82) 45.93,37.54 45.16,36.77 45.16,34.73 45.08,34.65 44.37,34.65 44.28,34.56 44.28,34.45 44.34,34.38 45.08,34.38 45.16,34.3 45.16,34.19 45.08,34.12 44.37,34.12 44.28,34.03 44.28,33.92 44.34,33.85 45.08,33.85 45.16,33.77 45.16,33.66 45.08,33.58 44.79,33.58 44.71,33.5 44.71,33.39 44.79,33.32 45.08,33.32 45.16,33.24 45.16,32.31 45.27,32.2 45.78,32.2 46.35,31.62 51.43,31.62 51.51,31.7 51.51,31.93 51.59,32.01 51.7,32.01 51.78,31.93 51.78,31.7 51.86,31.62 51.97,31.62 52.05,31.7 52.05,32.03 52.12,32.11 52.23,32.11 52.31,32.03 52.31,31.7 52.39,31.62 52.5,31.62 52.58,31.7 52.58,32.12 52.65,32.2 52.77,32.2 52.85,32.12 52.85,31.7 52.92,31.62 53.03,31.62 53.11,31.7 53.11,32.07 53.2,32.16 53.31,32.16 53.38,32.09 53.38,31.7 53.46,31.62 53.57,31.62 53.65,31.7 53.65,32.16 53.74,32.25 53.85,32.25 53.91,32.19 53.91,31.7 53.99,31.62 54.24,31.62 54.9,32.28 55.49,32.28 55.57,32.36 55.57,32.67 55.65,32.75 55.76,32.75 55.84,32.67 55.84,32.36 55.92,32.28 60.42,32.28 61.76,33.62 61.88,33.62 63.7,35.44 63.7,36.26 64.1,36.66 64.1,37.14 64.64,37.68 65.42,37.68 65.94,38.2 67.17,38.2 67.31,38.34 72.57,38.34 75.72,41.5 75.72,43.93 76.45,44.66 76.45,45.22 77.33,46.1 77.33,46.53 77.83,47.03 v2(78.19,47.03)
  BOTTOM w0.114: U2030.AU21 v2(78.19,47.03)
M_B_DQ59: length 60.1
  TOP w0.102: U2012.C7 v2(45.06,39.49)
  IN3 w0.079: 77.81,46.69 78.02,46.69 78.07,46.64 78.45,46.64 v2(78.84,47.03)
  IN3 w0.089: 77.81,46.69 77.56,46.44 77.56,45.85 76.67,44.96 76.67,44.55 75.97,43.86 75.97,43.37 76.06,43.28 76.45,43.28 76.53,43.2 76.53,42.95 76.45,42.87 76.11,42.87 75.96,42.73 75.96,41.4 72.67,38.1 67.41,38.1 67.24,37.93 66.8,37.93 66.73,37.86 66.73,37.52 66.63,37.42 66.52,37.42 66.42,37.52 66.42,37.83 66.33,37.93 66.22,37.93 66.1,37.81 66.1,36.79 66.01,36.7 65.9,36.7 65.81,36.79 65.81,37.5 65.76,37.55 65.65,37.55 65.54,37.45 65.54,36.67 65.47,36.59 65.36,36.59 65.28,36.67 65.28,37.32 65.2,37.4 65.09,37.4 65.01,37.32 65.01,36.67 64.93,36.59 64.37,36.59 63.94,36.16 63.94,35.34 61.9,33.3 61.78,33.3 60.52,32.04 55,32.04 54.34,31.38 46.25,31.38 45.68,31.96 45.07,31.96 44.94,31.83 44.94,31.63 44.84,31.53 44.72,31.53 44.63,31.62 44.63,32.04 44.78,32.19 44.78,32.9 44.71,32.97 44.13,32.97 44.02,33.08 44.02,33.21 44.09,33.28 44.36,33.28 44.43,33.36 44.43,33.47 44.35,33.55 44.09,33.55 44.02,33.63 44.02,34.65 44.27,34.91 44.68,34.91 44.86,35.08 44.86,39.28 v2(45.06,39.49)
  BOTTOM w0.114: v2(78.84,47.03) U2030.AT21
M_B_DQ60: length 63.3
  TOP w0.102: v2(47.75,35.82) 48.41,36.48 48.41,40.87 46.53,42.75 45.33,42.75 45.14,42.94 45.14,43.41 U2012.C2
  IN3 w0.089: v2(47.75,35.82) 48.06,36.13 54.8,36.13 55.06,35.86 57.89,35.86 57.95,35.8 57.95,35.68 57.72,35.44 57.72,35.32 57.84,35.2 57.94,35.2 58.41,35.68 58.55,35.68 58.64,35.59 58.64,35.5 58.17,35.02 58.17,34.87 58.25,34.79 58.41,34.79 58.92,35.3 59.02,35.3 59.11,35.21 59.11,35.08 58.61,34.58 58.61,34.43 58.72,34.32 58.83,34.32 59.61,35.1 59.74,35.1 59.83,35.01 59.83,34.86 59.37,34.4 59.37,34.28 59.45,34.2 59.62,34.2 60.18,34.76 60.18,35.01 60.27,35.1 60.53,35.1 61.75,36.33 61.75,37.51 62.77,38.52 62.77,39.35 63.82,40.4 67.82,40.4 68.58,41.16 71.51,41.16 71.51,41.16 71.62,41.16 71.88,40.9 72,40.9 72.08,40.98 72.08,41.08 71.81,41.35 71.81,41.46 71.89,41.54 72,41.54 72.4,41.13 72.5,41.13 72.58,41.21 72.58,41.33 72.19,41.72 72.19,41.83 72.26,41.91 72.38,41.91 72.76,41.52 72.89,41.52 72.97,41.6 72.97,41.7 72.56,42.1 72.56,42.21 72.64,42.29 72.75,42.29 72.95,42.1 73.06,42.1 73.14,42.18 73.14,42.28 72.94,42.48 72.94,42.59 73.14,42.79 73.14,44.35 73.89,45.09 74.54,45.09 75.08,45.63 75.08,46.51 76.73,48.15 76.73,48.25 77.25,48.77 79.6,48.77 79.69,48.68 79.69,48.34 v2(80.07,47.96)
  BOTTOM w0.114: U2030.AN22 v2(80.07,47.96)
M_B_DQ61: length 62.7
  TOP w0.102: v2(47.79,35.23) 48.72,36.16 48.72,41.07 46.7,43.08 U2012.A3
  IN3 w0.089: v2(47.79,35.23) 47.99,35.03 48.14,35.03 48.21,35.11 48.21,35.79 48.29,35.87 48.4,35.87 48.48,35.79 48.48,35.16 48.56,35.08 48.67,35.08 48.74,35.15 48.74,35.81 48.82,35.88 48.93,35.88 49.01,35.8 49.01,35.16 49.09,35.08 49.2,35.08 49.28,35.15 49.28,35.81 49.35,35.88 49.46,35.88 49.54,35.8 49.54,35.14 49.61,35.07 49.72,35.07 49.81,35.16 49.81,35.81 49.88,35.88 49.99,35.88 50.08,35.8 50.08,35.14 50.14,35.07 50.25,35.07 50.34,35.16 50.34,35.81 50.42,35.88 50.53,35.88 50.61,35.8 50.61,35.24 50.7,35.15 50.82,35.15 50.9,35.24 50.9,35.78 51.01,35.89 54.58,35.89 54.66,35.81 54.66,35.27 54.75,35.19 54.84,35.19 54.93,35.28 54.93,35.5 55.05,35.62 57.4,35.62 57.48,35.54 57.48,35.22 58.74,33.96 59.72,33.96 61.99,36.23 61.99,37.41 63.01,38.42 63.01,39.25 63.92,40.16 67.92,40.16 68.68,40.92 70.69,40.92 70.74,40.86 70.74,40.72 70.81,40.65 70.98,40.65 71.04,40.71 71.04,40.87 71.09,40.92 71.42,40.92 71.64,40.7 71.64,40.23 71.72,40.16 71.89,40.16 71.95,40.21 71.95,40.54 72.09,40.68 72.41,40.68 73.38,41.65 73.38,44.17 73.99,44.77 74.52,44.77 75.28,45.54 75.28,46.42 76.99,48.13 76.99,48.22 77.34,48.57 78.35,48.57 78.52,48.4 78.81,48.4 78.98,48.57 79.2,48.57 79.43,48.33 v2(79.43,47.96)
  BOTTOM w0.114: v2(79.43,47.96) U2030.AP22
M_B_DQ62: length 61.3
  TOP w0.102: U2012.C8 45.08,38.67 45.08,38.09 44.88,37.89 44.88,35.86 v2(44.37,35.35)
  IN3 w0.079: v2(80.11,47.03) 79.57,46.49 78.01,46.49 77.87,46.35
  IN3 w0.089: 77.87,46.35 77.76,46.23 77.76,45.5 76.87,44.6 76.87,42.9 76.2,42.23 76.2,41.3 72.77,37.86 67.51,37.86 65.96,36.31 65.43,36.31 65.31,36.19 65.31,35.67 65.25,35.61 65.11,35.61 65.02,35.7 65.02,36.22 64.93,36.31 64.43,36.31 64.18,36.06 64.18,35.24 61.94,33 61.82,33 60.56,31.74 55.12,31.74 54.52,31.13 44.47,31.13 44.38,31.22 44.38,32.06 44.32,32.12 44.16,32.12 44.09,32.05 44.09,31.1 44.02,31.03 43.86,31.03 43.78,31.12 43.78,31.56 43.7,31.64 42.95,31.64 42.87,31.72 42.87,31.83 42.95,31.9 43.7,31.9 43.78,31.98 43.78,32.9 43.7,32.98 43.23,32.98 43.15,33.06 43.15,33.17 43.23,33.25 43.7,33.25 43.78,33.33 43.78,33.57 43.7,33.64 43.32,33.64 43.24,33.72 43.24,33.83 43.32,33.91 43.7,33.91 43.78,33.99 43.78,34.76 v2(44.37,35.35)
  BOTTOM w0.114: U2030.AP21 v2(80.11,47.03)
M_B_DQ63: length 62.4
  TOP w0.102: U2012.D7 44.21,39.54 44.21,37.49 43.86,37.14 43.86,36.55 v2(44.38,36.04)
  IN3 w0.089: v2(80.73,47.03) 80.73,46.56 79.87,45.7 78.4,45.7 77.08,44.38 77.08,42.78 76.47,42.17 76.47,41.22 72.87,37.62 67.75,37.62 65.5,35.37 64.65,35.37 61.93,32.65 61.81,32.65 60.59,31.43 55.25,31.43 54.6,30.78 40.64,30.78 40.5,30.91 40.5,31.74 40.67,31.9 42.52,31.9 42.61,31.99 42.61,33.05 42.53,33.12 42.13,33.12 42.05,33.2 42.05,33.31 42.13,33.39 42.53,33.39 42.61,33.47 42.61,34.27 v2(44.38,36.04)
  BOTTOM w0.114: v2(80.73,47.03) U2030.AN21
M_B_DQS0: length 56.4
  TOP w0.102: U2009.B7 v2(45.88,87.35)
  IN3 w0.089: v2(83.46,72.74) 83.24,72.95 82.95,72.95 82.64,73.26 82.64,74.27 83.07,74.7 83.07,75.01 82.41,75.67 81.31,75.67 79.98,77 79.98,79.76 79.39,80.36 77.28,80.36 76.32,81.32 76.18,81.32 75.3,82.19 69.29,82.19 66.38,85.11 65.87,85.11 64.19,86.79 62.56,86.79 62.35,87 62.35,87.4 62.26,87.48 61.94,87.48 61.85,87.4 61.85,87 61.65,86.79 61.16,86.79 60.95,87 60.95,87.4 60.86,87.48 60.55,87.48 60.46,87.4 60.46,87 60.25,86.79 59.76,86.79 59.56,87 59.56,87.4 59.47,87.48 59.15,87.48 59.06,87.4 59.06,87 58.85,86.79 58.37,86.79 58.16,87 58.16,87.4 58.07,87.48 57.75,87.48 57.66,87.4 57.66,87 57.46,86.79 55.18,86.79 54.98,87 54.98,87.4 54.89,87.48 54.57,87.48 54.48,87.4 54.48,87 54.27,86.79 51.43,86.79 51.22,87 51.22,87.25 51,87.47 50.81,87.47 50.72,87.38 50.72,87 50.51,86.79 50.03,86.79 49.82,87 49.82,87.4 49.73,87.48 49.41,87.48 49.33,87.4 49.33,87 49.12,86.79 48.63,86.79 48.42,87 48.42,87.4 48.33,87.48 48.02,87.48 47.93,87.4 47.93,87 47.72,86.79 47.23,86.79 47.07,86.63 46.45,86.63 46.09,87 46.09,87.14 v2(45.88,87.35)
  BOTTOM w0.114: U2030.AH65 v2(83.46,72.74)
M_B_DQS1: length 63
  TOP w0.102: U2009.G3 41.58,90.96 41.79,90.74 41.79,90.28 42,90.07 42.57,90.07 42.66,89.98 v2(42.66,89.71)
  IN3 w0.089: v2(42.66,89.71) 42.66,89.98 42.73,90.05 43.19,90.05 43.77,90.63 43.77,92.29 45.2,93.72 49.12,93.72 49.64,93.2 50.25,93.2 50.33,93.12 50.33,92.29 50.54,92.09 51.03,92.09 51.24,92.29 51.24,93.12 51.33,93.2 53.2,93.2 54.34,92.06 65.85,92.06 68.59,89.32 68.59,88.34 71.2,85.74 80.34,85.74 82.74,83.34 82.74,82.91 84.03,81.62 84.52,81.62 85.63,80.51 85.63,79.03 85.49,78.89 85.26,78.89 85.18,78.98 v2(85.18,79.11)
  BOTTOM w0.076: 84.33,77.29 84.33,77.1 83.78,76.54 83.78,76.26 83.82,76.07 83.82,75.89 83.79,75.78 83.79,75.42 83.77,75.39 83.71,75.34 U2030.AG70
  BOTTOM w0.102: v2(85.18,79.11) 85.18,78.98 85.06,78.86 84.66,78.86 84.33,78.53 84.33,77.29
M_B_DQS2: length 54.3
  TOP w0.102: v2(41.86,77.33) 41.86,77.52 41.68,77.7 U2010.G3
  IN3 w0.079: v2(78.83,72.71) 78.83,72.88 78.74,72.97 78.5,72.97 78.44,73.03 77.91,73.03 77.86,72.98 77.24,72.98 77.22,72.95 77.2,72.95
  IN3 w0.089: 77.2,72.95 76.62,72.95 75.68,73.89 75.05,73.89 74.69,74.25 74.69,75.33 73.89,76.13 73.89,76.64 74.15,76.91 74.15,77.35 72.57,78.93 67.88,78.93 66.43,80.38 65.75,80.38 64.82,81.31 54.14,81.31 53.44,82.01 51.25,82.01 50.72,81.48 47.99,81.48 47.86,81.36 47.86,79.53 47.63,79.3 47.15,79.3 46.9,79.54 46.9,81.57 46.79,81.68 46.47,81.68 46.37,81.58 46.37,79.58 46.08,79.3 45.56,79.3 45.32,79.53 45.32,80.42 45.21,80.53 44.89,80.53 44.77,80.4 44.77,79.48 44.58,79.3 43.19,79.3 43,79.11 43,78.16 42.55,77.71 41.95,77.71 41.86,77.63 v2(41.86,77.33)
  BOTTOM w0.114: v2(78.83,72.71) 78.83,72.31 78.96,72.18 U2030.AR65
M_B_DQS3: length 56.7
  TOP w0.102: v2(47.71,74.14) 47.51,74.33 46.92,74.33 46.75,74.16 45.81,74.16 U2010.B7
  IN3 w0.089: v2(47.71,74.14) 47.93,74.35 49.18,74.35 50.78,75.96 53.88,75.96 54.02,75.83 54.02,74.91 54.22,74.71 54.73,74.71 54.93,74.92 54.93,76 55.02,76.08 55.34,76.08 55.43,76 55.43,74.92 55.64,74.71 56.12,74.71 56.33,74.92 56.33,76.02 56.42,76.11 56.74,76.11 56.83,76.02 56.83,74.92 57.03,74.71 57.52,74.71 57.73,74.92 57.73,76.33 57.82,76.41 58.14,76.41 58.22,76.33 58.22,74.92 58.43,74.71 58.92,74.71 59.13,74.92 59.13,75.82 59.21,75.91 59.53,75.91 59.62,75.82 59.62,74.89 59.83,74.69 60.29,74.69 60.52,74.92 60.52,75.69 60.61,75.78 60.93,75.78 61.02,75.69 61.02,74.89 61.23,74.69 61.71,74.69 61.92,74.89 61.92,75.61 62.01,75.7 62.33,75.7 62.42,75.61 62.42,74.89 62.62,74.69 63.11,74.69 63.32,74.89 63.32,75.61 63.41,75.7 63.72,75.7 63.81,75.61 63.81,74.89 64.02,74.69 64.68,74.69 64.89,74.89 64.89,75.61 64.98,75.7 65.3,75.7 65.39,75.61 65.39,74.89 65.59,74.69 66.08,74.69 66.29,74.89 66.29,75.61 66.38,75.7 66.59,75.7 66.78,75.51 66.78,74.79 67.9,73.67 71.25,73.67 73.84,71.08 74.83,71.08 75.86,70.04 76.89,70.04 77.11,70.27 78.47,70.27 v2(78.83,69.9)
  BOTTOM w0.114: U2030.AR60 v2(78.83,69.9)
M_B_DQS4: length 63.4
  TOP w0.102: U2011.G3 41.59,56.17 v2(41.59,55.65)
  IN3 w0.079: 76.97,58.35 76.98,58.37 77.01,58.37 77.17,58.52 78.43,58.52 78.64,58.31 78.64,58.17 v2(78.85,57.96)
  IN3 w0.089: 76.97,58.35 76.68,58.07 76.36,58.07 74.25,55.96 73.56,55.96 72.48,54.88 65.84,54.88 65.49,54.53 65.49,53.85 65.31,53.67 65.12,53.67 64.98,53.8 64.98,55.01 64.74,55.26 64.35,55.26 64.08,54.99 64.08,52.56 63.95,52.43 63.65,52.43 63.57,52.51 63.57,55.03 63.34,55.26 62.92,55.26 62.67,55 62.67,52.66 62.56,52.55 62.24,52.55 62.16,52.63 62.16,55.02 61.91,55.27 61.51,55.27 61.23,54.99 61.23,52.61 61.1,52.48 60.79,52.48 60.71,52.56 60.71,53.13 60.5,53.33 60.02,53.33 59.81,53.13 59.81,52.12 59.69,52.01 59.41,52.01 59.31,52.11 59.31,53.25 59.15,53.42 58.66,53.42 58.41,53.17 58.41,52.1 58.32,52.01 58,52.01 57.92,52.1 57.92,53.17 57.71,53.37 57.23,53.37 57.01,53.16 57.01,52.56 56.93,52.48 53.38,52.48 52.79,53.07 50.42,53.07 49.2,54.29 48.56,54.29 46.74,56.11 43.32,56.11 43.2,56.23 42.21,56.23 41.97,55.98 41.63,55.65 v2(41.59,55.65)
  BOTTOM w0.114: U2030.AR38 78.85,57.86 v2(78.85,57.96)
M_B_DQS5: length 64.3
  TOP w0.102: U2011.B7 45.79,53.09 46.23,52.65 46.55,52.65 46.7,52.5 46.7,51.35 46.09,50.73 46.09,50.56 v2(45.8,50.27)
  IN3 w0.079: v2(78.82,54.39) 78.68,54.39 78.57,54.28 78.57,54.04 78.38,53.84 77.29,53.84 77.16,53.98 77.07,53.98 77.04,53.95 77.02,53.95
  IN3 w0.089: 77.02,53.95 76.14,53.95 74.36,52.17 74.36,51.66 73.86,51.16 73.53,51.16 72.84,50.47 67.51,50.47 67.37,50.33 67.37,50.15 67.7,49.82 67.7,49.48 67.35,49.14 66.94,49.14 66.68,49.4 66.43,49.4 65.31,48.28 62.48,48.28 61.16,46.97 61.16,46.19 59.07,44.1 58.78,44.1 58.58,44.29 58.58,44.79 58.5,44.87 58.18,44.87 58.09,44.79 58.09,43.65 57.85,43.42 57.35,43.42 57.15,43.62 57.15,44.5 57.06,44.59 56.74,44.59 56.65,44.5 56.65,43.88 56.44,43.67 55.96,43.67 55.75,43.88 55.75,44.5 55.66,44.59 55.34,44.59 55.25,44.5 55.25,44.03 55.04,43.81 54.36,43.81 53.6,44.58 53.6,45.27 53.48,45.4 53.15,45.4 53.06,45.31 53.06,44.65 52.79,44.38 52.22,44.38 51.94,44.65 51.94,45.23 51.81,45.36 51.52,45.36 51.23,45.06 51.23,44.25 50.79,43.81 50.41,43.81 49.72,44.5 49.72,44.94 50.7,45.92 50.7,46.09 50.53,46.27 50.33,46.27 49.28,45.22 49,45.22 48.69,45.54 48.69,45.9 49.76,46.98 49.76,47.13 49.56,47.33 49.41,47.33 48.69,46.61 48.35,46.61 48.01,46.95 48.01,47.24 48.2,47.42 48.2,47.54 47.97,47.77 47.84,47.77 47.66,47.59 47.37,47.59 47.03,47.93 47.03,48.23 47.26,48.46 47.26,48.86 47.13,48.99 46.98,48.99 46.65,48.65 46.3,48.65 46.1,48.86 46.1,50.01 45.84,50.27 v2(45.8,50.27)
  BOTTOM w0.114: U2030.AR32 79,54.13 v2(78.82,54.39)
M_B_DQS6: length 62.8
  TOP w0.102: U2012.G3 41.77,42.78 41.77,42.37 42.12,42.03 43.26,42.03 43.54,42.31 44.44,42.31 44.55,42.21 44.55,41.98 v2(44.32,41.75)
  IN3 w0.079: v2(78.85,51.59) 78.85,51.29 78.77,51.21 78.66,51.21 77.35,51.21 77.08,50.93 77.05,50.93 77.03,50.92
  IN3 w0.089: v2(44.32,41.75) 44.53,41.97 44.53,42.4 44.36,42.58 44.36,43.53 44.71,43.88 45.27,43.88 45.48,43.67 45.48,42.54 45.59,42.43 46.02,42.43 50.36,38.09 54.77,38.09 55.07,38.39 58.65,38.39 58.77,38.5 58.77,38.83 58.97,39.03 59.29,39.03 59.83,38.49 59.98,38.49 60.21,38.72 60.21,38.85 59.62,39.43 59.62,39.79 59.93,40.09 60.26,40.09 60.54,39.81 60.67,39.81 60.85,39.99 60.85,40.24 60.61,40.48 60.61,40.82 60.93,41.14 61.22,41.14 61.47,40.9 61.59,40.9 61.81,41.12 61.81,41.27 61.57,41.52 61.57,41.79 63.16,43.37 63.54,43.37 63.71,43.19 63.86,43.19 63.94,43.28 63.94,44.05 64.15,44.26 64.69,44.26 64.89,44.05 64.89,43.28 64.98,43.19 65.31,43.19 65.4,43.28 65.4,44.08 65.61,44.28 66.09,44.28 66.3,44.08 66.3,43.28 66.39,43.19 66.71,43.19 66.8,43.28 66.8,44.08 67.01,44.28 67.49,44.28 67.7,44.08 67.7,43.28 67.79,43.19 68.13,43.19 68.21,43.27 68.21,44.08 68.42,44.29 68.89,44.29 69.12,44.06 69.12,43.32 69.25,43.19 69.52,43.19 69.62,43.29 69.62,43.95 69.87,44.21 70.37,44.21 71.27,45.1 71.81,45.1 75.02,48.31 75.02,49.11 76.46,50.55 76.66,50.55 77.03,50.92
  BOTTOM w0.114: U2030.AR27 78.85,51.46 v2(78.85,51.59)
M_B_DQS7: length 61.2
  TOP w0.102: U2012.B7 45.72,39.88 46.07,39.53 46.5,39.53 47.05,38.98 47.05,37.51 46.9,37.36 46.26,37.36 46.01,37.12 46.01,36.9 v2(45.71,36.6)
  IN3 w0.079: v2(79.46,47.03) 79.08,47.42 77.98,47.42 77.88,47.32 77.62,47.32 77.51,47.21 77.51,47.17 77.49,47.16
  IN3 w0.089: 77.49,47.16 77.23,46.9 76.91,46.9 76.1,46.08 76.1,44.92 75.16,43.98 75.16,42.89 75.13,42.87 75.13,42.18 75.16,42.15 75.16,41.66 72.4,38.9 70.31,38.9 69.5,39.71 69.14,39.71 68.4,38.97 65.98,38.97 65.22,38.21 64.47,38.21 63.18,36.92 63.18,35.74 60.21,32.78 57.8,32.78 57.59,32.98 57.59,33.44 57.39,33.64 55.15,33.64 54.98,33.46 54.98,33.15 54.73,32.9 54.26,32.9 54,33.16 54,33.73 53.76,33.97 51.32,33.97 51.22,33.88 51.22,32.35 51.01,32.14 50.53,32.14 50.32,32.34 50.32,33.27 50.23,33.36 49.92,33.36 49.83,33.27 49.83,32.37 49.64,32.19 49.16,32.19 48.92,32.42 48.92,33.27 48.84,33.36 48.52,33.36 48.43,33.27 48.43,32.37 48.24,32.19 47.76,32.19 47.53,32.42 47.53,33.27 47.43,33.37 45.89,33.37 45.69,33.57 45.69,34.22 46.03,34.56 46.03,36.28 v2(45.71,36.6)
  BOTTOM w0.114: U2030.AR21 v2(79.46,47.03)
M_B_DQS#0: length 56.4
  TOP w0.102: v2(46.65,87.35) 46.65,87.37 U2009.A7
  IN3 w0.089: v2(46.65,87.35) 46.33,87.35 46.28,87.3 46.28,87.09 46.54,86.84 46.98,86.84 47.14,86.99 47.64,86.99 47.73,87.08 47.73,87.48 47.93,87.69 48.42,87.69 48.63,87.48 48.63,87.08 48.72,86.99 49.03,86.99 49.12,87.08 49.12,87.48 49.33,87.69 49.82,87.69 50.02,87.48 50.02,87.08 50.11,86.99 50.43,86.99 50.52,87.08 50.52,87.46 50.73,87.67 51.09,87.67 51.42,87.34 51.42,87.08 51.51,86.99 54.19,86.99 54.28,87.08 54.28,87.48 54.49,87.69 54.97,87.69 55.18,87.48 55.18,87.08 55.27,86.99 57.37,86.99 57.46,87.08 57.46,87.48 57.67,87.69 58.15,87.69 58.36,87.48 58.36,87.08 58.45,86.99 58.77,86.99 58.86,87.08 58.86,87.48 59.06,87.69 59.55,87.69 59.76,87.48 59.76,87.08 59.85,86.99 60.17,86.99 60.25,87.08 60.25,87.48 60.46,87.69 60.95,87.69 61.16,87.48 61.16,87.08 61.24,86.99 61.56,86.99 61.65,87.08 61.65,87.48 61.86,87.69 62.35,87.69 62.55,87.48 62.55,87.08 62.64,86.99 64.27,86.99 65.95,85.31 66.46,85.31 69.38,82.39 75.39,82.39 76.26,81.52 76.4,81.52 77.36,80.56 79.47,80.56 80.18,79.85 80.18,77.08 81.39,75.87 82.49,75.87 83.27,75.09 83.27,74.62 82.84,74.19 82.84,73.34 83.03,73.15 83.35,73.15 83.46,73.26 v2(83.46,73.39)
  BOTTOM w0.114: U2030.AH66 v2(83.46,73.39)
M_B_DQS#1: length 63
  TOP w0.102: U2009.F3 42,90.68 42,90.36 42.09,90.28 42.47,90.28 v2(42.66,90.47)
  IN3 w0.089: v2(85.17,78.48) 85.39,78.69 85.58,78.69 85.83,78.95 85.83,80.6 84.6,81.82 84.11,81.82 82.94,82.99 82.94,83.42 80.43,85.94 71.28,85.94 68.79,88.43 68.79,89.4 65.93,92.26 54.43,92.26 53.28,93.41 51.24,93.41 51.03,93.2 51.03,92.38 50.94,92.29 50.63,92.29 50.54,92.38 50.54,93.2 50.33,93.41 49.73,93.41 49.21,93.93 45.11,93.93 43.57,92.38 43.57,90.72 43.1,90.26 42.88,90.26 42.66,90.47 v2(42.66,90.47)
  BOTTOM w0.076: 84.53,77.33 84.53,77.25 84.5,77.21 84.5,77.03 83.94,76.48 83.94,76.28 83.98,76.1 83.99,76.08 83.99,75.87 83.95,75.75 83.95,75.37 83.9,75.29 83.89,75.28 83.78,75.13 U2030.AG69
  BOTTOM w0.102: 84.53,77.33 84.53,78.44 84.76,78.67 84.98,78.67 v2(85.17,78.48)
M_B_DQS#2: length 54.3
  TOP w0.102: U2010.F3 v2(41.87,78.1)
  IN3 w0.079: 77.2,73.16 77.22,73.16 77.24,73.13 77.8,73.13 77.85,73.18 78.51,73.18 78.56,73.13 79.05,73.13 v2(79.46,73.53)
  IN3 w0.089: 77.2,73.16 76.7,73.16 75.76,74.09 75.13,74.09 74.89,74.33 74.89,75.42 74.09,76.22 74.09,76.55 74.36,76.82 74.36,77.43 72.66,79.13 67.97,79.13 66.52,80.58 65.83,80.58 64.9,81.51 54.23,81.51 53.52,82.22 51.17,82.22 50.64,81.69 47.9,81.69 47.66,81.44 47.66,79.62 47.55,79.5 47.23,79.5 47.1,79.63 47.1,81.65 46.87,81.88 46.38,81.88 46.16,81.66 46.16,79.67 46,79.5 45.64,79.5 45.53,79.62 45.53,80.5 45.29,80.73 44.81,80.73 44.56,80.49 44.56,79.56 44.5,79.5 43.1,79.5 42.8,79.2 42.8,78.24 42.47,77.91 42.05,77.91 v2(41.87,78.1)
  BOTTOM w0.114: U2030.AR66 v2(79.46,73.53)
M_B_DQS#3: length 56.7
  TOP w0.102: v2(47.7,74.83) 47.7,74.62 47.62,74.54 46.83,74.54 46.66,74.37 46.39,74.37 U2010.A7
  IN3 w0.089: v2(47.7,74.83) 47.7,74.65 47.79,74.56 49.09,74.56 50.7,76.16 53.97,76.16 54.22,75.91 54.22,75 54.3,74.92 54.64,74.92 54.73,75 54.73,76.08 54.94,76.29 55.43,76.29 55.63,76.08 55.63,75 55.72,74.92 56.04,74.92 56.13,75 56.13,76.11 56.34,76.31 56.82,76.31 57.03,76.11 57.03,75 57.12,74.92 57.44,74.92 57.53,75 57.53,76.41 57.73,76.62 58.22,76.62 58.43,76.41 58.43,75 58.52,74.92 58.83,74.92 58.92,75 58.92,75.9 59.13,76.11 59.62,76.11 59.82,75.9 59.82,74.98 59.91,74.89 60.21,74.89 60.32,75 60.32,75.78 60.53,75.98 61.01,75.98 61.22,75.78 61.22,74.98 61.31,74.89 61.63,74.89 61.72,74.98 61.72,75.7 61.92,75.91 62.41,75.91 62.62,75.7 62.62,74.98 62.71,74.89 63.02,74.89 63.11,74.98 63.11,75.7 63.32,75.91 63.81,75.91 64.02,75.7 64.02,74.98 64.1,74.89 64.6,74.89 64.69,74.98 64.69,75.7 64.9,75.91 65.38,75.91 65.59,75.7 65.59,74.98 65.68,74.89 66,74.89 66.09,74.98 66.09,75.7 66.29,75.91 66.68,75.91 66.99,75.6 66.99,74.88 67.99,73.88 71.33,73.88 73.93,71.28 74.92,71.28 75.95,70.25 76.81,70.25 77.03,70.47 78.56,70.47 78.72,70.31 78.8,70.31 78.87,70.38 v2(78.87,70.78)
  BOTTOM w0.114: U2030.AR61 78.96,70.35 78.75,70.56 78.75,70.66 v2(78.87,70.78)
M_B_DQS#4: length 63.4
  TOP w0.102: U2011.F3 41.91,56.29 41.79,56.17 41.79,56.03 42.18,55.65 v2(42.24,55.65)
  IN3 w0.079: 77.11,58.21 77.12,58.22 77.12,58.25 77.23,58.36 78.36,58.36 78.48,58.24 78.48,58.02 78.42,57.96 v2(78.19,57.96)
  IN3 w0.089: 77.11,58.21 76.76,57.86 76.44,57.86 74.33,55.76 73.65,55.76 72.57,54.68 65.92,54.68 65.7,54.45 65.7,53.76 65.4,53.47 65.04,53.47 64.78,53.72 64.78,54.93 64.65,55.05 64.43,55.05 64.28,54.9 64.28,52.48 64.03,52.23 63.56,52.23 63.37,52.42 63.37,54.95 63.26,55.05 63,55.05 62.87,54.92 62.87,52.57 62.64,52.35 62.16,52.35 61.96,52.55 61.96,54.94 61.83,55.07 61.6,55.07 61.43,54.9 61.43,52.52 61.19,52.28 60.71,52.28 60.51,52.48 60.51,53.04 60.42,53.13 60.1,53.13 60.01,53.04 60.01,52.04 59.78,51.8 59.33,51.8 59.11,52.02 59.11,53.17 59.06,53.22 58.74,53.22 58.61,53.09 58.61,52.01 58.41,51.8 57.92,51.8 57.71,52.01 57.71,53.09 57.63,53.17 57.31,53.17 57.22,53.08 57.22,52.48 57.02,52.28 53.3,52.28 52.7,52.87 50.34,52.87 49.12,54.09 48.47,54.09 46.66,55.91 43.24,55.91 43.11,56.03 42.29,56.03 42.17,55.9 42.17,55.72 v2(42.24,55.65)
  BOTTOM w0.114: v2(78.19,57.96) 78.21,57.96 U2030.AT38
M_B_DQS#5: length 64.4
  TOP w0.102: U2011.A7 46.08,53.09 46.02,53.15 46.02,53.32 46.14,53.44 46.39,53.44 46.64,53.19 46.64,52.84 46.91,52.58 46.91,51.26 46.29,50.64 46.29,50.54 v2(46.56,50.27)
  IN3 w0.079: v2(78.17,54.39) 78.34,54.39 78.42,54.31 78.42,54.1 78.32,54 77.35,54 77.22,54.13 77.07,54.13 77.04,54.16 77.02,54.16
  IN3 w0.089: v2(46.56,50.27) 46.36,50.27 46.3,50.22 46.3,48.94 46.39,48.86 46.57,48.86 46.9,49.19 47.22,49.19 47.46,48.95 47.46,48.37 47.23,48.14 47.23,48.02 47.45,47.79 47.58,47.79 47.76,47.97 48.05,47.97 48.4,47.63 48.4,47.34 48.22,47.15 48.22,47.03 48.44,46.81 48.61,46.81 49.32,47.53 49.65,47.53 49.97,47.21 49.97,46.89 48.89,45.82 48.89,45.62 49.09,45.42 49.2,45.42 50.24,46.47 50.61,46.47 50.91,46.18 50.91,45.84 49.92,44.86 49.92,44.59 50.5,44.01 50.71,44.01 51.03,44.33 51.03,45.15 51.44,45.56 51.9,45.56 52.14,45.31 52.14,44.74 52.3,44.58 52.7,44.58 52.86,44.74 52.86,45.39 53.06,45.6 53.56,45.6 53.81,45.36 53.81,44.66 54.45,44.02 54.96,44.02 55.05,44.11 55.05,44.58 55.26,44.79 55.75,44.79 55.95,44.58 55.95,43.96 56.04,43.87 56.36,43.87 56.45,43.96 56.45,44.58 56.66,44.79 57.14,44.79 57.35,44.58 57.35,43.7 57.43,43.62 57.77,43.62 57.89,43.74 57.89,44.87 58.09,45.08 58.58,45.08 58.79,44.87 58.79,44.38 58.86,44.3 58.99,44.3 60.96,46.27 60.96,47.05 62.39,48.49 65.23,48.49 66.34,49.6 66.76,49.6 67.02,49.34 67.27,49.34 67.5,49.57 67.5,49.74 67.17,50.07 67.17,50.41 67.43,50.68 72.76,50.68 73.44,51.36 73.77,51.36 74.15,51.74 74.15,52.26 76.05,54.16 77.02,54.16
  BOTTOM w0.114: v2(78.17,54.39) 78.17,54.23 78.51,53.89 U2030.AT32
M_B_DQS#6: length 62.8
  TOP w0.102: v2(45.08,41.75) 44.86,41.75 44.75,41.87 44.75,42.29 44.53,42.51 43.45,42.51 43.17,42.23 42.2,42.23 41.97,42.46 41.97,42.78 U2012.F3
  IN3 w0.079: 77.18,50.78 77.19,50.79 77.19,50.82 77.42,51.05 78.66,51.05 78.77,51.05 78.85,50.97 v2(78.85,50.66)
  IN3 w0.089: v2(45.08,41.75) 44.81,41.75 44.74,41.82 44.74,42.49 44.56,42.66 44.56,43.45 44.79,43.67 45.19,43.67 45.27,43.59 45.27,42.45 45.51,42.22 45.94,42.22 50.28,37.88 54.85,37.88 55.15,38.19 58.74,38.19 58.97,38.42 58.97,38.74 59.05,38.83 59.2,38.83 59.74,38.29 60.06,38.29 60.41,38.64 60.41,38.93 59.83,39.52 59.83,39.7 60.01,39.89 60.18,39.89 60.46,39.61 60.76,39.61 61.05,39.9 61.05,40.32 60.81,40.56 60.81,40.74 61.01,40.94 61.14,40.94 61.38,40.7 61.68,40.7 62.02,41.04 62.02,41.36 61.77,41.6 61.77,41.7 63.24,43.17 63.45,43.17 63.63,42.99 63.94,42.99 64.15,43.19 64.15,43.97 64.23,44.06 64.6,44.06 64.69,43.97 64.69,43.2 64.9,42.99 65.4,42.99 65.6,43.2 65.6,43.99 65.69,44.08 66.01,44.08 66.1,43.99 66.1,43.2 66.31,42.99 66.79,42.99 67,43.2 67,43.99 67.09,44.08 67.41,44.08 67.5,43.99 67.5,43.2 67.7,42.99 68.22,42.99 68.41,43.18 68.41,44 68.5,44.09 68.81,44.09 68.92,43.97 68.92,43.23 69.17,42.99 69.6,42.99 69.82,43.21 69.82,43.87 69.96,44 70.45,44 71.35,44.9 71.89,44.9 75.22,48.23 75.22,49.02 76.54,50.34 76.74,50.34 77.18,50.78
  BOTTOM w0.114: U2030.AR25 v2(78.85,50.66)
M_B_DQS#7: length 61.3
  TOP w0.102: v2(46.47,36.6) 46.36,36.6 46.21,36.74 46.21,37.03 46.34,37.16 46.98,37.16 47.25,37.43 47.25,39.06 46.66,39.65 46.66,39.96 46.4,40.22 46.05,40.22 45.95,40.12 45.95,39.94 46.01,39.88 U2012.A7
  IN3 w0.079: v2(78.8,47.96) 78.8,47.65 78.72,47.58 77.91,47.58 77.81,47.47 77.55,47.47 77.39,47.32 77.36,47.32 77.35,47.3
  IN3 w0.089: v2(46.47,36.6) 46.32,36.6 46.23,36.51 46.23,34.47 45.89,34.14 45.89,33.66 45.98,33.57 47.51,33.57 47.73,33.35 47.73,32.5 47.84,32.39 48.16,32.39 48.23,32.46 48.23,33.35 48.43,33.56 48.92,33.56 49.13,33.35 49.13,32.5 49.24,32.39 49.56,32.39 49.62,32.46 49.62,33.35 49.83,33.56 50.32,33.56 50.52,33.35 50.52,32.43 50.61,32.34 50.93,32.34 51.02,32.43 51.02,33.96 51.23,34.17 53.84,34.17 54.2,33.81 54.2,33.25 54.34,33.11 54.65,33.11 54.77,33.23 54.77,33.55 55.07,33.84 57.47,33.84 57.8,33.52 57.8,33.06 57.88,32.98 60.13,32.98 62.97,35.82 62.97,37 64.38,38.42 65.14,38.42 65.89,39.17 68.31,39.17 69.06,39.91 69.58,39.91 70.39,39.1 72.31,39.1 74.96,41.75 74.96,44.06 75.89,45 75.89,46.17 76.83,47.1 77.15,47.1 77.35,47.3
  BOTTOM w0.114: U2030.AR22 78.94,48.4 78.8,48.26 v2(78.8,47.96)
M_B_ODT0_MD: length 162.1
  TOP w0.102: U2010.K3 39.21,77.56 39.21,77.41 38.95,77.15 38.8,77.15 v2(38.68,77.27) ; U2011.K3 38.87,56.29 38.44,55.87 38.44,55.07 38.61,54.9 39.02,54.9 39.19,55.07 v2(39.19,55.34) ; v2(38.71,91.36) 38.7,91.35 38.7,91.33 U2009.K3 ; v2(39.64,42.51) 39.73,42.61 39.73,42.75 39.54,42.94 39.54,43.01 39.47,43.08 U2012.K3
  TOP w0.165: R2104.2 37.7,98.77 v1(37.7,98.28)
  IN1 w0.089: v2(39.64,42.51) 40.08,42.51 40.17,42.42 40.17,42.24 40.08,42.15 39.85,42.15 39.76,42.06 39.76,41.9 39.84,41.82 40.4,41.82 40.49,41.91 40.49,42.77 40.37,42.89 40.16,42.89 40.07,42.98 40.07,43.11 40.16,43.2 40.36,43.2 40.45,43.29 40.45,43.41 40.36,43.5 40.16,43.5 40.07,43.59 40.07,43.72 40.16,43.81 40.36,43.81 40.45,43.9 40.45,44.02 40.36,44.11 39.86,44.11 38.94,45.04 38.94,47.17 38.56,47.55 38.56,52.5 38.69,52.63 38.88,52.63 38.97,52.72 38.97,52.85 38.88,52.94 38.66,52.94 38.59,53.01 38.59,53.14 38.67,53.23 38.88,53.23 38.98,53.33 38.98,53.46 38.9,53.53 38.67,53.53 38.59,53.62 38.59,53.78 38.66,53.86 38.7,53.86 38.78,53.94 38.78,54.16 38.68,54.26 38.68,54.36 38.98,54.65 38.98,54.75 39.06,54.84 39.34,54.84 39.39,54.89 39.39,55.13 v2(39.19,55.34) 39.19,55.97 38.37,56.79 38.37,60.4 38.74,60.77 39.58,60.77 39.69,60.87 39.69,61.03 39.58,61.14 38.92,61.14 38.82,61.24 38.82,61.38 38.92,61.48 39.56,61.48 39.66,61.58 39.66,61.73 39.56,61.83 38.95,61.83 38.86,61.92 38.86,62.04 38.95,62.13 39.52,62.13 39.62,62.24 39.62,62.38 39.52,62.48 39.27,62.48 39.15,62.61 39.15,62.79 39.6,63.24 39.6,64.07 39.1,64.57 39.1,71.36 38.22,72.24 38.22,76.81 v2(38.68,77.27) 38.53,77.42 38.53,77.73 38.44,77.82 38.25,77.82 38.16,77.91 38.16,78.03 38.25,78.12 38.44,78.12 38.53,78.21 38.53,78.34 38.44,78.43 38.25,78.43 38.16,78.52 38.16,78.64 38.25,78.73 38.44,78.73 38.53,78.82 38.53,78.95 38.44,79.04 38.25,79.04 38.16,79.13 38.16,79.25 38.25,79.34 38.44,79.34 38.53,79.43 38.53,81.38 38.21,81.7 38.21,84.17 38.24,84.2 38.24,89.76 38.33,89.85 38.9,89.85 38.99,89.94 38.99,90.3 38.9,90.38 38.58,90.38 38.49,90.47 38.49,90.71 38.62,90.84 38.97,90.84 39.06,90.93 39.06,91.3 38.95,91.42 38.77,91.42 v2(38.71,91.36)
  IN3 w0.089: 68.24,58.22 68.49,57.96 71.91,57.96 72.2,58.26 v2(72.2,58.96)
  IN3 w0.102: v1(37.7,98.28) 37.7,97.77 38.23,97.24 38.45,96.61 38.8,96.45 38.83,96.34 38.83,93.42 38.78,93.36 38.78,91.43 v2(38.71,91.36)
  IN3 w0.14: 68.24,58.22 68.05,58.41 66.97,58.41 66.44,57.87 61.21,57.87 60.72,58.36 59.29,58.36 58.7,57.77 56.52,57.77 56.44,57.84 50.4,57.84 49.07,59.17 47.34,59.17 46.56,59.95 46.06,59.95 45.45,60.55 42.07,60.55 40.37,58.86 40.37,58.43 40.29,58.35 40.02,58.35 39.88,58.21 39.88,58.01 39.99,57.89 40.53,57.89 40.68,57.75 40.68,57.21 40.56,57.09 39.99,57.09 39.89,56.99 39.89,56.75 39.99,56.65 40.54,56.65 40.63,56.56 40.63,56.37 40.47,56.22 39.75,56.22 39.66,56.13 39.66,55.89 39.76,55.79 40.4,55.79 40.52,55.66 40.52,55.49 40.4,55.36 39.9,55.36 39.73,55.18 39.73,53.85 40.57,53 40.57,49.95 41.21,49.31 42.66,49.31 43.68,48.3 43.68,48.1 43.52,47.94 40.24,47.94 39.41,47.11 39.41,45.8 39.78,45.43 42.21,45.43 43.07,44.57 43.07,43.32 43.6,42.79 43.6,40.39 44.16,39.83 44.16,37.58 43.72,37.15 41.34,37.15 40.57,37.91 40.57,41.34 40.19,41.72 39.83,41.72 39.64,41.92 v2(39.64,42.51)
  BOTTOM w0.076: U2030.BA42 75.25,59.11 75.11,58.97 75.1,58.97 75.1,58.96 74.85,58.84 73.72,58.84 73.66,58.9 73.28,58.9 72.93,58.56 72.61,58.56 v2(72.2,58.96)
M_B_PARITY: length 175.6
  TOP w0.102: U2009.T3 33.16,89.85 v2(33.16,89.39) ; U2011.T3 32.95,56.29 v2(32.7,56.05) ; v2(31.69,77.51) 32.52,77.51 32.71,77.7 U2010.T3
  TOP w0.165: v2(33.67,42.96) 33.67,42.55 33.77,42.45 34.01,42.45 34.27,42.72 U2012.T3 ; v2(33.16,89.39) 32.77,89.39 32.22,89.94 32.22,92.96 31.77,93.41 30.51,93.41 R2116.2
  IN1 w0.089: v2(33.67,42.96) 33.67,42.65 33.97,42.35 33.97,42.15 33.87,42.05 33.74,42.05 33.3,42.49 33.3,44.19 33.39,44.28 33.51,44.28 33.6,44.19 33.6,43.44 33.69,43.35 33.82,43.35 33.91,43.44 33.91,44.98 33.83,45.06 33.34,45.06 33.23,45.16 33.23,45.28 33.34,45.38 33.82,45.38 33.89,45.46 33.89,45.59 33.74,45.73 33.44,45.73 33.36,45.81 33.36,49.85 32.93,50.28 32.93,55.01 32.84,55.09 32.56,55.09 32.49,55.17 32.49,55.31 32.55,55.37 32.84,55.37 32.93,55.46 32.93,55.59 32.85,55.66 32.57,55.66 32.52,55.71 32.52,55.87 v2(32.7,56.05) 32.7,57.23 31.91,58.02 31.91,65.93 32.52,66.54 32.52,71.3 32.06,71.76 32.06,76.1 31.48,76.67 31.48,77.3 v2(31.69,77.51) 31.81,77.62 32.92,77.62 33.01,77.54 33.01,77.3 33.14,77.16 33.31,77.16 33.39,77.24 33.39,77.94 33.29,78.04 32.92,78.04 32.43,78.53 32.09,78.53 31.88,78.74 31.88,79.28 32.08,79.48 32.08,80.65 32.76,81.34 32.88,81.34 32.98,81.44 32.98,83.24 32.78,83.44 32.53,83.44 32.44,83.53 32.44,83.65 32.53,83.74 32.92,83.74 33.01,83.84 33.01,83.97 32.93,84.05 32.53,84.05 32.44,84.14 32.44,84.26 32.53,84.36 32.91,84.36 33,84.45 33,84.58 32.92,84.66 32.53,84.66 32.44,84.75 32.44,86.47 32.67,86.7 32.67,86.91 32.44,87.14 32.44,87.35 32.73,87.64 32.83,87.75 33.55,87.75 33.64,87.84 33.64,87.96 33.54,88.06 32.83,88.06 32.73,88.16 32.73,89.19 32.92,89.39 v2(33.16,89.39)
  IN3 w0.079: 77.28,61.33 78.47,61.33 78.47,61.32 79.68,61.32 v2(80.23,60.77)
  IN3 w0.14: v2(33.67,42.96) 33.67,43.49 32.85,44.31 32.85,45.47 31.98,46.35 31.98,51.11 32.26,51.4 32.26,52.86 32.42,53.02 32.72,53.02 32.84,53.14 32.84,53.42 32.76,53.5 32.59,53.5 32.47,53.62 32.47,53.79 32.84,54.15 32.84,55.44 32.62,55.66 32.1,55.66 31.9,55.85 31.9,56.05 32.55,56.7 32.55,57.05 33.09,57.59 33.32,57.59 33.44,57.48 33.6,57.48 33.72,57.59 33.72,57.93 33.99,58.21 33.99,58.49 34.23,58.73 34.4,58.73 34.58,58.55 35.12,58.55 35.37,58.8 35.37,59.24 38.44,62.31 39.04,62.31 40.57,63.83 50.23,63.83 50.47,64.07 50.71,64.07 50.91,63.87 50.91,63.51 51.07,63.35 51.77,63.35 51.85,63.44 51.85,63.61 51.98,63.74 52.23,63.74 52.35,63.62 52.35,62.79 52.48,62.66 53.1,62.66 53.21,62.77 53.21,63.28 53.31,63.39 53.54,63.39 53.63,63.29 53.63,62.77 53.73,62.66 54.1,62.66 54.83,63.39 56.24,63.39 56.35,63.28 56.35,63.06 56.45,62.96 56.66,62.96 56.78,63.08 56.78,63.72 56.9,63.84 57.08,63.84 57.2,63.72 57.2,63.08 57.32,62.96 57.5,62.96 57.62,63.08 57.62,63.72 57.74,63.84 57.92,63.84 58.04,63.72 58.04,63.08 58.16,62.96 58.33,62.96 58.46,63.08 58.46,63.72 58.58,63.84 58.75,63.84 58.88,63.72 58.88,63.08 59,62.96 59.17,62.96 59.3,63.08 59.3,63.72 59.42,63.84 59.59,63.84 59.71,63.72 59.71,63.08 59.84,62.96 60.01,62.96 60.13,63.08 60.13,63.72 60.26,63.84 60.43,63.84 60.55,63.72 60.55,63.08 60.68,62.96 60.85,62.96 60.97,63.08 60.97,63.72 61.09,63.84 61.27,63.84 61.39,63.72 61.39,63.08 61.51,62.96 61.69,62.96 61.81,63.08 61.81,63.72 61.93,63.84 62.11,63.84 62.23,63.72 62.23,63.08 62.35,62.96 62.53,62.96 62.65,63.08 62.65,63.72 62.77,63.84 62.94,63.84 63.07,63.72 63.07,63.08 63.19,62.96 63.36,62.96 63.49,63.08 63.49,63.72 63.61,63.84 63.78,63.84 63.91,63.72 63.91,63.08 64.03,62.96 64.2,62.96 64.32,63.08 64.32,63.72 64.45,63.84 64.62,63.84 64.74,63.72 64.74,63.08 64.87,62.96 65.04,62.96 65.14,63.06 65.14,63.33 65.25,63.45 65.43,63.45 65.59,63.29 65.59,63.01 65.64,62.96 65.92,62.96 66.56,62.33 68.41,62.33 69.25,61.49 73.56,61.49 73.69,61.35 73.69,60.52 73.82,60.39 73.99,60.39 74.13,60.53 74.13,61.7 74.26,61.83 74.49,61.83 74.59,61.73 74.59,60.5 74.71,60.39 74.89,60.39 75.02,60.51 75.02,61.71 75.13,61.83 75.28,61.83 75.45,61.65 75.45,60.64 75.56,60.53 75.77,60.53 75.88,60.64 75.88,61.47 76.01,61.6 76.22,61.6 76.32,61.5 76.32,60.81 76.45,60.68 76.63,60.68 76.75,60.81 76.75,61.41 76.87,61.53 77,61.53 77.2,61.33 77.28,61.33
  BOTTOM w0.102: U2030.AP43 79.81,60.13 80,59.95 80.07,59.95 80.16,60.03 80.16,60.7 v2(80.23,60.77)
MAIND: length 118.4
  TOP w0.102: v1(28.96,26.83) 28.96,28.19 28.1,29.04 28.1,30.09 27.21,30.97 27.21,32.52 27.49,32.8 27.49,33.92 28.09,34.51 PQ9.2 ; v1(105.01,40.45) 104.61,40.85 104.61,41.22 PR2060.2
  IN2 w0.089: v1(28.96,26.83) 29.93,25.86 30.27,25.86 31.46,24.67 41.67,24.67 42.3,24.04 43.67,24.04 44.21,24.57 46.01,24.57 v1(46.39,24.19) 46.79,23.79 48.52,23.79 49.16,23.15 52.06,23.15 54.04,21.17 64.43,21.17 66.13,22.87 74.64,22.87 75.91,24.14 77.28,24.14 78.04,23.38 81.13,23.38 82.53,24.78 91.59,24.78 91.69,24.68 93.62,24.68 93.82,24.48 93.83,24.48 93.84,24.47 94.69,24.47 94.98,24.18 v1(95.08,24.18)
  IN3 w0.089: v1(105.01,40.45) 104.53,40.45 103.69,39.61 103.69,37.71 103.92,37.48 104.06,37.48 104.46,37.08 104.46,35.46 104.77,35.15 104.77,34.02 104.93,33.86 104.93,33.07 103.99,32.13 103.68,32.13 102.45,30.9 102.45,28.61 102.94,28.12 102.94,27.5 101.64,26.2 101.04,26.2 99.63,24.79 95.93,24.79 95.33,24.18 v1(95.08,24.18)
  BOTTOM w0.102: PR59.2 52.97,19.14 53.2,19.37 PC51.1 51.81,19.89 51.35,20.35 PQ6.3 50.76,20.53 50.76,23.48 50.63,23.61 46.98,23.61 v1(46.39,24.19)
MAINON: length 360.5
  TOP w0.102: v1(28.09,27.55) 28.09,28.41 27.16,29.34 PR120.1 27.16,30.31 PQ16.2 25.31,29.91 PR6028.1 ; PR265.2 66.56,125.39 v1(66.36,125.59) ; v1(171.34,26.07) 171.34,24.98 171.8,24.51 171.8,22.67 175.16,19.32 175.16,18.41 175.42,18.15 176.59,18.15 176.82,17.92 PR9270.2 177.19,17.34 R890.1 178.5,16.32 180.05,16.32 180.21,16.48 180.21,16.81 180.68,17.28 181.77,17.28 182.48,16.58 U37.30 ; PR9268.2 159.48,25.74 159.63,25.59 160.23,25.59 160.53,25.29 v1(160.53,24.96) 160.92,24.57 162.2,24.57 163.51,25.89 PR6417.2
  IN1 w0.089: v1(66.36,125.59) 66.36,123.38 69.49,120.24 70.14,120.24 71.06,119.32 71.06,116.85 70.23,116.01 68.84,116.01 65.12,112.29 63.82,112.29 62.96,111.43 58.89,111.43 58.58,111.74 55.78,111.74 55.49,111.45 55.18,111.45 54.32,110.59 50.66,110.59 49.9,109.83 49.9,108.54 48.2,106.84 46.15,106.84 45.47,107.52 43.14,107.52 41.09,105.47 40.37,105.47 38.72,103.81 26.05,103.81 25.28,103.05 23.87,103.05 23.11,102.28 v1(22.54,102.28)
  IN2 w0.089: v1(28.09,27.55) 28.14,27.49 29.3,27.49 30.11,26.68 34,26.68 34.61,26.08 34.61,25.94 34.96,25.59 48.42,25.59 49.82,24.19 52.41,24.19 54.37,22.24 62.37,22.24 64.07,23.94 64.53,23.94 64.53,23.94 74.26,23.94 75.5,25.18 77.71,25.18 78.47,24.42 80.82,24.42 82.19,25.79 90.73,25.79 91.36,26.42 92.33,26.42 92.47,26.28 93.42,26.28 94.12,25.58 98.73,25.58 100.44,23.86 101.19,23.86 105.02,20.03 119.1,20.03 119.96,19.17 124.52,19.17 124.97,18.72 142.22,18.72 146.24,22.74 148.63,22.74 149.28,22.1 151.71,22.1 151.96,22.34 153.62,22.34 154.09,21.87 155.01,21.87 155.79,22.66 157.3,22.66 158.56,23.92 159.98,23.92 160.53,24.46 v1(160.53,24.96) 161.06,25.49 170.76,25.49 v1(171.34,26.07)
  BOTTOM w0.102: v1(22.54,102.28) 22.42,102.16 22.42,101.71 23.3,100.83 23.3,98.56 23.94,97.93 23.94,96.51 28.97,91.48 28.97,83.28 29.68,82.56 29.68,81.35 30.31,80.71 30.31,76.51 30.21,76.41 30.21,75.46 30.67,75 30.67,74.33 30.07,73.73 30.07,72.59 29.68,72.19 29.68,57.69 29.37,57.39 29.37,55.66 28.92,55.21 28.92,51.52 30.31,50.12 30.31,42.7 29.7,42.09 29.7,39.03 30.29,38.44 30.29,33.98 31.18,33.09 31.18,29.83 29.7,28.36 28.91,28.36 v1(28.09,27.55) ; PR6016.1 150.81,28.01 151.29,28.48 153.75,28.48 153.86,28.59 153.86,28.94 154.06,29.15 155.54,29.15 156.27,29.88 157.11,29.88 157.19,29.96 158.18,29.96 158.29,29.84 160.38,29.84 160.44,29.91 162.29,29.91 162.86,30.48 165.3,30.48 168.16,27.62 170.09,27.62 171.34,26.37 v1(171.34,26.07)
MAINON_ON_G: length 174.4
  TOP w0.102: v1(97.83,18.85) 98.53,19.54 100.42,19.54 101.89,21.02 103.34,21.02 104.63,22.31 104.63,23 105.21,23.57 PR116.2 106.63,23.57 107.33,24.27 107.33,25.51 107.71,25.9 v1(107.88,25.9) ; v1(8.72,22.82) 8.35,22.45 PR118.1 ; v1(21.55,8.22) 22.56,9.23 23.39,9.23 24.17,10.01 24.56,10.01 24.91,10.36 25.53,10.36 25.78,10.61 25.78,11.1 26.2,11.52 30.62,11.52 31.35,10.78 31.35,10.12 PQ12.2 ; PQ16.3 26.81,31.69 26.99,31.51 26.99,30.88 27.87,29.99 27.87,28.95 28.53,28.3 28.53,26.39 28.2,26.06 28.2,22.59 27.62,22.01 27.62,20.95 27,20.33 26.46,20.33 v1(25.78,19.65)
  IN1 w0.089: v1(21.55,8.22) 21.55,8.65 23.43,10.53 23.43,11.38 26.22,14.18 26.22,17.09 25.78,17.53 v1(25.78,19.65)
  IN2 w0.089: v1(48.58,20.56) 48.98,20.16 52.08,20.16 53.38,18.86 80.06,18.86 83.49,22.29 89.24,22.29 89.95,21.58 92.08,21.58 92.62,21.04 95.07,21.04 96.16,19.95 96.16,19.2 96.78,18.58 97.56,18.58 v1(97.83,18.85) ; v1(8.72,22.82) 9.53,22.01 11.42,22.01 12.08,21.35 v1(12.48,21.35) 12.48,21.1 13.79,19.79 15.61,19.79 16,20.18 20.62,20.18 21.28,19.52 21.46,19.52 21.92,19.06 23.04,19.06 23.11,19.13 23.93,19.13 24.15,18.91 24.78,18.91 25.52,19.65 v1(25.78,19.65) 27.07,19.65 27.34,19.38 28.79,19.38 29.53,18.65 v1(29.53,18.2)
  BOTTOM w0.102: v1(29.53,18.2) 30.49,18.2 30.87,18.58 30.87,20.9 30.97,21 37.61,21 39.56,22.95 49.39,22.95 PQ6.2 49.99,22.12 48.58,20.71 v1(48.58,20.56) ; PQ14.2 109.35,29.07 ; 109.35,29.07 109.21,29.21 107.85,29.21 107.61,29.45 107.61,29.93 107.28,30.26 106.82,30.26 PQ19.2 ; 109.35,29.07 109.35,28.76 109.17,28.59 108.51,28.59 108.27,28.35 108.27,27.96 108.49,27.74 108.49,27.41 107.88,26.8 v1(107.88,25.9) ; PQ9050.2 11.88,20.74 v1(12.48,21.35)
MBCLK: length 117.9
  TOP w0.102: R361.1 192.57,31.53 192.72,31.38 192.72,31.11 v2(192.72,31.11) 192.72,30.87 192.58,30.73 192.17,30.73 192.05,30.6 U37.110
  TOP w0.152: PR12.2 103.1,14.71 PC11.1 108.6,14.71 PD4.1 110.85,15.52 111.85,16.52 111.85,23.18 v1(112.03,23.35)
  IN3 w0.089: v1(112.03,23.35) 112.03,24.16 113.47,25.6 123.16,25.6 123.81,26.24 125.1,26.24 125.71,25.63 127.75,25.63 128.36,26.24 131.86,26.24 132.47,25.63 137.42,25.63 138.75,26.96 v1(138.85,26.96) 138.85,26.44 139.88,25.41 156.94,25.41 157.74,26.2 159.03,26.2 159.49,26.66 159.49,27.07 157.44,29.11 157.44,31.03 157.82,31.41 159.76,31.41 160.25,31.89 162.69,31.89 163.06,31.53 163.91,31.53 166.5,28.94 169.7,28.94 169.98,29.22 178.76,29.22 179.12,29.58 184.83,29.58 184.9,29.66 189.42,29.66 190.11,30.35 191.95,30.35 v2(192.72,31.11)
  BOTTOM w0.102: v1(138.85,26.96) 138.85,27.65 139.46,28.26 139.46,28.74 139.03,29.17 139.03,29.53 138.95,29.6 138.79,29.6 138.69,29.5 PR17.1
MBDATA: length 115.1
  TOP w0.102: R369.1 192.13,31.7 v2(192.13,31.11) 192.12,31.11 191.65,30.64 U37.111
  TOP w0.152: v1(111.39,23.33) 111.57,23.15 111.57,17.29 110.32,16.04 108.2,16.04 PD3.1
  TOP w0.305: PR13.2 105.79,16.18 PC10.1 106.41,15.35 106.73,15.68 107.83,15.68 PD3.1
  IN3 w0.089: v2(192.13,31.11) 191.56,30.54 190.03,30.54 189.34,29.85 184.83,29.85 184.75,29.77 179.04,29.77 178.68,29.41 169.91,29.41 169.62,29.13 166.58,29.13 163.99,31.72 163.14,31.72 162.77,32.09 160.17,32.09 159.68,31.6 157.74,31.6 157.25,31.11 157.25,29.03 159.29,26.99 159.29,26.73 158.95,26.39 157.66,26.39 156.86,25.6 139.96,25.6 139.3,26.25 v1(139.3,27.44) 138.76,27.44 137.15,25.82 132.55,25.82 131.94,26.43 128.28,26.43 127.67,25.82 125.79,25.82 125.18,26.43 123.73,26.43 123.09,25.79 113.28,25.79 111.39,23.91 v1(111.39,23.33)
  BOTTOM w0.102: v1(139.3,27.44) 139.3,27.54 139.74,27.97 139.74,28.76 139.2,29.3 139.2,29.65 139.08,29.78 138.79,29.78 138.69,29.88 PR19.1
MDI0+: length 16
  TOP w0.102: U24.1 41.56,106.8 41.3,107.06 39.34,107.06 39.04,106.75 39.04,106.36 v1(38.9,106.22)
  BOTTOM w0.102: U25.9 29.9,105.08 30.47,105.65 37.26,105.65 37.48,105.43 38.82,105.43 39.01,105.62 39.01,106.12 v1(38.9,106.22)
MDI0+_1: length 24.7
  IN1 w0.089: CN8.1 13.47,99.77 13.95,100.25 14.44,100.25 23.47,109.28 30.06,109.28 30.2,109.42 30.2,109.64 v1(30.06,109.78)
  BOTTOM w0.102: v1(30.06,109.78) 30.2,109.92 30.2,110.79 29.9,111.1 U25.16
MDI0-: length 16.1
  TOP w0.102: U24.2 41.4,106.4 41.13,106.67 39.51,106.67 39.43,106.59 39.43,106.46 v1(39.66,106.22)
  BOTTOM w0.102: U25.8 30.9,104.2 30.8,104.3 30.4,104.3 30.29,104.41 30.29,104.92 30.63,105.26 37.1,105.26 37.31,105.04 38.98,105.04 39.4,105.46 39.4,106.13 39.5,106.22 v1(39.66,106.22)
MDI0-_1: length 24.7
  IN1 w0.089: v1(30.7,109.78) 30.57,109.65 30.57,109.27 30.21,108.91 23.62,108.91 14.59,99.88 14.1,99.88 13.45,99.23 CN8.2
  BOTTOM w0.102: U25.17 30.9,111.11 30.6,110.81 30.6,109.88 v1(30.7,109.78)
MDI1+: length 17.9
  TOP w0.102: v1(27.01,104.41) 27.09,104.48 27.09,105.29 27.61,105.81 37.82,105.81 38.48,105.16 40.14,105.16 40.51,105.54 41.25,105.54 41.31,105.6 U24.4
  BOTTOM w0.102: U25.12 26.9,103.97 27.01,104.09 v1(27.01,104.41)
MDI1+_1: length 25.9
  TOP w0.102: CN8.3 14.18,97.73 14.29,97.63 14.29,97.14 14.59,96.84 14.97,96.84 15.17,97.04 15.17,100.99 23.22,109.03 26.92,109.03 27.2,109.32 27.2,109.75 v1(27.08,109.87)
  BOTTOM w0.102: U25.13 26.9,111.1 27.22,110.78 27.22,110.01 v1(27.08,109.87)
MDI1-: length 17.9
  TOP w0.102: U24.5 41.47,105.2 41.41,105.14 40.68,105.14 40.3,104.76 38.31,104.76 37.66,105.42 27.77,105.42 27.48,105.13 27.48,104.6 27.67,104.41 v1(27.77,104.41)
  BOTTOM w0.102: v1(27.77,104.41) 27.6,104.41 27.47,104.28 27.47,104.1 27.57,104 27.75,104 27.9,103.85 U25.11
MDI1-_1: length 25.9
  TOP w0.102: CN8.6 13.45,95.34 14.56,96.45 15.13,96.45 15.57,96.88 15.57,100.83 23.38,108.64 27.08,108.64 27.6,109.15 27.6,109.75 v1(27.72,109.87)
  BOTTOM w0.102: U25.14 27.9,110.98 27.62,110.7 27.62,109.97 v1(27.72,109.87)
MDI2+: length 8.7
  TOP w0.102: U24.6 42.02,104.79 41.45,104.79 41.44,104.79 41.12,104.79 40.17,103.85 36.92,103.85 36.54,104.23 36.54,104.56 36.59,104.61 v1(36.82,104.61)
  BOTTOM w0.102: v1(36.82,104.61) 36.56,104.61 36.46,104.5 36.46,104.33 36.9,103.89 U25.2
MDI2+_1: length 34.7
  IN1 w0.089: v1(36.68,109.52) 36.55,109.65 36.55,110.1 36.24,110.41 35.52,110.41 33.56,108.44 23.94,108.44 14.62,99.13 14.62,96.33 14.34,96.06 13.63,96.06 13.45,96.24 CN8.4
  BOTTOM w0.102: U25.23 36.9,110.96 36.55,110.61 36.55,109.65 v1(36.68,109.52)
MDI2-: length 8.7
  TOP w0.102: v1(36.06,104.61) 36.14,104.53 36.14,104.06 36.75,103.45 40.34,103.45 41.28,104.4 U24.7
  BOTTOM w0.102: U25.3 35.9,103.9 36.06,104.06 v1(36.06,104.61)
MDI2-_1: length 34.6
  IN1 w0.089: v1(36.04,109.52) 36.18,109.66 36.18,109.95 36.09,110.04 35.67,110.04 33.71,108.08 24.09,108.08 14.99,98.97 14.99,96.18 14.5,95.69 CN8.5
  BOTTOM w0.102: U25.22 35.9,110.96 36.16,110.71 36.16,109.64 v1(36.04,109.52)
MDI3+: length 13.8
  TOP w0.102: U24.9 42.74,103.29 42.74,102.69 41.69,101.64 41.69,101.08 v1(41.51,100.9)
  BOTTOM w0.102: U25.6 32.9,102.1 33.26,101.74 33.26,101.52 33.59,101.19 39.72,101.19 40.01,101.48 41.57,101.48 41.69,101.36 41.69,101.08 v1(41.51,100.9)
MDI3+_1: length 34.2
  IN3 w0.089: v1(33.09,109.54) 33.17,109.46 33.17,109.14 33.09,109.05 23.35,109.05 14.73,100.43 14.73,94.33 14.16,93.77 13.37,93.77 12.97,93.36 12.64,93.36 CN8.7
  BOTTOM w0.102: v1(33.09,109.54) 33.22,109.68 33.22,110.77 32.9,111.09 U25.19
MDI3-: length 13.8
  TOP w0.102: v1(42.27,100.9) 42.09,101.08 42.09,101.48 42.8,102.2 43.13,102.52 U24.10
  BOTTOM w0.102: v1(42.27,100.9) 42.09,101.08 42.09,101.52 41.73,101.88 39.85,101.88 39.56,101.59 33.76,101.59 33.65,101.69 33.65,101.88 33.9,102.12 U25.5
MDI3-_1: length 34.1
  IN3 w0.089: CN8.8 13.45,93.16 13.57,93.28 14.36,93.28 15.22,94.13 15.22,100.23 23.55,108.57 33.29,108.57 33.66,108.94 33.66,109.48 v1(33.72,109.54)
  BOTTOM w0.102: v1(33.72,109.54) 33.62,109.65 33.62,110.83 33.9,111.12 U25.20
ME_WR#: length 183.6
  TOP w0.102: v2(192.18,23.86) 192.39,24.06 192.39,24.93 191.35,25.97 191.35,27.48 191.15,27.69 191.15,28.41 191.67,28.93 192.33,28.93 192.45,29.05 U37.109 ; v2(61.61,46.72) 57.67,42.79 57.67,33.15 57.06,32.54 57.06,30.01 56.5,29.45 56.5,29.21 54.75,27.46 54.43,27.46 v2(54.01,27.04)
  IN2 w0.089: v2(192.18,23.86) 191.52,23.86 191.14,24.24 191.14,24.63 190.87,24.89 188.69,24.89 188.62,24.83 187.56,24.83 187.21,25.18 184.64,25.18 184.06,24.6 180.35,24.6 179.67,25.28 178.21,25.28 177.74,24.81 173.71,24.81 172.78,25.75 172.78,26.29 172.34,26.73 170.17,26.73 169.32,25.87 160.61,25.87 159.94,25.21 159.94,24.98 159.26,24.3 158.41,24.3 157.15,23.04 155.63,23.04 154.85,22.26 154.25,22.26 153.78,22.73 151.8,22.73 151.55,22.48 149.44,22.48 148.79,23.13 146.08,23.13 142.45,19.49 127.72,19.49 127.21,20 125.13,20 124.68,19.55 120.12,19.55 119.25,20.41 106.43,20.41 104.61,22.24 104.61,22.65 104.37,22.89 104,22.89 102.65,24.25 100.6,24.25 98.89,25.96 94.28,25.96 93.57,26.67 92.63,26.67 92.49,26.8 87.66,26.8 87.04,26.19 82.05,26.19 81.58,25.72 75.32,25.72 73.95,24.34 67.47,24.34 66.51,25.31 63.28,25.31 61.68,23.7 56.94,23.7 54.01,26.63 v2(54.01,27.04)
  BOTTOM w0.102: R2494.2 v2(61.61,46.72)
MEM_VREF_CTL_QA: length 3.4
  TOP w0.381: R25283.1 134.82,102.3 v1(134.63,102.11) 134.31,101.8 R411.1 Q20.3
MIC2-VREFO: length 11.9
  TOP w0.381: R471.1 R468.1 207.35,41.77 203.39,37.82 203.39,37.24 v1(203.65,36.98)
  BOTTOM w0.203: U20.29 204.06,36.57 v1(203.65,36.98)
MINICAR_PME#: length 20
  TOP w0.102: v1(168.46,16.8) 168.56,16.9 Q33.1
  BOTTOM w0.102: CN17.55 181.8,17.63 181.7,17.53 181.7,15.12 R651.2 181.22,14.4 180.94,14.11 171.16,14.11 v1(168.46,16.8)
MODEM_CLKREQ: length 90.9
  TOP w0.102: v1(147.56,27.78) 147.42,27.65 147.42,26.35 147.64,26.14 R679.2 147.86,25.46 147.97,25.36 147.97,22.16 148.51,21.62 U36.1 148.51,20.14 148.63,20.03 149.03,20.03 149.16,20.15 U36.2
  IN2 w0.089: v1(147.56,27.78) 147.35,27.58 147.35,26.43 146.34,25.41 144.3,25.41 143.44,24.55 133.13,24.55 131.52,26.16 127.45,26.16 126.72,26.89 126.28,26.89 125.83,26.43 112.7,26.43 107.76,31.37 106.28,31.37 105.89,31.76 105.89,32.09 105.54,32.45 105.54,34.01 104.98,34.57 103.85,34.57 102.97,33.69 101.11,33.69 99.94,34.86 98.3,34.86 97.32,35.84 96.38,35.84 95.77,35.22 92.38,35.22 91.33,34.18 90.15,34.18 89.8,33.84 87.84,33.84 87.41,33.41 86.83,33.41 85.84,34.4 85.42,34.4 83.85,35.97 83.5,35.97 82.02,37.46 82.02,40.45 81.72,40.75 v4(81.62,40.75)
  BOTTOM w0.102: U2030.AK9 81.73,40.69 81.68,40.69 v4(81.62,40.75)
