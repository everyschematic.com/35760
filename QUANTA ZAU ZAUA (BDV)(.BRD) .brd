# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SUSPWRDNACK: length 155.4
  TOP w0.102: U37.15 182.48,22.58 181.57,21.68 176.98,21.68 176.37,22.28 176.37,24.89 176.24,25.02 175.89,25.02 v1(175.58,25.34) ; v2(61.83,24.98) 61.83,26.33 62.19,26.68 62.19,27.82 61.28,28.74 59.86,28.74 59.24,29.36 59.24,31.46 60.56,32.78 60.56,37.91 60.92,38.26 61.66,38.26 R2608.1
  IN2 w0.089: v1(175.58,25.34) 175.09,25.82 173.51,25.82 172.42,26.92 170.09,26.92 169.25,26.07 160.54,26.07 159.75,25.29 159.75,25.06 159.18,24.49 158.33,24.49 157.07,23.23 155.55,23.23 155.44,23.12 154.25,23.12 154.05,22.92 151.72,22.92 151.47,22.67 149.51,22.67 148.87,23.32 145.62,23.32 143.68,21.38 137.31,21.38 136.23,22.46 132.24,22.46 131.05,23.65 127.77,23.65 127.43,23.31 121.96,23.31 120.26,21.61 108.46,21.61 105.62,24.45 104.39,24.45 102.77,26.07 101.15,26.07 100.6,26.63 99.05,26.63 98.77,26.35 94.43,26.35 93.73,27.05 92.79,27.05 92.62,27.21 87.51,27.21 86.87,26.57 81.89,26.57 81.45,26.12 76.59,26.12 75.53,27.19 75.53,28.47 73.2,30.8 70.78,30.8 70.39,30.41 69.93,30.11 69.81,29.98 69.81,29.98 65.57,25.74 62.87,25.74 62.11,24.98 v2(61.83,24.98)
PCH_SUSPWRDNACK_C: length 20.4
  TOP w0.079: 75.25,40.73 76.54,42.02 77.97,42.02 78.11,42.16 79.1,42.16 v4(79.42,42.47)
  TOP w0.102: 75.25,40.73 75.19,40.67 73.11,40.67 71.24,38.8 67.25,38.8 66.67,38.21 65.78,38.21 65.22,38.77 64.7,38.77 64.2,39.28 63.28,39.28 62.8,38.8 R2609.2 62.6,38.42 R2608.2
  BOTTOM w0.102: U2030.AR13 79.42,42.67 v4(79.42,42.47)
PCH_TYPEC_UPFB#: length 136.7
  TOP w0.102: v4(90.93,38.25) 91.2,37.99 91.2,36.89 91.83,36.26 92.72,36.26 93.88,35.1 95.03,35.1 95.41,34.71 96.46,34.71 96.84,34.32 96.84,34.09 96.96,33.97 97.87,33.97 97.9,33.94 99.33,33.94 100.88,32.38 100.88,30.54 100.77,30.43 100.77,28.43 100.8,28.4 100.8,28.01 100.8,27.52 100.46,27.18 99.87,27.18 98.77,26.07 R2588.1 98.77,24.21 R25480.2 98.54,24.01 98.13,23.61 98.13,22.72 97.65,22.24 95.85,22.24 94.74,21.13 94.74,19.87 v1(94.45,19.58)
  IN2 w0.089: v1(8.72,22.06) 9.18,22.06 9.42,21.82 11.34,21.82 13.69,19.48 13.69,19.12 14.11,18.69 16.83,18.69 17.14,18.39 19.78,18.39 20.19,18.8 21.23,18.8 21.64,18.39 22.71,18.39 23.33,17.77 24.24,17.77 24.45,17.56 25.57,17.56 26.12,18.11 26.12,18.71 26.38,18.97 26.8,18.97 26.96,18.81 26.96,18.37 27.45,17.88 28.27,17.88 29.38,16.77 29.38,13.71 28.81,13.15 28.81,10.85 30.04,9.62 38.05,9.62 43.39,14.96 43.99,14.96 45.97,16.94 64.11,16.94 65.33,15.71 78.31,15.71 83.87,21.27 88.68,21.27 91.02,18.93 93.8,18.93 v1(94.45,19.58)
  BOTTOM w0.102: Q6505.1 8.5,22.28 v1(8.72,22.06) ; v4(90.93,38.25) 90.96,38.25 91.12,38.41 U2030.L6
PCH_VRALERT#: length 17.6
  TOP w0.079: v4(81.62,41.96) 82.56,41.02 82.56,37.04 81.57,36.05 81.57,35.52
  TOP w0.102: 81.57,35.52 81.57,31.33 82.74,30.16 82.74,27.78 82.94,27.58 TP2051.1 82.9,27.05 R2304.1
  BOTTOM w0.102: U2030.AM11 81.58,42 v4(81.62,41.96)
PCI_PLTRST#: length 24.4
  TOP w0.079: v4(80.76,41.55) 80.54,41.32 80.54,40.53 80.24,40.24 80.03,40.24 78.38,38.59 78.04,38.59 77.73,38.28
  TOP w0.102: U2019.2 63.26,34.15 63.33,34.23 63.79,34.23 63.91,34.11 U2019.1 63.91,33.02 64.02,32.9 64.25,32.9 64.37,33.03 64.37,33.82 64.65,34.1 65.87,34.1 68.29,36.51 72.18,36.51 73.95,38.28 77.73,38.28
  BOTTOM w0.102: v4(80.76,41.55) 80.76,41.39 U2030.AN10
PCIE5_TXN: length 8.4
  BOTTOM w0.079: U2030.C19 96.07,46.47 96.12,46.42 96.5,46.42 96.59,46.38 96.83,46.38 96.93,46.42 97.16,46.42 97.27,46.38 98.24,46.38 98.97,45.65 99.26,45.65 99.28,45.67 99.3,45.67
  BOTTOM w0.102: 99.3,45.67 101.1,45.67 101.81,44.96 103.17,44.96 103.26,45.05 103.26,45.18 C2574.2
PCIE5_TXP: length 8.5
  BOTTOM w0.079: U2030.D19 96.06,46.26 96.47,46.26 96.56,46.22 96.86,46.22 96.97,46.27 97.13,46.27 97.24,46.22 98.18,46.22 98.9,45.49 99.26,45.49 99.28,45.47 99.3,45.47
  BOTTOM w0.102: 99.3,45.47 101.01,45.47 101.73,44.75 102.95,44.75 C2576.2
PCIE_CLKREQ_LAN#: length 151.8
  TOP w0.102: v2(28.45,69.08) 27.73,69.08 27.15,68.5 27.15,67.17 26.45,66.47 26.45,65.55 27.15,64.85 27.15,59.98 27.74,59.39 27.74,56.42 26.86,55.54 26.86,38.57 28.45,36.98 28.45,36.85 v1(29.02,36.28) ; R2305.1 62.19,36.56 60.92,35.29 60.92,32.73 59.93,31.74 v1(59.93,30.88) ; v1(47.89,96.89) 48.25,96.89 50.09,95.04 52.85,95.04 53.81,96 54.86,96 55.92,97.06 58.03,97.06 58.61,97.65 58.61,97.83 60.89,100.11 60.89,100.52 60.08,101.33 R25446.1 R25444.1 58.37,101.21 57.35,101.21 Q6531.3
  IN3 w0.089: v1(29.02,36.28) 29.02,36.03 31.95,33.1 31.95,31.9 33.79,30.05 47.69,30.05 48.13,29.61 52.95,29.61 53.38,30.03 55.26,30.03 55.59,29.7 56.3,29.7 57.29,30.69 59.75,30.69 v1(59.93,30.88) ; 30.03,97.85 29.63,97.85 28.5,96.72 28.5,88.7 28.21,88.41 28.21,87.2 27.96,86.94 27.96,83.79 30.12,81.62 30.12,78.71 29.53,78.11 29.53,76.34 28.87,75.68 28.87,74.92 29.81,73.98 29.81,70.43 v2(28.45,69.08)
  IN3 w0.102: 30.03,97.85 30.62,97.85 v1(31.1,98.33)
  BOTTOM w0.102: v1(31.1,98.33) 32.02,99.25 44.59,99.25 46.95,96.89 v1(47.89,96.89)
PCIE_CLKREQ_SSD#: length 80.9
  TOP w0.102: v1(59.9,30.26) 60.34,30.69 60.34,31.74 61.33,32.73 61.33,35.04 62.44,36.16 63.26,36.16 R2285.1
  IN1 w0.089: v1(26.99,3.26) 28.17,4.42 29.12,4.42 29.6,4.9 29.6,5.22 32.68,8.29 37.48,8.29 45.09,15.9 45.09,17.26 45.86,18.04 45.86,18.74 45.06,19.54 45.06,20.13 44.11,21.09 37.65,21.09 36.43,22.31 36.43,25.82 35.32,26.94 35.32,27.13 34.73,27.71 v1(34.73,28.26)
  IN3 w0.089: v1(34.73,28.26) 34.73,28.65 35.75,29.66 47.35,29.66 47.81,29.2 53.35,29.2 53.78,29.63 55.11,29.63 55.42,29.31 56.46,29.31 57.24,30.09 59.35,30.09 59.52,30.26 v1(59.9,30.26)
  BOTTOM w0.102: v1(26.99,3.26) 27.1,3.12 CN16.52
PCIE_CLKREQ_VGA#: length 228.4
  TOP w0.102: v1(61.53,31.66) 61.73,31.86 61.73,34.76 R226.1
  IN1 w0.089: v1(61.53,31.66) 61.44,31.75 59.49,31.75 56.37,28.64 55.92,28.64 54.79,27.5 54.64,27.5 54.63,27.5 54.62,27.5 54.54,27.42 54.27,27.42 53.89,27.57 53.73,27.68 53.65,27.76 52.88,27.76 52.54,27.42 47.2,27.42 46.19,26.4 39.46,26.4 39.21,26.65 39.21,27.26 38.52,27.95 37.1,27.95 35.27,29.78 33.06,29.78 31.08,31.76 31.08,32.4 27.81,35.67 27.81,36.39 24.27,39.92 24.27,42.34 24.7,42.77 24.7,52.49 24.35,52.84 24.35,60.05 24.83,60.54 24.83,64.91 26.15,66.23 26.15,67.2 25.42,67.93 25.42,72.03 24.65,72.81 24.65,74.17 24.22,74.59 24.22,76.21 22.51,77.92 22.51,79.55 20.89,81.17 20.89,83.25 18.19,85.95 18.19,87.15 17.62,87.72 v1(17.62,93.12)
  IN3 w0.089: v1(17.62,93.12) 17.08,93.66 17.08,95.97 17.92,96.81 17.92,98.84 25.34,106.27 32.29,106.27 33.3,107.28 35.1,107.28 38.14,110.32 38.14,112.45 37.83,112.76 36.26,112.76 35.62,113.4 35.62,113.8 38.91,117.09 41.31,117.09 41.95,116.45 42.42,116.45 43.59,117.61 43.59,122.81 43.79,123.02 49.32,123.02 50.55,124.24 50.55,125.6 51.32,126.37 76.41,126.37 78.59,124.19 85.09,124.19 89.21,120.07 93.24,120.07 94.94,121.77 v1(94.94,125.51)
  BOTTOM w0.102: R25487.1 95.18,121.21 94.83,121.56 94.83,122.67 94.85,122.69 94.85,125.43 v1(94.94,125.51) 95.18,125.27 95.35,125.27 95.51,125.12 96.49,125.12 96.58,125.22 Q9.3
PCIE_CLKREQ_WLAN#: length 126.9
  TOP w0.102: R2307.1 62.16,34.45 62.16,33.01 63.62,31.56 63.62,30.79 63.71,30.69 63.79,30.69 64.02,30.47 64.02,30.11 63.71,29.81 63.71,29.78 v1(63.56,29.63) ; v1(169.84,16.5) 169.98,16.64 170.65,16.64 v1(170.79,16.5) 172.89,16.5 Q63.3
  IN1 w0.089: v1(169.84,16.5) 169.09,17.24 168.3,17.24 167.55,16.49 154.9,16.49 154.53,16.86 153.68,16.86 153.55,16.98 153.17,16.98 153.05,16.86 151.62,16.86 151.14,17.33 141.9,17.33 141.27,17.96 139.52,17.96 138.46,16.9 131.11,16.9 130.79,17.22 122.98,17.22 122.58,17.61 119.33,17.61 119.07,17.87 109.79,17.87 109.35,18.3 97.06,18.3 94.89,20.46 93.1,20.46 92.12,21.45 91.49,22.08 91.49,22.49 90.59,23.39 83.01,23.39 81.57,21.96 70.88,21.96 66.77,26.07 66.77,27.79 65.02,29.54 64.03,29.54 63.94,29.63 v1(63.56,29.63)
PCIE_RCOMPN: length 1.4
  TOP w0.079: v4(94.23,38.79) 94.39,38.63 94.39,38.48 R2217.2
  BOTTOM w0.102: v4(94.23,38.79) 94.23,38.57 U2030.F5
PCIE_RCOMPP: length 1.5
  TOP w0.079: v4(94.86,38.79) 94.86,38.79 94.55,38.48 94.55,38.36 R2217.1
  BOTTOM w0.102: U2030.E5 94.65,38.59 v4(94.86,38.79)
PCIE_REQ_LAN#_R: length 30.3
  TOP w0.102: v1(61.94,103.41) 61.94,103.36 61.16,102.59 R25446.2 60.08,103.64 59.71,104.01 R25445.1 59.69,104.16 58.96,104.89 v1(58.51,104.89) 57.47,104.89 56.89,104.3 56.15,104.3 Q6531.1 ; U24.12 43.93,102.78 44.16,102.55 44.16,102.25 44.49,101.92 v1(44.49,101.66)
  IN1 w0.089: v1(61.94,103.41) 60.79,104.56 57.37,104.56 56.3,103.49 52.89,103.49 52.17,104.2 48.76,104.2 48.38,103.82 46.61,103.82 44.49,101.7 v1(44.49,101.66)
PCIE_RXN9_LAN: length 91.3
  TOP w0.102: v1(56.99,100.32) 57.19,100.32 57.3,100.2 57.3,99.85 57.14,99.68 55.86,99.68 55.32,100.21 52.81,100.21 v1(52.28,100.74) 51.75,100.21 50.95,100.21 C637.2
  IN3 w0.079: v4(93.67,44.25) 93.86,44.45 93.86,44.66 93.76,44.76 92.73,44.76 91.95,45.53 91.95,46.9 91.62,47.23 91.59,47.23 91.58,47.25
  IN3 w0.089: 91.58,47.25 90.51,48.31 90.51,50.52 90.36,50.68 90.36,51.69 90.16,51.9 90.16,58.47 89.29,59.34 89.29,75.59 89.57,75.87 89.57,81.82 87.49,83.91 87.49,84.54 84.63,87.4 84.35,87.4 83.72,88.02 83.15,88.02 82.61,88.56 81.05,90.13 79.89,90.13 78.37,91.65 78.37,92.43 77.58,93.22 76.79,93.22 74.42,95.59 64.54,95.59 63.21,96.93 63.21,98.05 62.22,99.03 57.95,99.03 57.31,99.67 57.31,100.21 57.21,100.32 v1(56.99,100.32)
  BOTTOM w0.102: U2030.F16 94,44.62 93.67,44.29 v4(93.67,44.25)
PCIE_RXN10_WLAN: length 111.2
  IN1 w0.089: v4(92.97,46.11) 93.18,45.91 93.18,45.74 93.18,45.43 93.83,44.78 94.34,44.78 94.65,44.47 94.65,44.12 94.91,43.87 94.91,43.33 96.35,41.88 96.35,41.2 97.67,39.89 98.08,39.89 99.97,38 99.97,36.98 101.36,35.6 101.61,35.6 102.55,34.66 102.96,34.66 103.27,34.34 104.7,34.34 105.04,34 106.51,34 108.75,31.76 110.16,31.76 110.36,31.56 119.37,31.56 123.04,27.9 123.04,27.44 124.22,26.26 125.08,26.26 125.67,25.67 131.98,25.67 132.68,24.97 145.11,24.97 145.6,25.46 149.08,25.46 150.48,26.86 150.94,26.86 151.57,26.22 152.72,26.22 153.12,25.82 156.9,25.82 158.36,27.28 159.17,27.28 159.63,26.83 166.58,26.83 167.11,26.3 169.89,26.3 170.24,26.65 172.05,26.65 172.93,25.77 176.65,25.77 177.31,26.43 180.77,26.43 180.96,26.25 180.96,26.07 v1(180.76,25.87)
  BOTTOM w0.102: U2030.G18 93.35,45.73 v4(92.97,46.11) ; v1(180.76,25.87) 181,25.63 181,24.69 180.16,23.85 180.16,21.49 180.87,20.77 182.35,20.77 182.49,20.63 CN17.43
PCIE_RXN13_SSD: length 90.8
  IN3 w0.089: v1(37.21,13.41) 37.21,13.02 37.49,12.74 38.43,12.74 45.79,20.1 50.3,20.1 50.38,20.03 64.07,20.03 64.79,20.75 67.35,20.75 68.68,22.08 75.93,22.08 78.32,24.47 79.97,24.47 80.35,24.85 81.75,24.85 82.49,25.59 85.05,25.59 88.67,29.21 89.3,29.21 89.62,29.53 89.62,29.86 92.82,33.06 92.82,33.19 96.05,36.42 96.05,36.79 96.63,37.38 96.63,39.11 99.5,41.98 99.5,43.39 99.05,43.84 96.91,43.84 95.24,45.52 95.24,45.96 95.33,46.05 95.33,48.15 95.13,48.34 94.97,48.34 94.4,48.91 v4(94.31,48.91)
  BOTTOM w0.102: U2030.E22 94.31,48.74 v4(94.31,48.91) ; R2652.1 38.8,11.54 38.7,11.64 38.7,12.19 38.47,12.42 37.82,12.42 37.21,13.03 v1(37.21,13.41)
PCIE_RXN13_SSD_C: length 1.6
  BOTTOM w0.102: CN16.5 38.85,10.35 38.71,10.49 38.71,10.82 R2652.2
PCIE_RXN14_SSD: length 94.1
  IN3 w0.089: v4(94.33,50.73) 94.58,50.48 94.58,49.85 95.97,48.45 95.97,47.31 96.58,46.7 96.58,45.48 97.62,44.44 99.29,44.44 100.1,43.63 100.1,41.92 97.12,38.94 97.12,37.19 96.65,36.72 96.65,35.98 96.32,35.66 94.37,33.71 94.37,33.26 94.13,33.03 93.63,33.03 90.23,29.63 90.23,29.09 89.72,28.59 88.91,28.59 85.32,24.99 82.74,24.99 82,24.26 80.62,24.26 80.22,23.86 78.57,23.86 76.19,21.47 69.11,21.47 67.78,20.15 65.08,20.15 64.36,19.43 50.14,19.43 50.08,19.49 46.09,19.49 42.43,15.83 42.43,15.3 41.64,14.51 41.1,14.51 38.05,11.47 36.07,11.47 35.66,11.88 35.66,12.01 35.76,12.11 v1(36.04,12.11)
  BOTTOM w0.102: R2654.1 35.77,11.54 35.67,11.64 35.67,12 35.78,12.11 v1(36.04,12.11) ; v4(94.33,50.73) 94,50.39 U2030.F25
PCIE_RXN14_SSD_C: length 1.6
  BOTTOM w0.102: R2654.2 35.71,10.82 35.71,10.49 35.85,10.35 CN16.17
PCIE_RXN15_SSD: length 102.6
  IN3 w0.089: v1(32.98,12.2) 32.82,12.2 32.65,12.03 32.65,11.42 33.29,10.78 38.28,10.78 41.38,13.88 41.87,13.88 43.06,15.07 43.06,15.62 46.33,18.88 49.21,18.88 49.66,18.43 50.03,18.43 50.43,18.83 64.6,18.83 65.32,19.55 69.34,19.55 69.73,19.95 69.73,20.54 70.06,20.86 76.44,20.86 77.81,22.24 77.83,22.24 78.84,23.25 80.48,23.25 80.88,23.66 82.25,23.66 82.99,24.4 86.52,24.4 88.3,26.18 88.3,26.99 89.29,27.98 90.35,27.98 93.55,31.18 94.37,31.18 94.77,31.58 94.77,32.32 95.06,32.6 95.06,33.55 95.75,34.24 96.03,34.52 96.81,34.52 97.13,34.84 97.24,34.95 97.24,36.53 97.65,36.93 97.65,37.59 98.18,38.12 98.18,39.32 100.7,41.84 100.7,43.92 100.08,44.54 100.08,44.54 99.58,45.04 97.87,45.04 97.18,45.73 97.18,47.08 96.57,47.69 96.57,48.63 96.22,48.98 96.22,51.01 96.07,51.16 94.72,51.16 94.56,51.32 v4(94.29,51.59)
  BOTTOM w0.102: R2656.1 32.81,11.54 32.7,11.65 32.7,12.08 32.82,12.2 v1(32.98,12.2) ; v4(94.29,51.59) 94.29,51.7 U2030.E28
PCIE_RXN15_SSD_C: length 1.6
  BOTTOM w0.102: R2656.2 32.71,10.82 32.71,10.49 32.85,10.35 CN16.29
PCIE_RXN16_SSD: length 108.1
  IN3 w0.089: v4(94.88,52.53) 95.05,52.36 95.08,52.33 96.11,52.33 97.06,51.37 97.06,49.31 97.55,48.83 97.55,47.97 97.98,47.53 97.98,46.71 98.85,45.84 100.6,45.84 101.5,44.94 101.5,41.65 98.97,39.12 98.97,37.15 98.66,36.84 98.66,35.48 98,34.83 98,34.58 96.15,32.73 96.15,31.29 95.7,30.85 95.17,30.85 94.7,30.38 93.88,30.38 90.64,27.14 90,27.14 89.52,26.66 89.52,25.91 87.2,23.6 83.32,23.6 82.58,22.86 81.24,22.86 80.82,22.44 79.8,22.44 78.04,20.68 78.04,20.03 76.69,18.68 65.6,18.68 64.95,18.03 50.78,18.03 50.38,17.63 49.31,17.63 48.87,18.07 46.65,18.07 43.93,15.35 43.93,14.77 42.24,13.08 41.71,13.08 38.6,9.97 30.58,9.97 29.42,11.13 29.42,12.08 v1(29.22,12.29)
  BOTTOM w0.102: R646.1 29.37,11.62 29.5,11.74 29.5,12.01 v1(29.22,12.29) ; U2030.E30 94.88,52.75 v4(94.88,52.53)
PCIE_RXN16_SSD_C: length 1.7
  BOTTOM w0.102: CN16.43 29.35,10.35 29.49,10.49 29.49,10.89 R646.2
PCIE_RXN_LAN_L: length 8.3
  TOP w0.102: C637.1 49.35,100.16 48.73,100.16 48.36,100.53 47.55,100.53 46.47,101.61 46.47,102.47 47.42,103.43 47.42,104.04 47.14,104.32 46.89,104.32 46.81,104.4 U24.18
PCIE_RXP9_LAN: length 91.3
  TOP w0.102: C640.2 50.7,99.71 50.99,100 51.73,100 v1(52.28,99.45) 52.83,100 55.23,100 55.77,99.47 57.23,99.47 57.52,99.76 57.52,100.08 v1(57.75,100.32)
  IN3 w0.079: 91.72,47.39 91.74,47.37 91.74,47.34 92.11,46.97 92.11,45.6 92.79,44.91 93.83,44.91 94.02,44.72 94.02,44.52 v4(94.26,44.29)
  IN3 w0.089: 91.72,47.39 90.9,48.21 90.71,48.4 90.71,50.61 90.56,50.76 90.56,51.78 90.36,51.98 90.36,58.56 89.5,59.42 89.5,75.51 89.77,75.79 89.77,81.91 87.69,83.99 87.69,84.63 84.72,87.6 84.43,87.6 83.81,88.23 83.24,88.23 81.13,90.33 79.97,90.33 78.57,91.73 78.57,92.51 77.66,93.43 76.88,93.43 74.51,95.79 64.63,95.79 63.41,97.01 63.41,98.13 62.3,99.24 58.04,99.24 57.52,99.76 57.52,100.08 v1(57.75,100.32)
  BOTTOM w0.102: v4(94.26,44.29) 94.26,44.35 94.65,44.74 U2030.E16
PCIE_RXP10_WLAN: length 111.1
  IN1 w0.089: v2(181.39,25.87) 181.21,25.87 181.16,25.92 181.16,26.33 180.86,26.63 177.23,26.63 176.57,25.97 173.02,25.97 172.14,26.85 170.16,26.85 169.81,26.5 167.19,26.5 166.66,27.04 159.71,27.04 159.26,27.49 158.28,27.49 156.81,26.02 153.21,26.02 152.8,26.43 151.66,26.43 151.03,27.06 150.39,27.06 148.99,25.66 145.51,25.66 145.02,25.17 132.76,25.17 132.06,25.87 125.76,25.87 125.17,26.47 124.3,26.47 123.24,27.53 123.24,27.98 119.46,31.77 110.44,31.77 110.25,31.96 108.83,31.96 106.6,34.2 105.13,34.2 104.78,34.55 103.36,34.55 103.04,34.86 102.64,34.86 101.7,35.8 101.44,35.8 100.18,37.07 100.18,38.08 98.16,40.09 97.75,40.09 96.56,41.29 96.56,41.96 95.11,43.41 95.11,43.95 94.85,44.21 94.85,44.55 94.42,44.99 93.91,44.99 93.38,45.52 93.38,45.74 93.38,46.03 93.45,46.11 v4(93.66,46.11)
  BOTTOM w0.102: U2030.F18 93.66,46 v4(93.66,46.11) ; CN17.41 182.45,21.13 182.3,20.99 180.96,20.99 180.38,21.58 180.38,23.76 181.21,24.6 181.21,25.82 181.27,25.87 v2(181.39,25.87)
PCIE_RXP13_SSD: length 90.8
  IN3 w0.089: v1(36.67,12.87) 37.07,12.87 37.41,12.53 38.51,12.53 45.88,19.9 50.22,19.9 50.3,19.82 64.15,19.82 64.87,20.54 67.43,20.54 68.77,21.88 76.02,21.88 78.4,24.27 80.05,24.27 80.44,24.65 81.84,24.65 82.57,25.39 85.13,25.39 88.75,29.01 89.39,29.01 89.83,29.44 89.83,29.78 93.03,32.98 93.03,33.11 96.25,36.33 96.25,36.71 96.84,37.29 96.84,39.03 99.71,41.9 99.71,43.47 99.13,44.05 96.99,44.05 95.44,45.6 95.44,45.88 95.53,45.97 95.53,48.23 95.22,48.54 95.06,48.54 94.97,48.63 v4(94.97,48.9)
  BOTTOM w0.102: v1(36.67,12.87) 37.06,12.87 37.73,12.2 38.38,12.2 38.49,12.1 38.49,11.64 38.38,11.54 R2653.1 ; U2030.E23 94.72,49.32 94.97,49.07 v4(94.97,48.9)
PCIE_RXP13_SSD_C: length 1.6
  BOTTOM w0.102: CN16.7 38.35,10.35 38.49,10.49 38.49,10.81 R2653.2
PCIE_RXP14_SSD: length 94.1
  IN3 w0.089: v1(35.25,12.11) 35.46,11.9 35.46,11.8 35.99,11.26 38.14,11.26 41.18,14.31 41.73,14.31 42.63,15.22 42.63,15.75 46.18,19.29 50,19.29 50.06,19.23 64.44,19.23 65.16,19.95 67.87,19.95 69.19,21.27 76.27,21.27 78.66,23.66 80.31,23.66 80.7,24.05 82.09,24.05 82.82,24.79 85.4,24.79 89,28.38 89.81,28.38 90.44,29.01 90.44,29.54 93.72,32.83 94.22,32.83 94.57,33.18 94.57,33.62 96.46,35.51 96.85,35.9 96.85,36.63 97.32,37.1 97.32,38.86 100.3,41.84 100.3,43.71 99.37,44.64 97.71,44.64 96.79,45.56 96.79,46.79 96.18,47.4 96.18,48.54 94.78,49.93 94.78,50.53 v4(94.94,50.69)
  BOTTOM w0.102: v4(94.94,50.69) 94.85,50.69 94.65,50.49 U2030.E25 ; v1(35.25,12.11) 35.46,11.9 35.46,11.78 R2655.1
PCIE_RXP14_SSD_C: length 1.6
  BOTTOM w0.102: CN16.19 35.35,10.35 35.49,10.49 35.49,10.81 R2655.2
PCIE_RXP15_SSD: length 102.6
  IN3 w0.089: v1(32.22,12.2) 32.45,11.97 32.45,11.33 33.2,10.58 38.36,10.58 41.46,13.68 41.95,13.68 43.27,14.99 43.27,15.54 46.41,18.68 49.13,18.68 49.58,18.23 50.11,18.23 50.51,18.63 64.69,18.63 65.41,19.35 69.42,19.35 69.94,19.87 69.94,20.46 70.14,20.66 76.52,20.66 77.9,22.03 77.91,22.03 78.93,23.05 80.56,23.05 80.97,23.46 82.33,23.46 83.07,24.19 86.6,24.19 88.5,26.1 88.5,26.9 89.38,27.77 90.44,27.77 93.64,30.97 94.46,30.97 94.98,31.5 94.98,32.23 95.26,32.51 95.26,33.47 95.89,34.1 96.11,34.32 96.89,34.32 97.28,34.7 97.45,34.87 97.45,36.44 97.85,36.85 97.85,37.5 98.39,38.04 98.39,39.24 100.9,41.75 100.9,44 100.28,44.62 99.66,45.24 97.95,45.24 97.38,45.81 97.38,47.17 96.77,47.77 96.77,48.71 96.43,49.06 96.43,51.09 96.16,51.36 95.14,51.36 v4(94.92,51.59)
  BOTTOM w0.102: U2030.E27 94.65,51.42 94.82,51.59 v4(94.92,51.59) ; R2657.1 32.32,11.54 32.49,11.7 32.49,11.93 v1(32.22,12.2)
PCIE_RXP15_SSD_C: length 1.6
  BOTTOM w0.102: CN16.31 32.35,10.35 32.49,10.49 32.49,10.82 R2657.2
PCIE_RXP16_SSD: length 108.2
  IN3 w0.089: v1(29.98,12.29) 29.76,12.29 29.63,12.15 29.63,11.21 30.67,10.17 38.51,10.17 41.62,13.28 42.15,13.28 43.72,14.85 43.72,15.44 46.56,18.27 48.96,18.27 49.4,17.84 50.3,17.84 50.7,18.24 64.87,18.24 65.52,18.88 76.61,18.88 77.84,20.11 77.84,20.76 79.72,22.64 80.73,22.64 81.15,23.06 82.5,23.06 83.23,23.8 87.12,23.8 89.32,26 89.32,26.74 89.92,27.34 90.56,27.34 93.8,30.58 94.62,30.58 95.09,31.05 95.62,31.05 95.95,31.38 95.95,32.81 97.8,34.67 97.8,34.91 98.46,35.56 98.46,36.92 98.77,37.23 98.77,39.2 101.29,41.73 101.29,44.85 100.51,45.63 98.77,45.63 97.78,46.63 97.78,47.45 97.34,47.88 97.34,48.75 96.86,49.23 96.86,51.28 96.02,52.12 94.62,52.12 v4(94.22,52.52)
  BOTTOM w0.102: R647.1 29.83,11.62 29.71,11.74 29.71,12.18 29.82,12.29 v1(29.98,12.29) ; U2030.F30 94.22,52.75 v4(94.22,52.52)
PCIE_RXP16_SSD_C: length 1.7
  BOTTOM w0.102: CN16.41 29.85,10.35 29.71,10.49 29.71,10.89 R647.2
PCIE_RXP_LAN_L: length 8.2
  TOP w0.102: U24.17 46.77,104 46.87,104.1 47.05,104.1 47.2,103.95 47.2,103.52 46.25,102.56 46.25,101.52 47.46,100.32 48.27,100.32 48.64,99.95 49.42,99.95 C640.1
PCIE_TXN9_LAN: length 116.5
  TOP w0.102: v1(59.06,100.37) 59.32,100.37 59.4,100.29 59.4,99.96 58.5,99.06 53.82,99.06 52.53,97.76 52.53,96.88 51.9,96.25 50.23,96.25 48.59,97.89 47.55,97.89 47.01,98.42 46.91,98.42 45.17,100.16 45.17,101.97 44.6,102.54 44.6,102.64 44.73,102.77 U24.14
  IN3 w0.089: v1(59.06,100.37) 59.37,100.37 59.42,100.32 59.42,99.9 59.69,99.63 64.49,99.63 67.93,96.19 74.67,96.19 77.04,93.82 78.16,93.82 79.08,92.9 79.28,92.9 80.91,91.27 80.91,91.11 83.4,88.62 83.97,88.62 84.59,88 84.88,88 88.11,84.77 88.11,84.17 90.13,82.16 90.13,59.77 91.6,58.3 93.13,58.3 94.12,59.29 94.55,59.29 94.86,58.97 95.48,58.97 96.62,60.11 98.22,60.11 99.89,58.44 99.93,58.4 99.93,53.4 101.46,51.88 102.14,51.88 103.3,50.71 104.28,50.71 104.61,50.38 104.61,50.15 105.89,48.87 106.42,48.87 106.79,48.49 106.79,46.98 106.5,46.69 v1(106.32,46.69)
  BOTTOM w0.102: v1(106.32,46.69) 106.52,46.69 106.61,46.6 106.61,46.29 106.42,46.1 105.56,46.1 105.24,45.78 104.81,45.78 104.06,45.03 103.61,45.03 103.54,45.1 C2574.1
PCIE_TXN10_WLAN: length 104
  IN1 w0.089: v1(105.67,47.18) 105.97,47.18 106.05,47.1 107.38,47.1 108.09,46.39 108.09,45.78 110.51,43.37 115.48,43.37 117.46,41.39 121.12,41.39 121.39,41.66 123.06,41.66 124.73,39.99 127.09,39.99 131.41,35.67 139.42,35.67 140.07,35.03 140.07,33.56 140.52,33.11 143.95,33.11 144.84,32.22 146.71,32.22 147.69,31.25 156.73,31.25 157.15,31.67 162.75,31.67 162.83,31.58 164.15,31.58 165.34,30.39 166.54,30.39 167.62,29.31 171.59,29.31 171.83,29.07 177.62,29.07 178,29.45 179.47,29.45 179.65,29.63 181.09,29.63 181.29,29.42 181.29,29.22 181.14,29.07 v2(181.12,29.07)
  BOTTOM w0.079: U2030.D20 95.98,47.21 96.28,46.91 96.52,46.91 96.79,47.19 98.16,47.19 99,46.35 99.79,46.35 99.81,46.33 99.83,46.33
  BOTTOM w0.102: v1(105.67,47.18) 105.67,47.44 105.6,47.51 104.81,47.51 104.46,47.15 102.59,47.15 102.26,46.82 101.94,46.82 101.45,46.33 99.83,46.33 ; v2(181.12,29.07) 181.24,29.07 181.41,28.9 181.41,27.56 182.03,26.93 182.03,24.8 181.13,23.91 181.13,23.22 181.03,23.12 C203.2
PCIE_TXN10_WLAN_C: length 3.1
  BOTTOM w0.102: C203.1 180.94,22.52 180.94,22.14 181.17,21.91 181.77,21.91 182,22.13 CN17.37
PCIE_TXN13_SSD: length 109.5
  TOP w0.102: v1(36.54,4.69) 36.38,4.84 36.38,5.6 C788.1
  IN3 w0.089: v1(98.97,50.02) 99.14,50.19 99.14,50.49 99.4,50.75 101.84,50.75 103.95,48.64 103.95,41.09 102.07,39.21 102.07,38.36 101.68,37.97 101.68,37.6 102.09,37.19 102.09,35.81 103.44,34.45 103.44,33.96 103.01,33.53 102.86,33.53 102.06,32.73 101.57,32.73 99.83,30.98 99.5,30.66 99.5,29.54 99.22,29.26 99.22,28.54 99.41,28.35 99.55,28.35 99.8,28.1 99.8,27.47 98.77,26.44 95.2,26.44 94.88,26.12 94.37,26.12 91.24,22.99 90.71,22.99 88.78,21.07 84.28,21.07 83.61,20.39 83.29,20.39 78.34,15.45 52.28,15.45 51.97,15.14 49.46,15.14 48.81,14.49 47.94,14.49 46.67,13.22 46.67,12.7 44.54,10.58 42.72,10.58 37.36,5.22 36.35,5.22 36.26,5.13 36.26,4.97 v1(36.54,4.69)
  BOTTOM w0.102: U2030.B23 97.15,49.54 98.92,49.54 98.99,49.62 98.99,49.99 v1(98.97,50.02)
PCIE_TXN13_SSD_C: length 4.3
  TOP w0.102: v1(36.52,7.46) 36.26,7.21 36.26,6.84 36.44,6.66 C788.2
  BOTTOM w0.102: CN16.11 37.35,8.7 37.21,8.56 37.21,8.27 36.98,8.04 36.35,8.04 36.24,7.94 36.24,7.73 v1(36.52,7.46)
PCIE_TXN14_SSD: length 110.7
  TOP w0.102: C790.1 34.33,5.74 34.33,4.84 v1(34.48,4.69)
  IN3 w0.089: v1(34.48,4.69) 34.2,4.97 34.2,5.52 34.78,6.11 37.4,6.11 42.48,11.19 44.31,11.19 46.06,12.94 46.06,14.07 47.74,15.75 51.74,15.75 52.05,16.06 77.86,16.06 82.79,20.99 83.36,20.99 84.05,21.68 88.44,21.68 90.97,24.2 91.6,24.2 93.86,26.46 93.86,26.58 94.78,27.49 95.9,27.49 96.3,27.89 96.3,28.78 96.39,28.87 97.15,28.87 98.16,29.87 98.16,31.58 98.69,32.12 98.85,32.27 99.94,32.27 101.16,33.49 102,33.49 102.37,33.86 102.37,34.53 101.46,35.44 101.46,36.16 101,36.62 101,37.95 101.56,38.51 101.56,39.41 103.36,41.22 103.36,47.71 102.25,48.82 101.33,48.82 100.9,49.25 100.9,49.85 v1(101.09,50.04)
  BOTTOM w0.079: 98.39,48.82 98.37,48.82 98.34,48.84 97.74,48.84 97.59,48.7 97.25,48.7 97.14,48.74 96.96,48.74 96.85,48.7 96.62,48.7 96.46,48.74 96.04,48.74 95.66,49.12 U2030.D23
  BOTTOM w0.102: v1(101.09,50.04) 100.9,49.85 100.9,49.52 100.2,48.82 98.39,48.82
PCIE_TXN14_SSD_C: length 3.4
  TOP w0.102: v1(34.48,7.66) 34.24,7.42 34.24,6.98 34.37,6.85 C790.2
  BOTTOM w0.102: v1(34.48,7.66) 34.21,7.93 34.21,8.33 34.35,8.47 CN16.23
PCIE_TXN15_SSD: length 113.7
  TOP w0.102: C792.1 31.41,5.85 31.41,5.17 v1(31.51,5.07)
  IN3 w0.089: v1(99.94,51.75) 99.76,51.56 99.76,51.3 99.49,51.03 98.98,51.03 98.44,50.49 98.44,49.89 100.06,48.26 102.06,48.26 102.78,47.54 102.78,41.29 100.92,39.43 100.92,38.59 100.49,38.16 100.49,36.27 100.9,35.86 100.9,34.63 99.17,32.9 98.63,32.9 97.53,31.81 97.53,30.1 96.9,29.46 96.14,29.46 95.85,29.16 95.44,29.16 93.21,26.94 92.86,26.94 88.21,22.29 83.81,22.29 83.11,21.59 82.07,21.59 77.16,16.67 51.81,16.67 51.49,16.35 48.54,16.35 48.16,16.73 47.22,16.73 45.27,14.79 45.27,13.63 43.43,11.78 42.24,11.78 38.74,8.29 32.95,8.29 32.57,7.91 32.57,6.99 31.35,5.77 31.35,5.22 v1(31.51,5.07)
  BOTTOM w0.102: U2030.D24 95.97,49.68 96.27,49.38 96.57,49.38 96.95,49.76 97.63,49.76 97.92,50.05 97.92,50.29 98.16,50.54 99.13,50.54 99.76,51.17 99.76,51.56 v1(99.94,51.75)
PCIE_TXN15_SSD_C: length 3.4
  TOP w0.102: C792.2 31.32,6.85 31.22,6.96 31.22,7.4 v1(31.48,7.66)
  BOTTOM w0.102: v1(31.48,7.66) 31.21,7.94 31.21,8.5 31.35,8.64 CN16.35
PCIE_TXN16_SSD: length 112.6
  TOP w0.102: C794.1 28.34,6.07 28.24,5.97 28.24,5.35 v1(28.51,5.07)
  IN3 w0.089: v4(98.54,51.74) 98.34,51.54 98.34,51.33 97.83,50.82 97.83,49.63 98.87,48.59 98.87,47.74 98.73,47.6 98.73,46.97 99.07,46.63 100.78,46.63 102.17,45.24 102.17,41.36 99.78,38.98 99.78,37.45 99.96,37.27 99.96,36 100.32,35.65 100.32,34.94 99.77,34.39 99.06,34.39 98.33,33.67 98.33,33.45 97.84,32.96 96.94,32.06 96.94,31.13 95.57,29.76 95.19,29.76 94.6,29.17 93.63,29.17 92.29,27.82 92.29,27.29 87.9,22.9 83.57,22.9 82.86,22.19 81.83,22.19 81.24,21.6 80.18,21.6 78.8,20.22 78.8,19.74 77.04,17.98 66.58,17.98 65.88,17.28 51.58,17.28 51.24,16.95 48.78,16.95 48.4,17.33 46.97,17.33 44.66,15.02 44.66,13.95 43.1,12.38 41.99,12.38 38.84,9.23 30.52,9.23 29.58,8.29 29.58,7.17 28.23,5.82 28.23,5.35 v1(28.51,5.07)
  BOTTOM w0.102: U2030.A25 97.37,50.49 98.13,51.25 98.13,51.34 98.23,51.44 98.39,51.44 98.54,51.58 v4(98.54,51.74)
PCIE_TXN16_SSD_C: length 3.4
  TOP w0.102: C794.2 28.3,6.85 28.23,6.93 28.23,7.41 v1(28.48,7.66)
  BOTTOM w0.102: v1(28.48,7.66) 28.21,7.94 28.21,8.5 28.35,8.64 CN16.47
PCIE_TXP9_LAN: length 116.5
  TOP w0.102: v1(59.83,100.37) 59.61,100.15 59.61,99.87 58.58,98.84 53.91,98.84 52.74,97.67 52.74,96.79 51.99,96.04 50.14,96.04 48.5,97.67 47.46,97.67 46.92,98.21 46.82,98.21 44.96,100.07 44.96,101.88 44.38,102.45 44.38,102.7 44.33,102.76 U24.13
  IN3 w0.089: v1(107.09,46.69) 107,46.78 107,48.58 106.5,49.07 105.98,49.07 104.81,50.23 104.81,50.46 104.36,50.91 103.39,50.91 102.22,52.08 101.54,52.08 100.14,53.49 100.14,58.48 100.04,58.58 98.3,60.31 96.54,60.31 95.4,59.18 94.95,59.18 94.63,59.49 94.03,59.49 93.04,58.5 91.69,58.5 90.33,59.85 90.33,82.24 88.32,84.26 88.32,84.85 84.97,88.2 84.68,88.2 84.06,88.82 83.49,88.82 81.11,91.2 81.11,91.35 79.36,93.1 79.17,93.1 78.24,94.02 77.12,94.02 74.76,96.39 68.01,96.39 64.57,99.83 59.78,99.83 59.62,99.99 59.62,100.17 v1(59.83,100.37)
  BOTTOM w0.102: v1(107.09,46.69) 106.83,46.43 106.83,46.2 106.51,45.88 105.65,45.88 105.33,45.57 104.9,45.57 104.15,44.81 103.74,44.81 C2576.1
PCIE_TXP10_WLAN: length 104
  IN1 w0.089: v2(181.75,29.07) 181.49,29.33 181.49,29.51 181.17,29.83 179.56,29.83 179.39,29.65 177.91,29.65 177.53,29.27 171.92,29.27 171.68,29.51 167.7,29.51 166.62,30.59 165.42,30.59 164.23,31.79 162.92,31.79 162.83,31.87 157.06,31.87 156.64,31.45 147.78,31.45 146.8,32.43 144.92,32.43 144.04,33.31 140.61,33.31 140.27,33.65 140.27,35.12 139.51,35.88 131.49,35.88 127.17,40.19 124.81,40.19 123.14,41.86 121.31,41.86 121.03,41.59 117.55,41.59 115.56,43.57 110.59,43.57 108.3,45.87 108.3,46.47 107.46,47.31 106.13,47.31 105.67,47.77 v1(105.67,47.96)
  BOTTOM w0.079: U2030.C20 96.21,47.21 96.15,47.26 96.15,47.37 96.29,47.51 96.56,47.51 96.72,47.34 98.23,47.34 99.06,46.51 99.79,46.51 99.81,46.53 99.83,46.53
  BOTTOM w0.102: 99.83,46.53 101.36,46.53 101.86,47.03 102.17,47.03 102.5,47.36 103.36,47.36 103.38,47.37 104.37,47.37 104.72,47.73 105.44,47.73 v1(105.67,47.96) ; v2(181.75,29.07) 181.62,28.94 181.62,27.65 182.24,27.02 182.24,24.71 181.35,23.82 181.35,23.27 C202.2
PCIE_TXP10_WLAN_C: length 3
  BOTTOM w0.102: CN17.35 182.52,22.63 182.24,22.35 181.91,22.35 181.68,22.12 181.26,22.12 181.15,22.23 181.15,22.55 181.27,22.67 C202.1
PCIE_TXP13_SSD: length 109.5
  TOP w0.102: C789.1 36.08,5.88 36.17,5.79 36.17,4.93 35.93,4.69 v1(35.77,4.69)
  IN3 w0.089: v1(35.77,4.69) 35.86,4.69 36.05,4.89 36.05,5.21 36.26,5.42 37.27,5.42 42.63,10.78 44.46,10.78 46.47,12.79 46.47,13.3 47.86,14.69 48.73,14.69 49.38,15.34 51.88,15.34 52.2,15.66 78.26,15.66 83.2,20.6 83.52,20.6 84.2,21.27 88.7,21.27 90.62,23.19 91.15,23.19 94.28,26.33 94.8,26.33 95.11,26.64 98.69,26.64 99.6,27.55 99.6,28.02 99.47,28.15 99.33,28.15 99.02,28.45 99.02,29.35 99.3,29.63 99.3,30.74 99.68,31.13 101.49,32.93 101.98,32.93 102.78,33.73 102.92,33.73 103.24,34.05 103.24,34.37 101.88,35.72 101.88,37.1 101.47,37.51 101.47,38.06 101.87,38.45 101.87,39.3 103.74,41.18 103.74,48.56 101.75,50.55 99.49,50.55 99.34,50.4 99.34,50.16 99.49,50.02 v1(99.6,50.02)
  BOTTOM w0.102: U2030.A23 97.37,49.27 97.45,49.34 99,49.34 99.19,49.53 99.19,49.65 99.3,49.75 99.54,49.75 99.6,49.81 v1(99.6,50.02)
PCIE_TXP13_SSD_C: length 4.3
  TOP w0.102: v1(35.76,7.46) 36.05,7.17 36.05,6.84 35.87,6.66 C789.2
  BOTTOM w0.102: CN16.13 36.85,8.71 36.98,8.59 36.98,8.34 36.89,8.25 36.26,8.25 36.03,8.03 36.03,7.73 v1(35.76,7.46)
PCIE_TXP14_SSD: length 110.7
  TOP w0.102: v1(33.72,4.69) 34.11,5.09 34.11,5.99 34.03,6.07 C791.1
  IN3 w0.089: v1(33.72,4.69) 34,4.97 34,5.61 34.7,6.31 37.32,6.31 42.4,11.39 44.22,11.39 45.86,13.02 45.86,14.16 47.66,15.96 51.65,15.96 51.96,16.27 77.78,16.27 82.71,21.2 83.27,21.2 83.96,21.88 88.36,21.88 90.88,24.4 91.52,24.4 93.66,26.55 93.66,26.66 94.69,27.7 95.82,27.7 96.1,27.98 96.1,28.86 96.31,29.07 97.06,29.07 97.95,29.96 97.95,31.66 98.55,32.26 98.76,32.47 99.86,32.47 101.08,33.69 101.92,33.69 102.17,33.94 102.17,34.45 101.26,35.36 101.26,36.08 100.8,36.54 100.8,38.03 101.36,38.59 101.36,39.5 103.16,41.3 103.16,47.63 102.17,48.62 101.25,48.62 100.7,49.17 100.7,49.9 100.57,50.03 v1(100.25,50.03)
  BOTTOM w0.079: 98.39,49.02 98.37,49.02 98.34,49 97.68,49 97.53,48.85 97.28,48.85 97.16,48.9 96.93,48.9 96.82,48.85 96.64,48.85 96.48,48.9 96.15,48.9 96.07,48.98 U2030.C23
  BOTTOM w0.102: 98.39,49.02 100.11,49.02 100.7,49.61 100.7,49.9 100.57,50.03 v1(100.25,50.03)
PCIE_TXP14_SSD_C: length 3.4
  TOP w0.102: C791.2 33.92,6.85 34.02,6.95 34.02,7.36 v1(33.72,7.66)
  BOTTOM w0.102: v1(33.72,7.66) 33.99,7.93 33.99,8.33 33.85,8.47 CN16.25
PCIE_TXP15_SSD: length 113.7
  TOP w0.102: v1(30.75,5.07) 30.88,5.07 31.2,5.39 31.2,5.92 31.04,6.07 C793.1
  IN3 w0.089: v1(99.25,51.75) 99.43,51.75 99.55,51.63 99.55,51.39 99.4,51.23 98.89,51.23 98.23,50.57 98.23,49.8 99.98,48.06 101.97,48.06 102.58,47.46 102.58,41.37 100.72,39.51 100.72,38.67 100.29,38.25 100.29,36.18 100.7,35.77 100.7,34.71 99.09,33.1 98.54,33.1 97.33,31.89 97.33,30.18 96.82,29.67 96.06,29.67 95.76,29.37 95.36,29.37 93.13,27.14 92.77,27.14 88.12,22.49 83.73,22.49 83.03,21.79 81.99,21.79 77.07,16.88 51.73,16.88 51.41,16.55 48.62,16.55 48.24,16.93 47.13,16.93 45.07,14.87 45.07,13.71 43.35,11.99 42.15,11.99 38.66,8.5 32.87,8.5 32.37,8 32.37,7.07 31.15,5.85 31.15,5.27 30.95,5.07 v1(30.75,5.07)
  BOTTOM w0.102: v1(99.25,51.75) 99.43,51.75 99.55,51.62 99.55,51.26 99.04,50.74 98.08,50.74 97.71,50.37 97.71,50.14 97.54,49.97 96.87,49.97 96.59,49.68 U2030.C24
PCIE_TXP15_SSD_C: length 3.4
  TOP w0.102: C793.2 30.9,6.85 31,6.95 31,7.38 v1(30.72,7.66)
  BOTTOM w0.102: CN16.37 30.85,8.64 30.99,8.5 30.99,7.94 v1(30.72,7.66)
PCIE_TXP16_SSD: length 112.7
  TOP w0.102: C795.1 27.91,6.07 28.02,5.96 28.02,5.35 v1(27.75,5.07)
  IN3 w0.089: v4(97.93,51.76) 98.13,51.56 98.13,51.41 97.62,50.91 97.62,49.55 98.66,48.51 98.66,47.82 98.52,47.68 98.52,46.88 98.98,46.42 100.7,46.42 101.97,45.16 101.97,41.45 99.58,39.06 99.58,37.37 99.76,37.19 99.76,35.92 100.11,35.56 100.11,35.02 99.69,34.6 98.98,34.6 98.13,33.75 98.13,33.54 97.7,33.11 96.73,32.14 96.73,31.21 95.49,29.96 95.11,29.96 94.51,29.37 93.55,29.37 92.09,27.91 92.09,27.37 87.82,23.1 83.49,23.1 82.78,22.39 81.74,22.39 81.16,21.8 80.1,21.8 78.6,20.31 78.6,19.82 76.96,18.18 66.49,18.18 65.8,17.49 51.49,17.49 51.16,17.15 48.87,17.15 48.49,17.53 46.89,17.53 44.46,15.11 44.46,14.03 43.01,12.58 41.9,12.58 38.75,9.43 30.43,9.43 29.37,8.38 29.37,7.25 28.03,5.9 28.03,5.35 v1(27.75,5.07)
  BOTTOM w0.102: v4(97.93,51.76) 97.93,51.33 96.85,50.25 U2030.B25
PCIE_TXP16_SSD_C: length 3.4
  TOP w0.102: v1(27.72,7.66) 28.01,7.37 28.01,6.93 27.94,6.85 C795.2
  BOTTOM w0.102: CN16.49 27.85,8.62 27.99,8.48 27.99,7.94 v1(27.72,7.66)
PCIE_WAKE#: length 377.7
  TOP w0.102: Q33.3 168.97,16.37 167.64,16.37 EC13.1 168.13,17.3 168.13,18.15 168.28,18.3 168.9,18.3 169.23,18.63 169.23,21.6 169.4,21.78 169.4,24.12 168.82,24.7 168.82,29.22 169.3,29.7 v1(169.3,31.18) ; R513.1 50.53,105.31 v1(50.53,105.75)
  IN1 w0.089: v1(102.55,67.22) 100.72,65.39 100.72,63.62 102.45,61.89 102.45,58.34 100.58,56.48 100.58,55.4 100.98,55 102.27,55 102.8,54.47 102.8,54.09 103.68,53.21 104.75,53.21 106.03,51.93 106.94,51.93 108.43,50.44 109.14,50.44 113.74,45.84 116.77,45.84 117.42,45.2 119.89,45.2 120.57,44.52 121.35,44.52 121.75,44.11 124.33,44.11 124.57,43.87 134.6,43.87 134.78,43.7 136.61,43.7 137,44.09 138.94,44.09 139.34,44.49 142.38,44.49 143.86,43.01 143.86,38.3 147.01,35.15 147.25,35.15 148.71,33.7 155.03,33.7 156.53,35.2 158.94,35.2 159.54,34.6 159.54,34.06 159.72,33.88 163.09,33.88 163.53,33.45 165.06,33.45 166.21,32.31 168.17,32.31 v1(169.3,31.18) ; v2(89.1,101.69) 88.97,101.82 88.71,101.82 88.15,102.37 85.28,102.37 84.49,101.58 84.49,101.2 83.99,100.7 78.51,100.7 77.29,101.92 76.48,101.92 76.19,101.64 70.33,101.64 68.47,103.5 65.7,103.5 65.45,103.74 63.44,103.74 61.45,105.73 60.06,105.73 59.83,105.95 59.83,106.34 61.01,107.53 62.67,107.53 62.92,107.78 62.92,108.68 61.78,109.82 59.02,109.82 57.55,111.28 57,111.28 56.84,111.12 56.84,109.15 56.06,108.37 55.51,108.37 55.28,108.14 55.28,108.09 55.23,108.04 54.39,108.04 54.04,107.68 53.4,107.68 53.26,107.54 51,107.54 50.53,107.07 v1(50.53,105.75) 50.53,105.52 50.02,105.01 46.14,105.01 44.89,103.75 42.47,103.75 42.34,103.88 40.35,103.88 39.52,103.05 26.63,103.05 25.5,101.91 v1(24.21,101.91) ; v1(37.92,26.9) 39.15,25.67 46.49,25.67 47.51,26.68 53.07,26.68 v2(53.43,27.04)
  IN3 w0.089: v2(89.1,101.69) 89.12,101.67 89.21,101.67 89.98,100.91 89.98,99.36 91.51,97.83 91.51,96.68 92.82,95.37 92.82,94.55 93.51,93.86 93.51,92.81 97.99,88.34 97.99,84.58 98.88,83.69 99.54,83.69 100.93,82.3 100.93,80.1 100.21,79.39 100.21,77.49 102.16,75.54 102.16,71.23 101.92,70.98 101.92,70.24 101.69,70.01 101.69,69.51 101.56,69.38 101.56,68.24 101.76,68.03 101.76,68.01 v1(102.55,67.22)
  BOTTOM w0.079: 73.72,44.33 74.64,44.33 U2030.BB15
  BOTTOM w0.102: v2(53.43,27.04) 53.88,26.58 55.35,26.58 55.91,27.14 62.42,27.14 64.55,29.27 64.55,30.97 64.22,31.3 64.22,34.46 64.15,34.54 64.15,37.56 65.38,38.8 65.76,38.8 66.22,39.25 67.22,39.25 67.44,39.48 R2519.1 67.44,39.88 71.42,43.85 73.14,43.85 73.62,44.33 73.72,44.33 ; v1(24.21,101.91) 24.01,101.71 24.01,99.2 24.75,98.46 24.75,96.83 29.68,91.9 29.68,87.05 30.59,86.14 31.09,86.14 31.53,85.7 31.53,84.05 32.65,82.93 32.65,79.21 33.74,78.11 33.74,72.95 33.13,72.34 33.13,71.66 33.39,71.41 33.39,69.97 32.27,68.86 32.27,58.37 34.76,55.88 34.76,53.06 34.1,52.4 34.1,51.91 33.29,51.1 33.29,50.34 34.1,49.53 34.1,39.51 33.46,38.87 33.46,36.18 36,33.64 36,31.89 37.65,30.24 37.65,28.66 37.92,28.4 v1(37.92,26.9)
PCIE_WAKE#_R: length 3.4
  TOP w0.102: U24.21 47.33,105.6 47.41,105.52 48.29,105.52 v1(48.47,105.34) 48.85,104.96 R513.2
PD#: length 25.5
  TOP w0.102: R478.2 211.37,28.37 v1(212.28,29.27) ; v1(212.43,24.5) 212.13,24.2 D12.2 211.3,24.04 209.61,24.04 208.97,23.39 208.97,23.22 208.75,23 208.04,23 207.66,23.38 207.66,23.51 207.03,24.13 205.54,24.13 205.01,23.61 205.01,22.49 204.2,21.67 D13.2
  IN1 w0.089: v1(212.43,24.5) 211.72,25.21 211.72,28.71 v1(212.28,29.27)
  BOTTOM w0.102: U20.47 208.31,30.82 208.47,30.67 208.47,29.96 208.65,29.78 210.69,29.78 R479.1 C595.1 212.28,29.44 v1(212.28,29.27)
PEDET: length 18
  TOP w0.102: Q34.2 12.44,6.32 12.63,6.51 13.43,6.51 13.89,6.06 14.29,6.06 14.82,5.52 14.82,4.51 15.48,3.85 16.87,3.85 v1(17.76,4.74) 18.9,5.88 21.62,5.88 22.36,6.62 22.87,6.62 22.95,6.7 R649.2 22.64,7.47 R654.2 22.64,7.95 v1(22.93,8.24)
  BOTTOM w0.102: CN16.69 22.85,8.32 v1(22.93,8.24)
PEG_RXN5: length 94.4
  TOP w0.102: C358.2 100.65,121.37 100.51,121.5 100.51,121.77 100.29,121.99 99.22,121.99 98.56,121.34 98.56,121.02 98.48,120.94 98.48,120.74 v1(98.28,120.54)
  IN1 w0.079: v4(93.05,42.47) 93.27,42.69 93.27,42.79 93.17,42.89 91.96,42.89 91.16,42.09 90.77,42.09 90.36,42.5 90.36,43.61 90.18,43.79 90.18,48.3 89.9,48.58 89.9,48.78 89.88,48.8 89.88,48.83
  IN1 w0.089: v1(98.28,120.54) 98.47,120.35 98.47,119.9 95.55,116.98 95.14,116.98 92.78,114.63 92.78,103.03 92.33,102.58 92.33,100.8 92.21,100.68 92.21,99.26 90.57,97.62 90.57,95.58 90.34,95.36 90.34,93.42 90.81,92.95 90.81,91.79 89.27,90.24 89.27,88.35 88.14,87.23 88.14,83.82 87.77,83.45 87.77,81.4 87.26,80.89 87.26,76.07 87.1,75.9 87.1,74.63 86.73,74.26 86.73,70.76 86.45,70.49 86.45,69.54 87.03,68.96 87.03,58.44 86.23,57.63 86.23,54.41 87.69,52.94 87.69,51.95 88.28,51.36 88.28,50.92 89.88,49.31 89.88,48.83
  BOTTOM w0.102: v4(93.05,42.47) 92.7,42.82 U2030.H13
PEG_RXN5_C: length 13.5
  TOP w0.102: v2(100.49,110.81) 100.73,111.05 100.95,111.05 101.12,111.22 101.12,112.06 98.11,115.07 98.11,116.8 100.5,119.19 100.5,120.52 C358.1
  BOTTOM w0.102: U8.AB9 v2(100.49,110.81)
PEG_RXN6: length 100.7
  TOP w0.102: C384.2 101.45,119.46 101.55,119.57 101.55,121.72 100.86,122.4 99.05,122.4 98.28,121.63 97.95,121.63 97.59,121.26 97.59,120.65 96.07,119.13 96.07,118.82 96.28,118.6 v1(96.45,118.6)
  IN1 w0.079: v4(93.64,41.56) 93.8,41.56 93.91,41.44 93.91,41.22 93.8,41.11 93.27,41.11 93.13,41.25 93.13,41.62 92.7,42.05 92.18,42.05 91.71,41.58 90.85,41.58 90.05,42.38 90.05,42.49 89.22,43.33 89.22,48.8 89.24,48.82 89.24,48.83
  IN1 w0.089: v1(96.45,118.6) 96.18,118.6 96.08,118.5 96.08,118.07 95.46,117.45 95.06,117.45 92.39,114.79 92.39,103.2 91.93,102.74 91.93,101 91.75,100.81 91.75,99.36 90.18,97.79 90.18,95.75 89.95,95.52 89.95,91.48 88.41,89.94 88.41,88.08 87.11,86.79 87.11,86.08 87.69,85.5 87.69,83.93 87.37,83.61 87.37,81.47 86.75,80.85 86.75,74.87 85.8,73.91 85.8,71.07 86.12,70.75 86.12,69.1 86.06,69.04 86.06,52.16 89.24,48.98 89.24,48.83
  BOTTOM w0.102: U2030.G11 93.4,42.06 93.55,42.06 93.72,41.88 93.72,41.64 v4(93.64,41.56)
PEG_RXN6_C: length 9.6
  TOP w0.102: v2(102.12,111.62) 102.19,111.68 102.19,111.82 102.02,111.98 102.02,112.5 101.37,113.15 101.37,117.62 101.55,117.8 101.55,118.92 101.46,119.01 C384.1
  BOTTOM w0.102: U8.AC10 101.48,111.23 101.41,111.31 101.41,111.45 101.57,111.62 v2(102.12,111.62)
PEG_RXN7: length 90.1
  TOP w0.102: C6554.2 102.96,121.37 102.84,121.49 102.84,121.79 v1(103.09,122.04)
  IN1 w0.079: v4(92.41,44.29) 92.61,44.49 92.61,45.19 92.41,45.39 92.41,47.36 91.29,48.48 91.29,48.78 91.27,48.8 91.27,48.83
  IN1 w0.089: v1(103.09,122.04) 102.86,122.27 102.86,122.41 102.6,122.67 101.49,122.67 101.17,122.34 101.17,120.84 96.12,115.79 95.64,115.79 94.14,114.29 94.14,102.69 93.52,102.08 93.52,101.09 93.98,100.63 93.98,99.34 91.76,97.13 91.76,95.09 91.53,94.86 91.53,94.15 92.01,93.68 92.01,91.29 90.47,89.76 90.47,87.87 89.34,86.73 89.34,82.89 88.96,82.52 88.96,76.21 88.56,75.81 88.56,58.36 90.13,56.79 90.13,52.05 90.36,51.82 90.36,50.85 91.27,49.94 91.27,48.83
  BOTTOM w0.102: U2030.H16 92.7,44.58 v4(92.41,44.29)
PEG_RXN7_C: length 10.6
  TOP w0.102: C6554.1 102.93,120.67 102.93,120.09 102.79,119.95 102.79,115.95 103.59,115.15 103.59,112.91 103.39,112.71 103.39,112.06 v2(102.97,111.64)
  BOTTOM w0.102: U8.AC11 102.96,111.64 v2(102.97,111.64)
PEG_RXN8: length 97
  TOP w0.102: v1(104.67,121.68) 104.36,121.36 104.36,120.87 103.93,120.44 103.93,119.86 C6557.2
  IN1 w0.079: 90.66,48.83 90.66,48.81 90.69,48.79 90.69,48.09 91.95,46.82 91.95,44.6 91.82,44.47 91.82,43.99 92.12,43.68 92.78,43.68 v4(93.03,43.44)
  IN1 w0.089: v1(104.67,121.68) 104.41,121.95 104.41,122.6 103.95,123.05 103.09,123.05 102.88,123.26 101.24,123.26 100.57,122.59 100.57,121.09 95.87,116.39 95.39,116.39 93.38,114.38 93.38,102.79 92.93,102.33 92.93,100.84 93.3,100.46 93.3,99.51 91.17,97.38 91.17,95.34 90.94,95.11 90.94,93.71 91.41,93.24 91.41,91.54 89.86,90 89.86,88.1 88.74,86.98 88.74,83.57 88.37,83.2 88.37,76.65 87.46,75.75 87.46,69.56 87.82,69.2 87.82,57.99 88.91,56.89 88.91,51.92 89.36,51.48 89.36,51.02 90.66,49.71 90.66,48.83
  BOTTOM w0.102: v4(93.03,43.44) 93.03,43.51 U2030.G15
PEG_RXN8_C: length 9.5
  TOP w0.102: C6557.1 104.18,118.86 104.18,118.22 103.87,117.91 103.87,116.11 104.42,115.56 104.42,112.14 104.2,111.92 104.2,111.23 v2(103.8,110.82)
  BOTTOM w0.102: v2(103.8,110.82) 103.8,110.8 U8.AB12
PEG_RXP5: length 94.4
  TOP w0.102: v1(99.06,120.54) 98.82,120.54 98.69,120.67 98.69,120.85 98.78,120.93 98.78,121.25 99.31,121.78 100.2,121.78 100.3,121.68 100.3,121.53 100.13,121.37 C370.2
  IN1 w0.079: v4(93.7,42.46) 93.51,42.46 93.43,42.54 93.43,42.85 93.23,43.04 91.89,43.04 91.1,42.25 90.83,42.25 90.52,42.56 90.52,43.68 90.34,43.86 90.34,48.37 90.06,48.65 90.06,48.78 90.08,48.8 90.08,48.82
  IN1 w0.089: 90.08,48.82 90.08,49.4 88.48,51 88.48,51.45 87.9,52.03 87.9,53.03 86.43,54.49 86.43,57.55 87.23,58.36 87.23,69.05 86.66,69.63 86.66,70.4 86.93,70.67 86.93,74.18 87.3,74.55 87.3,75.82 87.46,75.98 87.46,80.81 87.97,81.31 87.97,83.36 88.35,83.74 88.35,87.14 89.47,88.26 89.47,90.16 91.02,91.71 91.02,93.03 90.54,93.5 90.54,95.27 90.77,95.5 90.77,97.54 92.41,99.18 92.41,100.59 92.53,100.71 92.53,102.5 92.99,102.95 92.99,114.54 95.23,116.78 95.64,116.78 98.67,119.81 98.67,120.46 98.76,120.54 v1(99.06,120.54)
  BOTTOM w0.102: U2030.G13 93.35,42.73 93.62,42.46 v4(93.7,42.46)
PEG_RXP5_C: length 13.5
  TOP w0.102: v2(100.49,111.62) 100.49,111.34 100.56,111.26 100.86,111.26 100.9,111.31 100.9,111.97 97.89,114.98 97.89,116.89 100.28,119.28 100.28,120.52 C370.1
  BOTTOM w0.102: v2(100.49,111.62) 100.49,111.35 100.61,111.23 U8.AC9
PEG_RXP6: length 100.8
  TOP w0.102: C382.2 101.76,119.74 101.76,121.8 100.95,122.62 98.96,122.62 98.19,121.84 97.86,121.84 97.37,121.35 97.37,120.74 95.85,119.22 95.85,118.76 v1(95.69,118.6)
  IN1 w0.079: v4(94.28,41.55) 94.07,41.33 94.07,41.16 93.87,40.95 93.2,40.95 92.98,41.18 92.98,41.56 92.64,41.9 92.25,41.9 91.78,41.42 90.79,41.42 89.9,42.31 89.9,42.43 89.06,43.27 89.06,48.8 89.04,48.83 89.04,48.83
  IN1 w0.089: v1(95.69,118.6) 95.88,118.42 95.88,118.15 95.38,117.66 94.97,117.66 92.19,114.87 92.19,103.28 91.73,102.83 91.73,101.09 91.54,100.9 91.54,99.44 89.97,97.87 89.97,95.83 89.74,95.6 89.74,91.56 88.2,90.02 88.2,88.17 86.91,86.88 86.91,85.99 87.49,85.42 87.49,84.01 87.17,83.69 87.17,81.56 86.55,80.94 86.55,74.95 85.6,74 85.6,70.98 85.91,70.67 85.91,69.18 85.86,69.13 85.86,52.08 89.04,48.9 89.04,48.83
  BOTTOM w0.102: U2030.F11 v4(94.28,41.55)
PEG_RXP6_C: length 9.6
  TOP w0.102: C382.1 101.76,118.73 101.76,117.71 101.59,117.53 101.59,113.24 102.24,112.59 102.24,112.07 102.53,111.78 102.53,111.45 102.13,111.05 v2(102.13,110.78)
  BOTTOM w0.102: U8.AB10 102.1,110.78 v2(102.13,110.78)
PEG_RXP7: length 90.1
  TOP w0.102: v1(102.31,122.04) 102.54,122.04 102.63,121.95 102.63,121.58 102.42,121.37 C6556.2
  IN1 w0.079: v4(93.06,44.29) 92.89,44.29 92.77,44.42 92.77,45.25 92.57,45.45 92.57,47.43 91.45,48.55 91.45,48.78 91.47,48.8 91.47,48.82
  IN1 w0.089: v1(102.31,122.04) 102.58,122.04 102.65,122.11 102.65,122.33 102.52,122.46 101.58,122.46 101.37,122.26 101.37,120.76 96.2,115.59 95.72,115.59 94.34,114.2 94.34,102.61 93.73,102 93.73,101.17 94.18,100.72 94.18,99.26 91.97,97.04 91.97,95 91.74,94.78 91.74,94.24 92.21,93.77 92.21,91.21 90.68,89.68 90.68,87.78 89.54,86.65 89.54,82.81 89.17,82.43 89.17,76.13 88.76,75.72 88.76,58.45 90.33,56.87 90.33,52.13 90.56,51.9 90.56,50.93 91.47,50.02 91.47,48.82
  BOTTOM w0.102: U2030.G16 93.16,44.75 93.06,44.65 v4(93.06,44.29)
PEG_RXP7_C: length 10.5
  TOP w0.102: v2(102.94,112.44) 103.08,112.44 103.17,112.53 103.17,112.8 103.38,113 103.38,115.06 102.57,115.86 102.57,120.04 102.72,120.18 102.72,120.68 102.48,120.92 C6556.1
  BOTTOM w0.102: v2(102.94,112.44) 102.48,112.44 102.4,112.35 102.4,112.18 U8.AD11
PEG_RXP8: length 97
  TOP w0.102: C6555.2 103.71,119.86 103.71,120.53 104.14,120.96 104.14,121.43 v1(103.9,121.68)
  IN1 w0.079: v4(93.74,43.39) 93.28,43.84 92.19,43.84 91.97,44.06 91.97,44.4 92.11,44.54 92.11,46.89 90.84,48.16 90.84,48.79 90.87,48.81 90.87,48.83
  IN1 w0.089: v1(103.9,121.68) 104.2,121.98 104.2,122.51 103.87,122.85 103,122.85 102.79,123.06 101.33,123.06 100.77,122.51 100.77,121 95.95,116.18 95.48,116.18 93.59,114.29 93.59,102.7 93.13,102.25 93.13,100.92 93.51,100.55 93.51,99.43 91.37,97.29 91.37,95.25 91.14,95.02 91.14,93.79 91.61,93.32 91.61,91.46 90.07,89.91 90.07,88.02 88.94,86.89 88.94,83.49 88.57,83.11 88.57,76.57 87.67,75.66 87.67,69.64 88.02,69.29 88.02,58.07 89.11,56.98 89.11,52.01 89.56,51.56 89.56,51.1 90.87,49.8 90.87,48.83
  BOTTOM w0.102: v4(93.74,43.39) 93.67,43.45 93.67,43.63 93.88,43.83 U2030.F15
PEG_RXP8_C: length 9.4
  TOP w0.102: v2(103.8,111.62) 103.91,111.62 103.99,111.69 103.99,112.01 104.2,112.23 104.2,115.47 103.65,116.02 103.65,118 103.96,118.31 103.96,118.99 103.8,119.15 103.45,119.15 C6555.1
  BOTTOM w0.102: U8.AC12 103.57,111.23 103.8,111.46 v2(103.8,111.62)
PEG_TXN5: length 93.5
  IN1 w0.089: v1(106.42,44.13) 106.19,43.91 106.19,43.74 105.95,43.5 104.65,43.5 103.03,45.12 103.03,47.85 102.15,48.73 101.26,48.73 101.15,48.83 98.5,48.83 95.54,51.79 95.54,52.59 95.41,52.72 95.14,52.99 95.14,53.52 92.34,56.32 92.34,57.31 92.05,57.59 91.39,57.59 90.17,58.82 90.17,81.56 90.61,82 90.61,86.19 91.78,87.36 91.78,88.36 93.81,90.4 93.81,91.41 94.36,91.96 94.36,95.01 93.69,95.69 93.69,97.36 95.24,98.91 95.24,101.43 95.9,102.09 95.9,112.98 97.34,114.41 97.62,114.41 97.88,114.67 97.88,115.01 97.72,115.17 97.72,115.56 98.04,115.88 98.35,115.88 v1(98.54,116.07)
  BOTTOM w0.102: v1(98.54,116.07) 98.73,115.87 98.98,115.87 99.22,115.63 99.22,114.96 99.1,114.84 99.1,114.56 U8.AG7 ; C192.1 103.69,42.63 103.95,42.63 104.79,43.47 105.93,43.47 106.2,43.74 106.2,43.91 v1(106.42,44.13)
PEG_TXN5_C: length 7.6
  BOTTOM w0.079: 98.54,44.62 98.52,44.62 98.5,44.64 97.92,44.64 97.71,44.84 97.16,44.84 96.96,45.04 96.96,45.22 96.89,45.29 U2030.B17
  BOTTOM w0.102: 98.54,44.62 99.21,44.62 101.18,42.65 102.92,42.65 C192.2
PEG_TXN6: length 101.3
  IN1 w0.089: v1(105.09,42.38) 104.86,42.61 104.07,42.61 101.94,44.73 101.94,46.09 102.37,46.52 102.37,47.66 102.07,47.97 100.93,47.97 100.72,47.76 97.13,47.76 94.95,49.95 93.58,49.95 92.21,51.32 92.21,53.2 90.99,54.42 90.99,56.98 89.34,58.63 89.34,75.46 89.62,75.74 89.62,82.09 90.01,82.48 90.01,86.43 91.18,87.61 91.18,89.63 93.76,92.21 93.76,93.42 92.85,94.34 92.85,97.37 94.58,99.1 94.58,100.88 94.12,101.34 94.12,101.84 95.25,102.96 95.25,113.17 96.85,114.77 96.85,115.68 98.97,117.8 99.53,117.8 99.83,117.5 99.83,117.16 v1(100.01,116.98)
  BOTTOM w0.102: v1(105.09,42.38) 104.89,42.58 104.79,42.58 103.8,41.59 102.65,41.59 C194.1 ; v1(100.01,116.98) 99.83,116.8 99.83,115.86 99.71,115.73 99.71,114.86 99.78,114.79 99.78,114.04 99.57,113.83 99.57,113.41 99.23,113.06 U8.AE7
PEG_TXN6_C: length 7.7
  BOTTOM w0.079: U2030.D16 96.28,44.43 97.58,44.43 97.85,44.17 98.18,44.17 98.21,44.14
  BOTTOM w0.102: C194.2 101.77,41.46 101.33,41.46 99.64,43.15 99.64,43.42 98.92,44.14 98.21,44.14
PEG_TXN7: length 98.2
  IN1 w0.089: v1(107.03,45.43) 106.8,45.19 106.8,44.85 106.53,44.59 104.91,44.59 103.62,45.87 103.62,48.77 101.88,50.51 97.71,50.51 96.33,51.9 96.33,53.53 95.67,54.19 95.51,54.19 93.01,56.68 93.01,57.76 92.44,58.33 91.69,58.33 90.71,59.3 90.71,64.98 90.97,65.24 90.97,71.62 91.19,71.84 91.19,72.36 90.97,72.58 90.97,74.75 91.25,75.03 91.25,83.1 92.14,83.99 92.14,84.94 91.37,85.7 91.37,86.11 92.38,87.11 92.38,88.12 94.61,90.34 94.61,91.36 94.96,91.71 94.96,97.79 95.85,98.68 95.85,101.19 96.5,101.85 96.5,112.64 97.69,113.83 98.53,113.83 99.43,114.72 99.43,115.87 99.79,116.23 100.28,116.23 v1(100.47,116.42)
  BOTTOM w0.102: v1(100.47,116.42) 100.68,116.21 100.88,116.21 101.13,115.97 101.13,115.15 100.57,114.59 100.57,113.97 U8.AF9 ; v1(107.03,45.43) 106.8,45.2 106.8,44.84 106.53,44.58 104.82,44.58 104,43.75 102.62,43.75 C196.1
PEG_TXN7_C: length 7.7
  BOTTOM w0.079: 98.54,45.03 98.53,45.03 98.51,45.06 98.03,45.06 97.53,45.56 97.27,45.56 97.23,45.54 96.87,45.54 96.84,45.56 96.59,45.56 96.53,45.52 96.46,45.45 96.41,45.34 96.38,45.25 96.32,45.12 96.24,45.05 96.14,45 96,45 U2030.D17
  BOTTOM w0.102: 98.54,45.03 99.68,45.03 101.08,43.64 101.78,43.64 C196.2
PEG_TXN8: length 88.1
  IN1 w0.089: v1(105.04,47) 105.04,46.73 104.96,46.65 104.64,46.65 104.48,46.82 104.48,49.12 102.15,51.45 101.24,51.45 99.74,52.95 98.34,52.95 95.49,55.8 95.49,56.26 93.89,57.86 93.89,58.62 92.59,59.91 92.59,65.02 92.18,65.43 92.18,70.51 92.11,70.58 92.11,71.96 92.49,72.34 92.49,73.47 92.29,73.67 92.29,76.85 92.47,77.03 92.47,82.66 93.18,83.36 93.18,87.74 95.41,89.97 95.41,91.03 95.76,91.38 95.76,97.46 96.65,98.34 96.65,100.86 97.63,101.84 97.63,102.89 97.73,102.99 97.73,111.1 97.81,111.18 97.81,111.91 97.57,112.15 97.57,112.58 97.93,112.94 100.01,112.94 101.18,114.11 101.18,115.32 101.61,115.75 101.97,115.75 102.04,115.68 v1(102.04,115.39)
  BOTTOM w0.102: v1(105.04,47) 104.75,46.71 104.54,46.71 103.94,46.11 102.76,46.11 C198.1 ; U8.AG10 101.34,114.43 101.29,114.49 101.29,114.63 101.59,114.92 101.59,115.56 101.78,115.75 101.96,115.75 102.04,115.68 v1(102.04,115.39)
PEG_TXN8_C: length 5.9
  BOTTOM w0.079: U2030.B19 97.39,46.98 98.12,46.98 99.02,46.08 99.15,46.08 99.17,46.11
  BOTTOM w0.102: 99.17,46.11 101.57,46.11 101.69,46.22 101.9,46.22 C198.2
PEG_TXP5: length 93.5
  IN1 w0.089: v1(105.66,44.13) 105.92,44.13 105.99,44.06 105.99,43.82 105.87,43.7 104.74,43.7 103.23,45.2 103.23,47.93 102.23,48.93 101.34,48.93 101.24,49.04 98.59,49.04 95.74,51.88 95.74,52.67 95.56,52.86 95.34,53.07 95.34,53.6 92.54,56.4 92.54,57.39 92.14,57.8 91.48,57.8 90.37,58.9 90.37,81.47 90.81,81.91 90.81,86.1 91.98,87.28 91.98,88.28 94.02,90.31 94.02,91.33 94.56,91.87 94.56,95.1 93.89,95.77 93.89,97.28 95.44,98.83 95.44,101.34 96.11,102.01 96.11,112.9 97.42,114.21 97.71,114.21 98.09,114.59 98.09,115.09 97.93,115.25 97.93,115.48 98.13,115.68 98.43,115.68 98.54,115.57 v1(98.54,115.3)
  BOTTOM w0.102: U8.AG6 98.8,114.43 98.89,114.52 98.89,114.92 99.02,115.05 99.02,115.54 98.9,115.67 98.61,115.67 98.54,115.59 v1(98.54,115.3) ; C193.1 103.38,43.06 103.38,42.91 103.44,42.85 103.86,42.85 104.7,43.69 105.84,43.69 105.98,43.83 105.98,44.06 105.9,44.13 v1(105.66,44.13)
