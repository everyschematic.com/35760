# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A4: length 191.3
  TOP w0.102: v2(34.45,90.42) 34.85,90.03 35.74,90.03 U2009.N3 ; v2(30.2,74.71) 30.8,74.71 30.92,74.84 30.92,74.99 30.74,75.18 30.74,75.3 30.83,75.4 31.24,75.4 31.45,75.61 32.58,75.61 32.95,75.98 35.27,75.98 35.81,76.52 35.81,76.64 36.67,77.5 U2010.N3 ; U2012.N3 36.12,42.53 36.12,41.78 35.53,41.18 32.8,41.18 32.5,40.88 31.63,40.88 30.75,41.77 v2(30.54,41.77) ; U2011.N3 35.75,55.37 33.56,55.37 33.44,55.25 31.98,55.25 31.86,55.13 31.86,54.62 31.76,54.52 31.56,54.52 31.48,54.6 31.48,54.97 31.35,55.09 v2(30.8,55.09) ; 30.82,95.01 v2(30.97,95.01)
  TOP w0.165: 30.82,95.01 30.15,95.68 R2112.2
  IN1 w0.089: v2(34.45,90.42) 34.4,90.48 34.4,90.82 34.49,90.91 34.59,90.91 34.68,91 34.68,91.12 34.59,91.21 34.49,91.21 34.4,91.3 34.4,91.43 34.49,91.52 34.59,91.52 34.68,91.61 34.68,91.73 34.59,91.82 34.49,91.82 34.4,91.91 34.4,92.29 34.05,92.64 33.96,92.64 33.83,92.51 33.83,92.37 34.01,92.19 34.01,90.87 33.68,90.54 32.54,90.54 31.75,89.76 31.75,89.03 30.5,87.78 30.5,84.85 30.09,84.44 30.09,83.59 30.65,83.03 30.74,83.03 30.99,82.78 31.07,82.78 31.17,82.68 31.17,82.08 31,81.92 30.33,81.92 30.09,81.68 30.09,76.23 30.2,76.12 30.2,75.54 30.26,75.47 30.26,74.78 v2(30.2,74.71) 30.01,74.52 30.01,74.15 30.11,74.05 30.24,74.05 30.35,73.95 30.35,73.75 30.24,73.65 30.11,73.65 30.01,73.54 30.01,69.8 30.06,69.75 30.34,69.75 30.45,69.64 30.45,69.43 30.35,69.33 29.99,69.33 29.89,69.23 29.89,69.03 29.99,68.92 30.35,68.92 30.45,68.81 30.45,57.12 30.96,56.61 30.96,55.26 v2(30.8,55.09) 30.87,55.02 30.87,53.88 30.74,53.76 30.57,53.76 30.47,53.66 30.47,53.5 30.57,53.4 30.79,53.4 30.87,53.33 30.87,53.15 30.77,53.05 30.52,53.05 30.43,52.96 30.43,52.83 30.54,52.72 31.28,52.72 31.41,52.59 31.41,52.41 31.33,52.34 31.2,52.34 31.06,52.19 31.06,50.42 30.96,50.32 30.52,50.32 30.42,50.22 30.42,50.01 30.52,49.91 30.96,49.91 31.06,49.81 31.06,49.61 30.96,49.51 30.53,49.51 30.43,49.41 30.43,49.2 30.53,49.1 30.96,49.1 31.06,49 31.06,48.8 30.96,48.69 30.55,48.69 30.45,48.6 30.45,48.39 30.56,48.29 30.96,48.29 31.06,48.19 31.06,47.45 31.79,46.72 31.79,43.35 31.28,42.84 31.28,42.29 31.64,41.93 31.89,41.93 32.14,41.68 32.14,41.24 31.95,41.05 31.6,41.05 31.17,41.48 30.83,41.48 v2(30.54,41.77)
  IN3 w0.102: v2(34.45,90.42) 32.85,90.73 32.33,91.24 32.33,94.31 31.64,95.01 v2(30.97,95.01)
  IN3 w0.14: v2(30.54,41.77) 30.42,41.89 30.42,42 30.5,42.08 30.5,42.74 29.28,43.97 29.13,43.97 29.04,44.07 29.04,44.93 28.8,45.17 27.94,45.17 27.78,45.32 27.78,45.49 27.91,45.61 28.7,45.61 28.84,45.75 28.84,45.89 28.7,46.03 27.91,46.03 27.78,46.15 27.78,46.44 27.89,46.55 28.29,46.55 28.39,46.65 28.39,47.06 28.28,47.17 27.89,47.17 27.78,47.28 27.78,50.56 28.04,50.81 28.04,51.07 27.79,51.32 27.79,51.67 28.06,51.94 28.06,52.21 27.79,52.48 27.79,57.9 33,63.11 34.74,63.11 35.11,63.48 35.11,63.74 36.99,65.62 37.42,65.62 37.54,65.74 37.54,65.89 37.4,66.03 37.4,66.21 37.52,66.33 37.69,66.33 38.12,65.9 38.28,65.9 38.4,66.03 38.4,66.21 37.99,66.63 37.99,66.8 38.11,66.92 38.28,66.92 38.7,66.51 38.88,66.51 39.01,66.63 39.01,66.79 38.58,67.22 38.58,67.39 38.7,67.51 38.88,67.51 39.05,67.34 39.25,67.34 39.37,67.46 39.37,67.62 39.17,67.81 39.17,67.98 39.65,68.46 47.11,68.46 47.24,68.59 47.74,68.59 47.87,68.46 49,68.46 49.16,68.63 49.74,68.63 49.9,68.46 58.47,68.46 59.23,67.7 65.46,67.7 67.4,65.75 67.71,65.75 68.01,66.05 68.18,66.05 68.29,65.95 68.29,65.54 68.4,65.43 68.98,65.43 70.11,64.3 70.95,64.3 71.23,64.02 71.23,63.51 71.38,63.36 v2(71.38,63.11)
  BOTTOM w0.076: 73.77,62.5 74.34,62.5 74.48,62.36 74.87,62.36 74.9,62.37 74.91,62.37 74.93,62.38 75.03,62.41 75.13,62.41 75.27,62.35 75.5,62.35 U2030.BA47
  BOTTOM w0.102: v2(71.38,63.11) 71.38,63.01 71.26,62.88 71.26,62.67 71.09,62.5 69.35,62.5 69.25,62.39 69.25,62.2 69.35,62.1 71.43,62.1 71.53,62.2 71.53,62.61 71.64,62.71 71.82,62.71 71.93,62.6 71.93,62.17 72.03,62.07 72.29,62.07 72.39,62.17 72.39,62.37 72.49,62.47 72.67,62.47 72.77,62.37 72.77,62.15 72.87,62.05 73.07,62.05 73.18,62.15 73.18,62.38 73.29,62.5 73.77,62.5
M_B_A5: length 177.6
  TOP w0.102: U2011.P8 35.47,52.69 35.47,53.33 34.63,54.16 34.4,54.16 v2(34.13,53.9) ; v2(36.82,36.07) 36.48,36.41 36.48,37.46 36.3,37.64 36.3,38.44 35.87,38.87 U2012.P8 ; U2010.P8 35.82,73.7 35.39,73.27 33.72,73.27 33.32,72.86 v2(33.07,72.86) ; U2009.P8 35.47,87.36 35.47,87.99 34.71,88.75 33.96,88.75 v2(33.92,88.7)
  TOP w0.165: v2(31.39,92.87) 31.27,92.75 R2117.2
  IN1 w0.089: v2(36.82,36.07) 36.04,36.07 35.9,36.21 35.9,36.38 35.98,36.46 36.55,36.46 36.64,36.55 36.64,36.74 36.54,36.84 35.86,36.84 35.75,36.95 35.75,38.18 34.54,39.38 34.54,41.46 34.79,41.71 34.79,45.89 34.13,46.54 34.13,49.96 34.52,50.35 34.52,51.25 34.13,51.64 v2(34.13,53.9) 34.13,59.23 33.13,60.24 33.13,64.32 33.23,64.42 33.88,64.42 33.98,64.52 33.98,64.72 33.88,64.82 33.23,64.82 33.13,64.92 33.13,65.13 33.23,65.23 33.98,65.23 34.08,65.33 34.08,65.53 33.98,65.64 33.62,65.64 33.52,65.74 33.52,65.98 33.62,66.08 33.88,66.08 33.98,66.18 33.98,68.86 33.72,69.12 33.72,71.23 33.07,71.88 v2(33.07,72.86) 33.55,72.86 33.69,73.01 33.69,74.06 33.6,74.15 33.05,74.15 32.97,74.23 32.97,74.36 33.06,74.45 33.79,74.45 33.88,74.54 33.88,74.67 33.79,74.76 33.53,74.76 33.43,74.85 33.43,74.98 33.51,75.06 33.76,75.06 33.85,75.16 33.85,76.58 34.13,76.85 34.13,78.37 33.65,78.85 33.32,78.85 32.85,79.31 32.85,80.25 33.19,80.58 33.53,80.58 33.78,80.83 33.78,85.13 34.26,85.61 34.26,86.13 33.92,86.47 33.92,88.11 33.68,88.35 33.68,88.59 33.8,88.7 v2(33.92,88.7)
  IN3 w0.089: 71.83,64.16 72.02,63.96 72.02,63.54 71.97,63.48 v2(71.97,63.11)
  IN3 w0.102: v2(31.39,92.87) 31.62,92.64 31.62,91 32.61,90.01 32.61,88.62 32.93,88.3 33.51,88.3 v2(33.92,88.7)
  IN3 w0.14: 71.83,64.16 71.38,64.6 70.29,64.6 69.18,65.72 69.18,66.03 70,66.85 70,67 69.88,67.13 69.68,67.13 68.69,66.14 68.55,66.14 68.42,66.27 68.42,66.47 69.35,67.4 69.35,67.57 69.23,67.69 69.06,67.69 67.65,66.28 67.45,66.28 67.27,66.46 67.27,66.64 67.93,67.3 67.93,67.49 67.78,67.64 67.57,67.64 66.89,66.97 66.66,66.97 65.63,67.99 59.35,67.99 58.59,68.75 50.02,68.75 49.36,69.42 47.65,69.42 46.99,68.75 39.49,68.75 34.83,64.1 33.5,64.1 27.49,58.09 27.49,45.2 29.01,43.68 29.16,43.68 30.21,42.62 30.21,42.2 30.09,42.08 30.09,40.98 30.53,40.54 30.53,40.11 30.81,39.83 30.81,39.04 33.79,36.07 35.25,36.07 v2(36.82,36.07)
  BOTTOM w0.076: U2030.AY48 75.85,62.59 75.68,62.59 75.58,62.55 75.58,62.55 75.5,62.52 75.29,62.52 75.16,62.57 75,62.57 74.95,62.56 74.93,62.56 74.84,62.52 74.59,62.52 74.4,62.71 72.36,62.71 v2(71.97,63.11)
M_B_A6: length 183.7
  TOP w0.102: U2011.P2 35.58,57.09 35.17,56.69 33.37,56.69 33.31,56.63 31.84,56.63 v2(31.71,56.51) ; v2(30.92,75.84) 31.06,75.98 32.26,75.98 32.72,76.45 34.38,76.45 35.45,77.52 35.45,78.08 U2010.P2 ; v2(32.08,42.6) 32.58,42.1 34.12,42.1 34.65,42.62 34.65,43.25 34.87,43.48 35.47,43.48 35.78,43.79 U2012.P2
  TOP w0.165: v1(33.29,98.28) 33.29,98.38 33.87,98.96 R2103.2 ; v2(35.5,91.36) 35.87,91.73 U2009.P2
  IN1 w0.089: v2(35.5,91.36) 35.34,91.51 35.34,92.45 35.08,92.72 35.08,94.11 34.98,94.21 34.84,94.21 34.73,94.1 34.73,93.17 34.48,92.92 34.48,92.76 34.92,92.31 34.92,90.07 34.84,89.99 34.19,89.99 33.88,90.3 32.64,90.3 32.03,89.69 32.03,88.01 31.6,87.58 31.6,81.69 31.2,81.29 31.2,79.97 30.59,79.36 30.59,76.49 30.92,76.16 v2(30.92,75.84) 30.9,75.82 30.9,73.91 31.25,73.56 31.25,72.33 31.15,72.23 31.05,72.23 30.94,72.13 30.94,71.93 31.04,71.82 31.15,71.82 31.25,71.72 31.25,70.31 31.35,70.21 31.49,70.21 31.6,70.11 31.6,69.91 31.49,69.81 31.2,69.81 31.1,69.71 31.1,69.5 31.2,69.4 31.49,69.4 31.6,69.3 31.6,69.1 31.49,68.99 31.35,68.99 31.25,68.89 31.25,68.46 31,68.21 31,57.43 31.71,56.71 v2(31.71,56.51) 31.44,56.24 31.44,53.39 31.88,52.95 32.14,52.95 32.24,52.85 32.24,51.54 32.08,51.38 32.08,51.16 31.99,51.07 31.75,51.07 31.66,50.98 31.66,50.82 31.75,50.74 31.99,50.74 32.07,50.66 32.07,50.47 31.98,50.38 31.74,50.38 31.65,50.29 31.65,50.11 31.71,50.05 31.99,50.05 32.05,49.99 32.05,49.81 31.99,49.74 31.71,49.74 31.63,49.67 31.63,49.52 31.73,49.42 32.38,49.42 32.45,49.35 32.45,49.22 32.35,49.12 31.73,49.12 31.63,49.02 31.63,48.91 31.73,48.81 32.36,48.81 32.45,48.72 32.45,48.56 32.38,48.48 31.76,48.48 31.67,48.39 31.67,48.24 31.78,48.12 32.37,48.12 32.46,48.03 32.46,47.87 32.41,47.81 31.74,47.81 31.66,47.74 31.66,47.56 31.76,47.46 32.33,47.46 32.41,47.38 32.41,42.66 32.35,42.6 v2(32.08,42.6)
  IN3 w0.089: 72.6,62.59 73.06,63.06 73.06,63.23 72.66,63.62 v2(72.66,63.75)
  IN3 w0.102: v1(33.29,98.28) 33.85,97.72 33.85,97.39 35.42,95.82 35.42,95.05 35.32,94.95 35.32,91.53 v2(35.5,91.36)
  IN3 w0.14: 72.6,62.59 72.51,62.51 69.91,62.51 68.85,63.56 68.85,63.71 68.3,64.26 67.25,64.26 65.81,65.7 64.96,65.7 64.84,65.82 64.84,66.41 64.72,66.53 64.54,66.53 64.42,66.41 64.42,65.82 64.3,65.7 64.13,65.7 64,65.82 64,66.41 63.88,66.53 63.71,66.53 63.58,66.41 63.58,65.82 63.46,65.7 63.29,65.7 63.16,65.82 63.16,66.41 63.04,66.53 62.87,66.53 62.75,66.41 62.75,65.82 62.62,65.7 62.45,65.7 62.33,65.82 62.33,66.41 62.2,66.53 62.03,66.53 61.91,66.41 61.91,65.82 61.78,65.7 61.61,65.7 61.49,65.82 61.49,66.41 61.37,66.53 61.19,66.53 61.07,66.41 61.07,65.82 60.95,65.7 60.77,65.7 60.65,65.82 60.65,66.41 60.53,66.53 60.35,66.53 60.23,66.41 60.23,65.82 60.11,65.7 59.93,65.7 59.81,65.82 59.81,66.41 59.69,66.53 59.52,66.53 59.39,66.41 59.39,65.82 59.27,65.7 59.1,65.7 58.97,65.82 58.97,66.41 58.85,66.53 58.68,66.53 58.55,66.41 58.55,65.82 58.43,65.7 58.21,65.7 58.11,65.8 58.11,67.17 58,67.28 57.81,67.28 57.68,67.14 57.68,66.84 57.5,66.66 55.07,66.66 54.91,66.81 54.91,67.15 54.78,67.28 54.58,67.28 54.48,67.18 54.48,66.76 54.39,66.68 54.15,66.68 54.06,66.77 54.06,67.15 53.93,67.28 53.71,67.28 53.63,67.2 53.63,66.9 53.51,66.78 53.34,66.78 53.22,66.91 53.22,67.2 53.14,67.28 52.21,67.28 52.09,67.16 52.09,66.85 51.84,66.61 51.4,66.61 51.25,66.76 51.25,67.18 51.15,67.28 50.92,67.28 50.82,67.18 50.82,66.71 50.72,66.61 50.5,66.61 50.4,66.71 50.4,67.18 50.3,67.28 50.09,67.28 49.96,67.15 49.96,66.73 49.83,66.61 46.18,66.61 45.26,65.69 39.71,65.69 38.48,64.45 37.96,64.45 35.44,61.94 34.22,61.94 34.05,61.77 34.05,61.31 29.82,57.08 29.82,56.04 29.68,55.9 29.24,55.9 29.12,55.78 29.12,55.61 29.27,55.46 29.72,55.46 29.82,55.36 29.82,55.15 29.69,55.03 29.11,55.03 29.01,54.93 29.01,54.71 29.12,54.6 29.4,54.6 29.54,54.46 29.54,54.28 29.4,54.14 29.09,54.14 29.01,54.05 29.01,53.81 29.14,53.67 29.89,53.67 30.01,53.55 30.01,53.38 29.75,53.12 29.75,52.96 30.01,52.7 30.01,52.45 29.91,52.35 29.91,50.56 30.12,50.35 30.12,45.5 30.9,44.72 30.9,44 32.08,42.82 v2(32.08,42.6)
  BOTTOM w0.076: v2(72.66,63.75) 72.66,63.65 73.16,63.15 74.89,63.15 75.25,62.79 U2030.BA48
M_B_A7: length 177.5
  TOP w0.102: v2(31.53,88.18) 32.62,87.65 32.69,87.62 33.29,87.62 33.77,87.57 34.14,87.35 34.38,87.35 U2009.R8 ; v2(31.82,52.51) 32.48,52.51 32.57,52.41 32.57,51.98 32.68,51.88 32.83,51.88 32.92,51.97 32.92,52.51 33.37,52.96 33.89,52.96 34.16,52.68 34.54,52.68 34.93,52.29 U2011.R8 ; U2010.R8 34.68,74.08 33.03,74.08 32.75,73.8 31.89,73.44 30.7,73.44 v2(30.68,73.42) ; U2012.R8 34.33,39.43 31.3,39.43 v2(30.36,39.58)
  TOP w0.165: R2124.2 31.02,88.69 v2(31.53,88.18)
  IN1 w0.089: v2(30.36,39.58) 30.12,39.83 30.12,39.98 29.17,40.93 29.17,41.08 29.26,41.17 29.41,41.17 30.36,40.22 30.49,40.22 30.58,40.31 30.58,40.43 30.44,40.58 30.44,40.71 30.52,40.78 30.59,40.78 30.67,40.7 30.83,40.7 30.95,40.82 30.95,41.11 31.02,41.18 31.18,41.18 31.28,41.08 31.28,40.69 31.38,40.59 31.59,40.59 31.65,40.65 31.65,40.79 31.71,40.85 31.92,40.85 31.99,40.78 31.99,40.68 32.04,40.63 32.25,40.63 32.38,40.76 32.38,41.89 32.11,42.16 31.7,42.16 31.58,42.28 31.58,42.69 32.1,43.21 32.1,46.82 31.4,47.52 31.4,52.08 v2(31.82,52.51) 31.82,52.66 31.21,53.27 31.21,56.77 30.75,57.23 30.75,69.91 30.32,70.33 30.32,71.7 30.39,71.77 30.62,71.77 30.7,71.84 30.7,72.02 30.62,72.1 30.36,72.1 30.32,72.14 30.32,73.06 v2(30.68,73.42) 30.61,73.48 30.61,75.55 30.49,75.67 30.49,76.26 30.39,76.37 30.39,79.8 30.48,79.89 30.8,79.89 30.9,79.99 30.9,80.11 30.82,80.19 30.48,80.19 30.39,80.28 30.39,80.41 30.48,80.5 30.89,80.5 30.98,80.58 30.98,80.71 30.89,80.8 30.48,80.8 30.39,80.89 30.39,81.02 30.48,81.11 30.89,81.11 30.98,81.19 30.98,81.32 30.89,81.41 30.48,81.41 30.39,81.5 30.39,81.63 30.48,81.71 31.28,81.71 31.37,81.81 31.37,82.94 31.29,83.02 31.11,83.02 31.01,83.12 31.01,83.25 31.11,83.35 31.28,83.35 31.37,83.44 31.37,83.67 31.23,83.8 31.17,83.8 31.08,83.9 31.08,84.09 31.16,84.16 31.24,84.16 31.33,84.25 31.33,86.06 31.24,86.15 30.89,86.15 30.8,86.24 30.8,86.36 30.89,86.45 31.24,86.45 31.33,86.54 31.33,87.26 31.24,87.35 30.92,87.35 30.82,87.45 30.82,87.57 30.9,87.65 31.24,87.65 31.33,87.74 31.33,87.99 v2(31.53,88.18)
  IN3 w0.14: v2(30.36,39.58) 30.19,39.58 29.98,39.79 29.98,39.94 30.21,40.17 30.21,40.42 30.11,40.52 29.96,40.52 29.75,40.32 29.62,40.32 29.51,40.43 29.51,40.89 29.8,41.18 29.8,42 29.63,42.18 29.4,42.18 29.04,42.53 29.04,42.61 26.91,44.75 26.91,58.33 33.26,64.68 34.48,64.68 39.14,69.34 46.74,69.34 47.52,70.11 50.23,70.11 50.39,69.95 50.39,69.46 50.52,69.34 50.69,69.34 50.81,69.46 50.81,69.83 50.94,69.95 51.11,69.95 51.23,69.83 51.23,69.46 51.36,69.34 51.53,69.34 51.65,69.46 51.65,69.83 51.77,69.95 51.95,69.95 52.07,69.83 52.07,69.46 52.19,69.34 52.37,69.34 52.49,69.46 52.49,69.83 52.61,69.95 52.79,69.95 52.91,69.83 52.91,69.46 53.03,69.34 53.21,69.34 53.33,69.46 53.33,69.83 53.45,69.95 61.7,69.95 61.82,69.83 61.82,69.32 61.94,69.2 62.12,69.2 62.24,69.32 62.24,69.83 62.36,69.95 62.54,69.95 62.66,69.83 62.66,68.71 62.79,68.58 62.97,68.58 63.08,68.69 63.08,69.83 63.2,69.95 63.37,69.95 63.5,69.83 63.5,68.7 63.62,68.58 63.79,68.58 63.92,68.7 63.92,69.62 64.01,69.72 64.25,69.72 64.35,69.62 64.35,68.77 64.48,68.64 66.05,68.64 66.36,68.95 68.74,68.95 69.05,68.64 69.74,68.64 69.81,68.71 70.35,68.71 72.63,66.42 72.63,66.08 73.39,65.31 73.39,64.27 74.02,63.65 76.87,63.65 77.23,64 78.33,64 78.79,63.54 v2(79.49,63.54)
  BOTTOM w0.165: v2(79.49,63.54) 79.51,63.53 U2030.AP48
M_B_A8: length 184.9
  TOP w0.102: v2(29.06,57.78) 29.38,57.47 30.95,57.47 31.05,57.57 31.05,57.72 31.15,57.82 31.36,57.82 31.46,57.72 31.46,57.57 31.56,57.47 31.76,57.47 31.87,57.57 31.87,57.72 31.97,57.82 32.17,57.82 32.27,57.72 32.27,57.57 32.37,57.47 32.58,57.47 32.68,57.57 32.68,57.75 32.78,57.85 32.98,57.85 33.08,57.75 33.08,57.57 33.19,57.47 34.44,57.47 34.81,57.09 U2011.R2 ; U2012.R2 34.87,43.88 34.51,43.52 30.72,43.52 30.26,43.06 29.22,43.06 29.2,43.09 v2(29.17,43.09) ; v2(28.49,76.16) 29.39,77.06 30.32,77.06 30.49,77.23 30.64,77.23 30.9,76.97 31.05,76.97 31.2,77.13 31.2,77.25 30.97,77.48 30.97,77.66 31.42,78.1 33.6,78.1 33.63,78.08 34.65,78.08 U2010.R2 ; U2009.R2 34.85,91.76 34.47,92.14 33.92,92.14 33.15,92.91 33.15,94.41 33.43,94.69 33.43,95.25 v2(33.01,95.67)
  TOP w0.165: v1(32.6,100.75) 32.62,100.77 R2091.2
  IN1 w0.089: v2(29.17,43.09) 29.75,43.09 29.91,43.25 29.91,43.42 29.34,43.99 29.34,44.16 29.48,44.3 29.6,44.3 30.17,43.73 30.31,43.73 30.46,43.87 30.46,44.02 29.91,44.56 29.91,44.73 30.03,44.85 30.16,44.85 30.52,44.49 30.67,44.49 30.77,44.59 30.77,44.72 30.49,45 30.49,45.13 30.72,45.37 30.72,46.49 29.44,47.78 29.44,54.88 29.49,54.93 29.49,57.36 v2(29.06,57.78) 28.93,57.91 28.93,62.41 29.45,62.93 29.45,64.35 29.32,64.48 28.98,64.48 28.87,64.59 28.87,64.81 28.94,64.88 29.37,64.88 29.45,64.96 29.45,65.14 29.35,65.24 29.02,65.24 28.92,65.34 28.92,65.52 28.99,65.59 29.37,65.59 29.45,65.67 29.45,65.82 29.35,65.92 29.12,65.92 29.02,66.03 29.02,66.24 29.11,66.33 29.35,66.33 29.45,66.43 29.45,66.64 29.35,66.74 29.14,66.74 29.03,66.85 29.03,67.05 29.12,67.14 29.35,67.14 29.45,67.25 29.45,67.86 29.07,68.24 29.07,70.38 28.38,71.07 28.38,76.05 v2(28.49,76.16) 29.16,76.83 29.16,85.92 29.54,86.31 29.54,88.04 30.42,88.92 30.42,90.04 31.63,91.25 31.75,91.25 31.98,91.01 32.13,91.01 32.27,91.16 32.27,91.3 32.01,91.55 32.01,91.63 32.75,92.37 32.75,93.78 33.4,94.43 33.4,95.28 v2(33.01,95.67)
  IN3 w0.102: v2(33.01,95.67) 32.63,96.05 32.63,100.72 v1(32.6,100.75)
  IN3 w0.14: v2(72.55,63.12) 72.55,63.25 72.24,63.56 72.24,64.11 72.86,64.73 72.86,65.24 72.35,65.75 72.03,65.75 70.68,67.1 70.39,67.1 69.35,68.13 68.92,68.13 68.44,67.65 68.18,67.65 68.03,67.8 68.03,67.98 68.37,68.32 68.37,68.54 68.25,68.66 68.02,68.66 66.79,67.42 66.62,67.42 66.41,67.63 66.41,67.8 66.79,68.19 66.79,68.43 66.68,68.54 66.43,68.54 66.18,68.29 62.39,68.29 62.26,68.41 62.26,68.62 62.14,68.74 61.97,68.74 61.85,68.62 61.85,68.41 61.72,68.29 61.55,68.29 61.43,68.41 61.43,69.48 61.3,69.61 61.13,69.61 61.01,69.48 61.01,68.41 60.88,68.29 60.71,68.29 60.59,68.41 60.59,69.54 60.47,69.66 60.29,69.66 60.17,69.54 60.17,68.41 60.05,68.29 59.87,68.29 59.75,68.41 59.75,69.54 59.63,69.66 59.45,69.66 59.33,69.54 59.33,68.84 59.21,68.72 59.03,68.72 58.91,68.84 58.91,69.54 58.79,69.66 58.62,69.66 58.49,69.54 58.49,69.17 58.37,69.04 58.2,69.04 58.07,69.17 58.07,69.54 57.95,69.66 57.78,69.66 57.65,69.54 57.65,69.17 57.53,69.04 57.36,69.04 57.24,69.17 57.24,69.54 57.11,69.66 54.22,69.66 53.6,69.04 50.14,69.04 49.48,69.71 47.53,69.71 46.87,69.04 39.26,69.04 34.6,64.39 33.38,64.39 27.2,58.21 27.2,45.01 29.12,43.09 v2(29.17,43.09)
  BOTTOM w0.076: v2(72.55,63.12) 72.77,62.9 74.63,62.9 U2030.BB48
M_B_A9: length 181
  TOP w0.102: v2(28.97,41.57) 28.97,41.03 29.12,40.88 29.79,40.88 30.88,39.79 33.05,39.79 33.52,40.26 34.69,40.26 U2012.R7 ; U2010.R7 34.67,74.89 33.76,74.89 33.31,74.44 32.77,74.44 32.24,73.91 29.7,73.91 29.61,74 29.61,74.47 29.53,74.56 29.4,74.56 29.31,74.47 29.31,74 29.22,73.91 29,73.91 v2(28.87,73.77) ; U2009.R7 34.78,87.76 34.24,88.3 32.53,88.3 32.12,88.71 32.12,88.84 32.41,89.13 32.41,89.28 32.32,89.37 32.22,89.37 31.91,89.05 31.78,89.05 31.27,89.57 v2(31.27,90.25) ; v2(29.94,54.45) 30.66,53.73 30.81,53.73 31.15,54.06 31.3,54.06 31.38,53.99 31.38,53.81 31.11,53.54 31.11,53.28 31.31,53.07 33.02,53.07 33.4,53.45 34.42,53.45 34.78,53.09 U2011.R7
  TOP w0.165: R2119.2 30.8,90.72 v2(31.27,90.25)
  IN1 w0.089: v2(28.97,41.57) 28.64,41.9 28.64,42.03 29.09,42.48 29.17,42.48 29.32,42.33 29.32,42.2 29.2,42.07 29.2,41.94 29.34,41.79 29.34,41.59 29.95,40.98 30.08,40.98 30.14,41.05 30.14,41.2 29.58,41.76 29.58,41.9 29.65,41.97 29.75,41.97 29.96,41.77 30.09,41.77 30.18,41.86 30.18,41.95 29.89,42.23 29.89,42.39 30.06,42.56 30.06,43.12 30.6,43.66 30.78,43.66 30.97,43.47 31.08,43.47 31.15,43.55 31.15,43.75 30.77,44.13 30.77,44.28 31.03,44.54 31.03,46.7 29.68,48.05 29.68,52.18 29.76,52.27 29.87,52.27 29.96,52.35 29.96,52.47 29.87,52.56 29.76,52.56 29.68,52.64 29.68,52.76 29.76,52.85 29.87,52.85 29.96,52.94 29.96,53.06 29.87,53.14 29.76,53.14 29.68,53.23 29.68,53.35 29.76,53.43 29.87,53.43 29.96,53.52 29.96,53.64 29.87,53.73 29.76,53.73 29.68,53.81 29.68,54.19 v2(29.94,54.45) 29.8,54.59 29.8,57.83 29.27,58.36 29.27,59.96 29.37,60.06 29.73,60.06 29.83,60.16 29.83,60.36 29.73,60.46 29.37,60.46 29.27,60.57 29.27,60.77 29.37,60.87 29.73,60.87 29.83,60.97 29.83,61.17 29.73,61.28 29.37,61.28 29.27,61.38 29.27,61.59 29.37,61.69 29.69,61.69 29.8,61.8 29.8,67.93 29.25,68.48 29.25,71.39 29.14,71.49 28.93,71.49 28.83,71.59 28.83,71.8 28.93,71.9 29.14,71.9 29.25,72 29.25,72.2 29.14,72.3 28.95,72.3 28.84,72.42 28.84,72.62 28.93,72.71 29.14,72.71 29.25,72.81 29.25,73.39 v2(28.87,73.77) 28.76,73.88 28.76,74.74 28.85,74.84 28.96,74.84 29.05,74.93 29.05,75.05 28.96,75.14 28.81,75.14 28.73,75.22 28.73,75.35 28.82,75.45 28.96,75.45 29.05,75.53 29.05,76.14 29.46,76.54 29.46,82.3 29.53,82.37 30.26,82.37 30.35,82.46 30.35,82.59 30.26,82.67 29.53,82.67 29.46,82.75 29.46,84.95 29.55,85.04 29.88,85.04 29.97,85.13 29.97,85.25 29.88,85.34 29.55,85.34 29.46,85.43 29.46,85.62 29.54,85.69 29.86,85.69 29.94,85.77 29.94,88.04 31.27,89.37 v2(31.27,90.25)
  IN3 w0.14: v2(79.49,64.49) 79.15,64.83 76.91,64.83 76.84,64.91 75.98,64.91 74.39,66.5 73.75,66.5 70.8,69.45 69.57,69.45 69.16,69.85 67.27,69.85 66.3,70.83 57.82,70.83 57.14,71.51 51.54,71.51 51.02,70.99 41.17,70.99 40.58,70.39 38.89,70.39 38.37,69.88 38.15,69.88 37.88,70.14 37.65,70.14 37.53,70.01 37.53,69.84 37.85,69.51 37.85,69.36 37.7,69.2 37.47,69.2 37.1,69.58 36.92,69.58 36.76,69.42 36.76,69.22 37.13,68.85 37.13,68.67 37.01,68.55 36.84,68.55 36.49,68.9 36.31,68.9 36.19,68.78 36.19,68.6 36.54,68.25 36.54,68.11 36.42,67.98 36.22,67.98 35.89,68.31 35.74,68.31 35.62,68.18 35.62,67.98 35.95,67.66 35.95,67.49 35.82,67.36 35.65,67.36 35.28,67.74 35.08,67.74 26.03,58.69 26.03,44.08 28.55,41.57 v2(28.97,41.57)
  BOTTOM w0.165: v2(79.49,64.49) 79.49,64.43 79.81,64 U2030.AP50
M_B_A10: length 176.1
  TOP w0.102: U2012.M3 37.47,42.51 37.33,42.37 37.11,42.37 36.93,42.56 36.62,42.56 36.52,42.45 36.52,42.12 36.74,41.9 36.74,41.36 36.41,41.04 v2(35.92,41.04) ; U2009.M3 37.11,91.32 v2(37.11,91.35) ; v2(36.33,76.62) 36.39,76.62 U2010.M3 ; v2(36.19,55.08) 36.19,55.34 37.14,56.29 U2011.M3
  TOP w0.165: v1(36.41,98.28) 35.9,98.79 R2105.2
  IN1 w0.089: v2(35.92,41.04) 36.06,41.04 36.15,40.94 36.15,40.41 36.27,40.29 36.41,40.29 36.5,40.39 36.5,41.17 36.57,41.23 36.75,41.23 36.82,41.17 36.82,40.01 36.93,39.89 37.47,39.89 37.54,39.96 37.54,40.1 37.48,40.16 37.26,40.16 37.17,40.25 37.17,40.4 37.25,40.47 37.44,40.47 37.53,40.56 37.53,40.69 37.44,40.78 37.22,40.78 37.12,40.88 37.12,41.01 37.19,41.07 37.46,41.07 37.53,41.14 37.53,41.28 37.45,41.36 37.11,41.36 36.86,41.62 36.86,43.37 36.55,43.68 36.55,50.1 35.86,50.79 35.86,54.75 v2(36.19,55.08) 36.41,55.3 36.41,56.59 36.5,56.68 36.5,65.91 36.9,66.3 36.9,70.23 36.51,70.61 36.51,70.75 36.61,70.85 36.61,71 36.5,71.12 36.37,71.12 36.25,71 36.08,71 35.85,71.23 35.85,75.36 35.66,75.55 35.66,76.46 35.82,76.62 v2(36.33,76.62) 36.33,76.91 35.97,77.27 35.97,80.97 35.79,81.15 35.5,81.15 35.38,81.26 35.38,84.21 35.69,84.52 35.69,87.22 35.59,87.32 35.43,87.32 35.33,87.42 35.33,87.63 35.43,87.73 35.59,87.73 35.69,87.83 35.69,88.11 36.11,88.52 36.11,90.32 36.66,90.88 36.66,92.76 36.77,92.87 36.93,92.87 37.02,92.79 37.02,92.14 37.09,92.07 37.97,92.07 38.08,91.96 38.08,91.74 37.99,91.64 37.39,91.64 v2(37.11,91.35)
  IN3 w0.102: v2(37.11,91.35) 37.4,91.65 37.4,96.42 36.38,97.44 36.38,98.25 v1(36.41,98.28)
  IN3 w0.14: v2(69.89,60.64) 69.7,60.84 68.77,60.84 68.16,61.45 66.23,61.45 65.68,60.9 63.35,60.9 63.16,61.09 63.16,61.59 63,61.76 62.67,62.08 56.4,62.08 55.77,61.45 55.61,61.45 55.51,61.56 55.51,62.34 55.39,62.46 55.21,62.46 55.09,62.33 55.09,60.24 54.99,60.14 54.77,60.14 54.65,60.27 54.65,61.67 54.55,61.77 54.33,61.77 54.23,61.67 54.23,60.27 54.11,60.14 53.94,60.14 53.81,60.27 53.81,61.68 53.71,61.79 53.16,61.79 53.03,61.65 53.03,61.51 53.39,61.15 53.39,60.27 53.27,60.14 53.1,60.14 52.98,60.27 52.98,60.66 52.85,60.79 52.68,60.79 52.56,60.66 52.56,60.27 52.43,60.14 52.22,60.14 52.11,60.26 52.11,60.72 52,60.82 51.73,60.82 51.6,60.69 51.6,60.27 51.47,60.14 51.35,60.14 51.14,60.35 51.14,60.59 51.04,60.69 50.81,60.69 50.68,60.81 50.68,60.99 51.36,61.67 51.36,61.87 51.23,61.99 51.09,61.99 50.38,61.29 50.21,61.29 50.08,61.41 50.08,61.59 50.76,62.27 50.76,62.42 50.61,62.57 50.48,62.57 49.47,61.56 49.32,61.56 49.19,61.7 49.19,61.86 50,62.67 50,62.83 49.87,62.96 48.84,62.96 48.72,62.84 48.72,62.63 48.56,62.46 48.42,62.46 47.93,62.96 40.93,62.96 36.59,58.61 36.59,57.2 35.91,56.52 35.29,56.52 35.05,56.27 35.05,55.55 35.16,55.44 35.37,55.44 35.5,55.31 35.5,55.01 35.38,54.89 33.82,54.89 33.71,54.79 33.71,52.89 33.99,52.61 33.99,52.28 33.79,52.08 33.79,51.63 33.39,51.22 33.39,50.8 33.73,50.46 33.73,49.15 34.31,48.56 34.31,47.5 34.55,47.26 34.55,45.7 34.67,45.59 35.25,45.59 35.32,45.52 35.82,45.52 36.05,45.3 36.05,41.69 35.9,41.55 34.57,41.55 34.45,41.43 34.45,41.21 34.56,41.11 35.84,41.11 v2(35.92,41.04)
  BOTTOM w0.076: 72.55,61.1 72.66,60.99 72.66,60.55 72.86,60.35 73.22,60.35 73.47,60.59 73.47,60.9 73.6,61.03 75.06,61.03 75.08,61.06 75.41,61.06 75.62,61.27 76.12,61.27 76.32,61.37 76.51,61.56 U2030.AW46
  BOTTOM w0.102: v2(69.89,60.64) 68.47,60.64 68.37,60.75 68.37,61 68.47,61.1 72.55,61.1
M_B_A11: length 188.6
  TOP w0.102: U2011.T2 34.19,57.01 29.96,57.01 29.42,56.46 v2(28.83,56.46) ; v2(28.68,77.51) 30.12,77.51 31.11,78.5 U2010.T2 ; U2009.T2 33.55,91.76 32.66,92.65 32.66,94.67 v2(32.97,94.98) ; v2(28.59,42.51) 28.4,42.69 v1(28.4,43.71) 28.58,43.88 U2012.T2
  TOP w0.165: v1(31.89,100.75) 31.89,101.09 R2092.2
  IN1 w0.089: v2(32.97,94.98) 32.44,94.44 32.44,93.51 32.35,93.42 32.1,93.42 32.01,93.33 32.01,93.2 32.1,93.11 32.35,93.11 32.44,93.02 32.44,92.54 30.15,90.25 30.15,89.12 29.28,88.25 29.28,86.47 28.86,86.05 28.86,85.87 28.76,85.77 28.42,85.77 28.32,85.67 28.32,85.46 28.42,85.36 28.76,85.36 28.86,85.26 28.86,83.22 28.76,83.12 28.15,83.12 28.05,83.02 28.05,82.82 28.16,82.71 28.76,82.71 28.86,82.61 28.86,77.69 v2(28.68,77.51) 28.64,77.51 28.11,76.98 28.11,71.08 28.89,70.3 28.89,68.1 29.04,67.95 29.04,67.63 28.94,67.52 28.71,67.52 28.63,67.44 28.63,64.13 28.96,63.8 28.96,63.18 28.67,62.89 28.67,59.01 28.52,58.86 28.52,56.76 v2(28.83,56.46) 29.09,56.19 29.09,47.33 29.2,47.23 29.55,47.23 29.63,47.15 29.63,47 29.55,46.93 29.02,46.93 28.89,46.8 28.89,46.62 28.97,46.54 30.23,46.54 30.36,46.42 30.36,46.24 30.28,46.16 28.84,46.16 28.71,46.04 28.71,45.91 28.81,45.81 30.28,45.81 30.36,45.73 30.36,45.55 30.26,45.45 28.92,45.45 28.81,45.35 28.81,45.17 28.89,45.1 29.53,45.1 29.61,45.01 29.61,44.91 28.89,44.18 28.89,44.08 28.59,43.78 v2(28.59,42.51)
  IN3 w0.089: v2(80.13,63.56) 80.13,63.83 80.03,63.92 78.94,63.92 78.61,64.25 77.07,64.25 76.98,64.16 76.9,64.16
  IN3 w0.102: v2(32.97,94.98) 32.27,95.68 32.27,100.36 v1(31.89,100.75)
  IN3 w0.14: v2(28.59,42.51) 26.62,44.48 26.62,58.45 33.5,65.34 33.77,65.34 34.14,64.97 34.36,64.97 34.49,65.1 34.49,65.28 34.05,65.71 34.05,65.89 34.17,66.01 34.35,66.01 34.79,65.57 34.96,65.57 35.08,65.7 35.08,65.87 34.69,66.26 34.69,66.43 34.82,66.55 34.99,66.55 35.38,66.17 35.55,66.17 39.13,69.75 40.76,69.75 41.42,70.4 42.66,70.4 42.78,70.28 42.78,69.8 42.9,69.68 43.08,69.68 43.2,69.8 43.2,70.23 43.32,70.35 43.5,70.35 43.62,70.23 43.62,69.8 43.74,69.68 43.91,69.68 44.04,69.8 44.04,70.23 44.16,70.35 44.33,70.35 44.46,70.23 44.46,69.8 44.58,69.68 44.75,69.68 44.88,69.8 44.88,70.23 45,70.35 45.17,70.35 45.29,70.23 45.29,69.8 45.42,69.68 45.59,69.68 45.71,69.8 45.71,70.23 45.84,70.35 46.01,70.35 46.13,70.23 46.13,69.8 46.26,69.68 46.43,69.68 46.55,69.8 46.55,70.28 46.67,70.4 51.23,70.4 51.39,70.24 64.52,70.24 64.64,70.12 64.64,69.06 64.76,68.93 64.94,68.93 65.06,69.06 65.06,70.12 65.18,70.24 65.39,70.24 65.54,70.09 65.54,69.1 65.67,68.97 65.85,68.97 65.97,69.1 65.97,69.76 66.1,69.89 66.31,69.89 66.46,69.73 66.46,69.46 66.67,69.24 69.01,69.24 69.32,68.93 70.5,68.93 75.27,64.16 76.9,64.16
  BOTTOM w0.102: U2030.AN48 80.46,63.06
  BOTTOM w0.165: 80.46,63.06 v2(80.13,63.56)
M_B_A12: length 175.6
  TOP w0.102: U2010.M7 37.26,74.5 36.6,75.16 v2(36.6,75.46) ; U2011.M7 37.11,53.45 v2(37.11,53.5) ; v2(38.34,36.25) 37.85,38.01 37.85,39.3 37.47,39.68 U2012.M7 ; U2009.M7 37.47,89.02 v2(37.03,89.45)
  TOP w0.165: R2111.2 33.59,96.55 33.92,96.21 v2(33.92,95.72)
  IN1 w0.089: v2(38.34,36.25) 38.17,36.25 37.93,36.49 37.93,36.74 38.01,36.82 38.19,36.82 38.26,36.89 38.26,37.04 38.19,37.12 37.5,37.12 37.4,37.22 37.4,37.37 37.5,37.48 38.06,37.48 38.14,37.55 38.14,37.71 38.03,37.81 37.53,37.81 37.42,37.91 37.42,38.11 37.5,38.19 37.82,38.19 37.91,38.28 37.91,38.44 37.85,38.5 36.98,38.5 36.88,38.59 36.88,38.73 37.04,38.88 37.74,38.88 37.82,38.96 37.82,39.15 37.58,39.39 37.58,39.64 37.82,39.88 37.82,41.85 37.66,42.01 37.66,43.36 37.13,43.9 37.13,46.44 37.52,46.84 37.52,51.83 37.12,52.23 36.86,52.23 36.61,52.48 36.61,52.81 37.11,53.32 v2(37.11,53.5) 36.92,53.7 36.92,54.58 37.35,55.02 37.35,55.95 37.08,56.23 37.08,56.87 36.95,56.99 36.95,59.01 37.16,59.22 37.16,65.68 37.53,66.06 37.53,71.1 36.38,72.25 36.38,75.24 v2(36.6,75.46) 36.6,75.73 37.06,76.2 37.06,77.36 36.56,77.86 36.56,81.53 36.34,81.75 35.98,81.75 35.88,81.85 35.88,82.01 35.98,82.12 36.27,82.12 36.35,82.2 36.35,82.4 36.27,82.47 35.97,82.47 35.89,82.55 35.89,82.81 35.97,82.89 36.2,82.89 36.32,83.01 36.32,86.99 36.51,87.18 36.51,87.3 36.25,87.57 36.25,87.69 36.33,87.78 37.3,87.78 37.39,87.86 37.39,88.05 37.32,88.13 36.77,88.13 36.66,88.23 36.66,88.37 36.77,88.48 37.28,88.48 37.36,88.56 37.36,89.41 37.32,89.45 v2(37.03,89.45)
  IN3 w0.089: v2(80.11,64.41) 79.61,64.11 79.41,64.11 78.53,64.5 78.14,64.5
  IN3 w0.102: v2(33.92,95.72) 34.18,95.58 34.79,93.56 34.79,91.43 36.77,89.45 v2(37.03,89.45)
  IN3 w0.14: 78.14,64.5 75.63,64.5 73.93,66.19 73.65,66.19 70.62,69.22 69.47,69.22 69.16,69.53 67.18,69.53 66.18,70.53 51.51,70.53 51.35,70.7 41.3,70.7 40.64,70.04 38.95,70.04 35.75,66.84 34.59,66.84 26.32,58.57 26.32,44.2 28.48,42.05 29.11,42.05 29.45,41.71 29.45,41.48 29.21,41.25 29.21,40.12 33.56,35.77 34.98,35.77 35.66,35.09 36.78,35.09 37.11,35.34 v2(38.34,36.25)
  BOTTOM w0.165: v2(80.11,64.41) U2030.AN50
M_B_A13: length 163.7
  TOP w0.102: U2011.T8 33.75,52.29 v2(33.59,52.45) ; v2(33.06,87.12) 33.22,86.96 U2009.T8 ; U2010.T8 33.3,73.7 v2(33.17,73.56) ; v2(34.67,38.68) U2012.T8
  TOP w0.165: R2121.2 30.72,89.7 v2(30.83,89.59)
  IN1 w0.089: v2(33.06,87.12) 33.37,87.43 33.59,87.43 33.67,87.35 33.67,86.47 33.4,86.2 33.4,84.94 33.51,84.83 33.51,80.99 33.34,80.82 33.1,80.82 32.63,80.36 32.63,79.19 33.27,78.55 33.63,78.55 33.87,78.31 33.87,76.96 33.63,76.73 33.63,76.07 33.55,75.98 32.74,75.98 32.65,75.89 32.65,75.76 32.74,75.67 33.55,75.67 33.64,75.58 33.64,75.46 33.55,75.37 32.74,75.37 32.65,75.28 32.65,75.15 32.74,75.06 33.14,75.06 33.23,74.98 33.23,74.85 33.13,74.76 32.74,74.76 32.65,74.67 32.65,73.73 32.82,73.56 v2(33.17,73.56) 32.6,72.99 32.6,72 33.4,71.19 33.4,66.3 32.74,65.64 32.74,59.95 33.37,59.31 33.37,58.99 32.95,58.56 32.95,58.16 33.06,58.06 33.59,57.52 v2(33.59,52.45) 33.89,52.15 33.89,51.5 33.51,51.12 33.51,50.56 33.89,50.18 33.89,46.37 34.43,45.83 34.43,41.82 34.15,41.54 34.15,39.18 33.51,38.54 33.51,38.39 35.09,36.82 35.28,36.82 35.37,36.9 35.37,37.12 35.06,37.43 35.06,37.55 35.34,37.83 35.34,37.97 35.25,38.06 35.11,38.06 34.86,37.81 34.68,37.81 34.33,38.16 34.33,38.34 v2(34.67,38.68)
  IN3 w0.102: v2(30.83,89.59) 33.06,87.36 v2(33.06,87.12)
  IN3 w0.14: v2(34.67,38.68) 34.67,38.94 34.81,39.08 35.04,39.08 35.15,38.96 35.15,38.5 35.28,38.37 35.49,38.37 35.6,38.47 35.6,38.9 35.72,39.03 35.95,39.03 36.05,38.92 36.05,38.5 36.18,38.37 36.36,38.37 36.71,38.73 36.71,38.95 35.93,39.74 35.93,39.91 36.1,40.09 36.33,40.09 36.57,39.86 37.38,39.86 37.56,40.04 37.56,40.27 37.46,40.37 36.79,40.37 36.69,40.47 36.69,40.8 36.79,40.91 37.45,40.91 37.55,41.01 37.55,41.24 37.42,41.37 36.79,41.37 36.63,41.53 36.63,45.55 36.73,45.64 37.58,45.64 37.73,45.79 37.73,45.94 37.6,46.06 36.11,46.06 35.99,46.19 35.99,46.36 36.11,46.48 37.75,46.48 37.87,46.6 37.87,46.78 37.75,46.9 36.78,46.9 36.66,47.02 36.66,47.2 36.78,47.32 37.75,47.32 37.87,47.44 37.87,47.62 37.75,47.74 37.06,47.74 36.94,47.86 36.94,48.04 37.06,48.16 37.84,48.16 37.96,48.28 37.96,48.45 37.84,48.58 37.06,48.58 36.94,48.7 36.94,48.87 37.06,49 37.74,49 37.87,49.13 37.87,49.32 37.75,49.44 36.88,49.44 36.75,49.56 36.75,49.73 36.88,49.86 37.75,49.86 37.87,49.98 37.87,50.15 37.75,50.28 36.89,50.28 36.78,50.39 36.78,50.59 36.93,50.73 37.73,50.73 37.87,50.88 37.87,51.03 37.75,51.15 37.08,51.15 36.95,51.28 36.95,51.45 37.08,51.57 37.75,51.57 37.87,51.7 37.87,51.87 37.75,51.99 37.42,51.99 37.27,52.14 37.27,52.31 37.36,52.41 37.75,52.41 37.87,52.53 37.87,52.69 37.79,52.77 37.55,52.77 37.45,52.87 37.45,53.17 37.58,53.3 37.78,53.3 37.89,53.41 37.89,53.61 37.77,53.72 37.54,53.72 37.36,53.9 37.36,54.34 37.87,54.85 37.87,56.94 37.46,57.35 37.46,58.25 41.29,62.08 47.56,62.08 49.05,60.59 49.66,60.59 50.99,59.27 56.73,59.27 58.03,60.58 58.92,60.58 59.56,61.21 60.88,61.21 61.28,60.8 61.28,59.85 61.83,59.3 65.85,59.3 66.38,59.83 68.5,59.83 69.02,59.31 70.55,59.31 71.21,59.97 71.41,59.97 71.54,59.84 71.54,59.67 v2(70.78,58.92)
  BOTTOM w0.076: U2030.BA43 75.5,59.55 75.28,59.55 75.13,59.49 75.03,59.39 74.59,59.39 74.48,59.28 73.68,59.28 73.6,59.36 72.39,59.36 72.21,59.53 71.87,59.53
  BOTTOM w0.102: v2(70.78,58.92) 70.78,59.42 70.9,59.53 71.87,59.53
M_B_A14: length 182.9
  TOP w0.102: v2(37.31,41.77) 37.31,41.07 37.2,40.97 36.89,40.97 36.72,40.8 36.72,40.6 36.89,40.43 37.67,40.43 37.89,40.66 37.89,43.5 U2012.L2 ; v2(36.69,90.33) 36.93,90.58 37.66,90.58 37.87,90.79 37.87,91.35 U2009.L2 ; v2(36.91,55.25) 37.63,55.25 37.84,55.47 37.84,56.66 U2011.L2 ; v2(36.12,75.89) 36.42,75.89 37.87,77.34 37.87,78.09 U2010.L2
  TOP w0.165: v1(34.81,98.33) 34.89,98.41 R2106.2
  IN1 w0.089: v2(37.31,41.77) 37.31,43.32 36.86,43.77 36.86,46.77 36.95,46.86 37.17,46.86 37.26,46.94 37.26,47.07 37.17,47.16 36.95,47.16 36.86,47.25 36.86,47.38 36.95,47.47 37.17,47.47 37.26,47.55 37.26,47.68 37.17,47.77 36.95,47.77 36.86,47.86 36.86,47.99 36.95,48.07 37.17,48.07 37.26,48.16 37.26,48.29 37.17,48.38 36.95,48.38 36.86,48.47 36.86,48.6 36.95,48.68 37.17,48.68 37.26,48.77 37.26,48.9 37.17,48.99 36.95,48.99 36.86,49.08 36.86,49.2 36.95,49.29 37.17,49.29 37.26,49.38 37.26,49.51 37.17,49.6 36.95,49.6 36.87,49.68 36.87,49.84 36.97,49.94 37.19,49.94 37.27,50.02 37.27,50.13 37.2,50.2 36.79,50.2 36.71,50.28 36.71,50.38 36.79,50.46 37.22,50.46 37.27,50.51 37.27,50.69 37.22,50.74 36.79,50.74 36.69,50.84 36.69,50.99 36.76,51.07 37.2,51.07 37.27,51.14 37.27,51.29 37.17,51.4 36.53,51.4 36.43,51.49 36.43,51.62 36.51,51.7 36.97,51.7 37.05,51.79 37.05,51.89 36.95,51.99 36.27,51.99 36.18,52.08 36.18,52.5 36.24,52.56 36.31,52.56 36.38,52.64 36.38,52.77 36.31,52.84 36.23,52.84 36.18,52.9 36.18,53.17 36.27,53.26 36.6,53.26 36.7,53.35 36.7,53.48 36.61,53.57 36.25,53.57 36.18,53.63 36.18,53.81 36.28,53.91 36.61,53.91 36.69,53.99 36.69,54.14 36.61,54.22 36.28,54.22 36.18,54.32 36.18,54.49 36.24,54.55 36.57,54.55 36.91,54.89 v2(36.91,55.25) 36.91,55.91 36.71,56.11 36.71,59.24 36.85,59.38 36.85,65.8 37.18,66.14 37.18,70.29 36.87,70.61 36.87,70.73 37.1,70.95 37.1,71.12 36.66,71.56 36.56,71.56 36.36,71.36 36.23,71.36 36.12,71.47 v2(36.12,75.89) 36.26,75.89 36.77,76.4 36.77,77.07 36.27,77.57 36.27,81.37 36.16,81.48 35.79,81.48 35.63,81.65 35.63,83.17 35.73,83.27 35.96,83.27 36.06,83.37 36.06,83.57 35.96,83.68 35.73,83.68 35.63,83.78 35.63,83.97 35.72,84.06 35.91,84.06 36.01,84.16 36.01,87.96 36.47,88.42 36.47,88.69 36.54,88.75 36.84,88.75 36.93,88.84 36.93,88.98 36.79,89.13 36.47,89.13 36.36,89.24 36.36,89.58 36.46,89.68 36.67,89.68 37.14,90.15 37.14,90.32 37.61,90.8 37.98,90.8 38.08,90.89 38.08,91.16 38.01,91.23 37.59,91.23 36.69,90.33 v2(36.69,90.33)
  IN3 w0.102: v1(34.81,98.33) 35.16,97.02 35.97,96.55 36.28,94.65 36.5,91.88 v2(36.69,90.33)
  IN3 w0.14: v2(37.31,41.77) 37.6,41.77 37.75,41.91 37.75,42.18 37.65,42.28 37.02,42.28 36.92,42.38 36.92,42.62 37.05,42.74 37.93,42.74 38.06,42.87 38.06,43.04 37.93,43.16 37.05,43.16 36.92,43.28 36.92,43.46 37.05,43.58 38.14,43.58 38.4,43.32 38.59,43.32 38.73,43.46 38.73,43.88 38.61,44 37.05,44 36.92,44.12 36.92,44.3 37.05,44.42 38.07,44.42 38.19,44.54 38.19,44.71 38.06,44.84 37.05,44.84 36.92,44.96 36.92,45.23 37.04,45.35 37.7,45.35 38.02,45.67 38.02,45.94 38.26,46.17 38.26,46.73 38.17,46.82 38.17,47.2 38.23,47.27 38.23,47.67 38.1,47.81 38.1,48 38.21,48.12 38.81,48.12 38.93,48.24 38.93,48.44 38.83,48.54 38.29,48.54 38.17,48.66 38.17,48.84 38.29,48.96 39.49,48.96 39.6,49.06 39.6,49.28 39.49,49.38 38.27,49.38 38.17,49.48 38.17,49.69 38.27,49.8 39.13,49.8 39.26,49.92 39.26,50.09 39.13,50.22 38.27,50.22 38.17,50.32 38.17,50.53 38.27,50.63 38.99,50.63 39.09,50.74 39.09,50.95 38.99,51.05 38.27,51.05 38.17,51.16 38.17,51.37 38.27,51.47 38.99,51.47 39.09,51.57 39.09,51.69 39.07,51.71 39.07,51.81 38.99,51.89 38.25,51.89 38.15,51.99 38.15,52.21 38.25,52.31 39.43,52.31 39.56,52.43 39.56,52.61 39.26,52.91 39.11,52.91 38.94,52.73 38.24,52.73 38.17,52.8 38.17,52.81 38.1,52.87 38.1,53.01 38.24,53.15 38.64,53.15 38.78,53.29 38.78,53.43 38.64,53.57 38.29,53.57 38.17,53.69 38.17,56.27 38.29,56.39 38.29,57.87 38.19,57.97 37.98,57.97 37.88,58.08 37.88,58.26 41.36,61.74 47.49,61.74 48.93,60.3 49.54,60.3 50.86,58.97 56.91,58.97 56.99,58.9 57.25,58.9 57.36,59 57.36,59.43 57.48,59.55 57.66,59.55 57.83,59.39 57.83,59 57.93,58.9 58.23,58.9 58.57,59.25 58.57,59.39 58.49,59.48 58.34,59.48 57.92,59.9 57.92,60.05 58.16,60.28 59.43,60.28 59.53,60.38 59.53,60.75 59.69,60.91 60.76,60.91 60.99,60.68 60.99,60.23 60.79,60.03 60.44,60.03 60.34,59.93 60.34,59.63 60.48,59.49 61.19,59.49 61.68,59 65.97,59 66.5,59.54 68.34,59.54 68.95,58.93 69.53,58.93 v2(69.62,58.84)
  BOTTOM w0.076: U2030.AY44 75.8,60.34 75.7,60.24 75.47,60.16 75.34,60.16 75.19,60.2 75.11,60.22 74.97,60.22 74.88,60.18 74.83,60.17 74.58,60.17 74.44,60.31 74.12,60.31 73.5,59.69 72.53,59.69 72.27,59.94 70.7,59.94 70.08,59.32 69.66,59.32
  BOTTOM w0.102: v2(69.62,58.84) 67.78,58.84 67.68,58.94 67.68,59.22 67.78,59.32 69.66,59.32
M_B_A15: length 177.7
  TOP w0.102: v2(36.06,50) 36.31,50 36.59,50.28 36.79,50.28 37.07,50 37.22,50 37.36,50.14 37.36,50.28 37.13,50.52 37.13,50.69 37.25,50.81 37.4,50.81 37.6,50.61 37.73,50.61 37.84,50.72 37.84,51.92 U2011.M8 ; U2010.M8 37.08,74.08 36.44,74.08 36.28,73.92 36.28,71.23 36.09,71.04 35.95,71.04 35.83,71.16 35.65,71.16 35.32,70.83 v2(35.32,70.49) ; v2(37.05,39.46) 37.05,39.44 37.41,39.08 U2012.M8 ; U2009.M8 37.07,86.56 36.55,86.56 36.25,86.25 36.25,85.87 v2(35.23,84.86)
  TOP w0.165: v2(30.92,85.69) 30.92,85.86 R2130.2
  IN1 w0.089: v2(35.23,84.86) 35.07,84.7 35.07,81.39 34.99,81.31 34.99,79.55 35.58,78.96 35.58,76.87 35.44,76.73 35.44,75.97 35.35,75.89 35.31,75.89 35.22,75.8 35.22,75.61 35.13,75.52 35.04,75.52 34.95,75.43 34.95,75.31 35.04,75.22 35.41,75.22 35.5,75.13 35.5,75 35.41,74.91 35.04,74.91 34.95,74.82 34.95,74.7 35.04,74.61 35.35,74.61 35.44,74.52 35.44,74.39 35.35,74.3 35.04,74.3 34.95,74.21 34.95,74.09 35.04,74 35.38,74 35.47,73.91 35.47,73.78 35.38,73.69 35.04,73.69 34.95,73.6 34.95,73.48 35.04,73.39 35.48,73.39 35.57,73.3 35.57,73.17 35.48,73.08 35.04,73.08 34.95,72.99 34.95,72.87 35.04,72.78 35.51,72.78 35.6,72.69 35.6,72.56 35.51,72.47 35.04,72.47 34.95,72.38 34.95,72.26 35.04,72.17 35.52,72.17 35.61,72.08 35.61,71.95 35.52,71.86 35.04,71.86 34.95,71.77 34.95,71.65 35.04,71.56 35.51,71.56 35.6,71.47 35.6,71.34 35.51,71.25 35.04,71.25 34.95,71.17 34.95,71.04 35.04,70.95 35.13,70.95 35.22,70.86 35.22,70.58 v2(35.32,70.49) 35.8,70.01 36.24,70.01 36.48,69.76 36.48,66.37 36.11,65.99 36.11,59.77 36.3,59.58 36.3,57.15 36.14,56.99 36.14,55.6 35.53,54.99 35.53,50.53 v2(36.06,50) 36.27,49.79 36.27,43.52 36.58,43.21 36.58,41.54 36.49,41.44 36.33,41.44 36.23,41.54 36.23,41.87 36.17,41.93 36.02,41.93 35.95,41.87 35.95,41.57 35.83,41.44 35.54,41.44 35.47,41.36 35.47,40.67 35.27,40.47 35.27,40.32 35.35,40.24 35.47,40.24 35.73,40.5 35.85,40.5 35.94,40.41 35.94,40.29 35.68,40.02 35.68,39.87 35.77,39.78 35.87,39.78 36.16,40.07 36.39,40.07 36.47,39.98 36.47,39.84 36.05,39.42 36.05,39.23 36.49,38.8 36.61,38.8 36.76,38.95 36.76,39.08 36.54,39.31 36.54,39.42 36.71,39.59 36.92,39.59 v2(37.05,39.46)
  IN3 w0.102: v2(35.23,84.86) 32.8,84.86 31.97,85.69 v2(30.92,85.69)
  IN3 w0.14: v2(70.2,58.91) 70.2,58.63 69.99,58.41 69.01,58.41 68.17,59.25 66.62,59.25 66.09,58.71 61.56,58.71 61.07,59.2 58.94,59.2 58.35,58.61 56.87,58.61 56.79,58.68 50.74,58.68 49.42,60.01 48.81,60.01 47.37,61.44 41.48,61.44 38.63,58.59 38.63,56.14 38.46,55.97 38.46,54.16 39.9,52.72 39.9,49.29 40,49.19 40.38,49.19 40.51,49.06 40.51,48.81 40.35,48.65 39.76,48.65 38.55,47.45 38.55,44.53 38.76,44.32 40.08,44.32 40.22,44.18 40.22,43.9 40.32,43.8 40.6,43.8 40.7,43.9 40.7,44.59 40.85,44.74 41.08,44.74 41.18,44.64 41.18,44.13 41.31,44 41.67,44 41.77,44.11 41.77,44.41 41.9,44.54 42.07,44.54 42.4,44.21 42.4,43.7 42.28,43.57 41.03,43.57 40.69,43.23 40.69,43.05 40.85,42.89 41.03,42.89 41.29,43.14 42.21,43.14 42.3,43.05 42.3,42.84 42.17,42.71 41.54,42.71 41.34,42.51 41.34,42.33 41.49,42.18 42.88,42.18 42.98,42.08 42.98,41.83 42.88,41.73 41.92,41.73 41.79,41.61 41.79,41.43 41.92,41.31 42.88,41.31 43,41.19 43,41.01 42.88,40.89 41.92,40.89 41.79,40.77 41.79,40.59 41.92,40.47 42.8,40.47 42.9,40.37 42.9,40.1 43.07,39.94 43.07,37.9 42.95,37.78 42.58,37.78 42.43,37.93 42.43,38.42 42.63,38.62 42.63,38.8 42.43,39 42.43,39.31 42.63,39.51 42.63,39.69 42.45,39.87 41.66,39.87 41.36,40.17 41.36,41.57 40.32,42.61 40.32,42.86 39.87,43.31 39.87,43.6 39.57,43.9 39.28,43.9 39.02,43.65 39.02,43.06 38.9,42.94 38.54,42.94 38.09,42.48 38.09,41.52 37.85,41.28 37.85,39.87 37.45,39.46 v2(37.05,39.46)
  BOTTOM w0.076: U2030.AY43 76.08,59.96 75.98,59.96 75.96,59.97 75.89,60.04 75.66,60.05 75.53,60 75.5,59.99 75.32,59.99 75.3,60 75.17,60.04 75.14,60.04 75.09,60.06 75.01,60.06 74.94,60.03 74.85,60 74.51,60 74.47,60.05 74.35,60.08 74.13,60.08 73.57,59.52 72.46,59.52 72.22,59.75 71.13,59.75
  BOTTOM w0.102: 71.13,59.75 70.78,59.75 70.2,59.18 v2(70.2,58.91)
M_B_A16: length 177.2
  TOP w0.102: U2010.L8 37.96,73.7 37.8,73.86 37.8,75.38 37.7,75.48 v2(37.51,75.48) ; U2011.L8 37.88,52.68 37.88,53.35 37.25,53.99 37.25,54.16 37.43,54.34 37.6,54.34 v2(37.76,54.18) ; U2012.L8 38.27,39.26 37.87,39.66 37.87,40.03 38.16,40.32 38.16,40.82 38.29,40.95 38.47,40.95 v2(38.63,40.79) ; U2009.L8 37.87,87.36 37.87,89.86 v2(37.6,90.13)
  TOP w0.165: v1(37.07,98.28) 37.07,98.84 R2107.2
  IN1 w0.089: v2(37.6,90.13) 37.6,84.84 36.9,84.14 36.9,83.61 36.99,83.52 37.44,83.52 37.53,83.43 37.53,83.3 37.44,83.22 36.94,83.22 36.86,83.14 36.86,83.01 36.96,82.91 37.44,82.91 37.53,82.82 37.53,82.69 37.44,82.61 36.93,82.61 36.86,82.53 36.86,82.34 36.94,82.26 37.41,82.26 37.51,82.16 37.51,82.04 37.41,81.94 37.23,81.94 37.14,81.85 37.14,81.7 37.33,81.51 37.33,81.19 37.24,81.1 37.15,81.1 37.06,81.01 37.06,80.89 37.16,80.79 37.24,80.79 37.33,80.7 37.33,80.58 37.24,80.49 37.15,80.49 37.06,80.4 37.06,80.28 37.16,80.18 37.24,80.18 37.33,80.1 37.33,79.97 37.24,79.88 37.15,79.88 37.06,79.79 37.06,79.67 37.16,79.57 37.24,79.57 37.33,79.49 37.33,79.36 37.24,79.27 37.15,79.27 37.06,79.18 37.06,79.06 37.16,78.97 37.38,78.97 37.47,78.88 37.47,78.75 37.38,78.66 37.15,78.66 37.06,78.57 37.06,78.45 37.16,78.36 37.38,78.36 37.46,78.28 37.46,78.03 37.6,77.89 37.6,75.57 v2(37.51,75.48) 37.58,75.4 37.58,71.74 38.24,71.07 38.24,65.3 38.16,65.21 37.76,65.21 37.66,65.11 37.66,64.91 37.76,64.8 38.16,64.8 38.24,64.72 38.24,64.52 37.71,63.98 37.71,58.18 37.45,57.91 37.45,57.29 37.61,57.13 37.61,56.61 38.01,56.21 38.01,54.81 37.76,54.57 v2(37.76,54.18) 38.03,53.91 38.03,46.65 38.31,46.37 38.31,46.29 38.24,46.21 37.79,46.21 37.74,46.16 37.74,46.05 37.83,45.96 38.29,45.96 38.38,45.87 38.38,45.74 38.29,45.66 37.79,45.66 37.7,45.57 37.7,44.67 37.85,44.52 38.53,44.52 38.63,44.42 38.63,44.25 38.54,44.16 37.96,44.16 37.88,44.08 37.88,43.94 37.97,43.85 38.53,43.85 38.63,43.76 38.63,43.62 38.54,43.53 38.37,43.53 38.28,43.44 38.28,43.31 38.37,43.22 38.97,43.22 39.06,43.13 39.06,43.01 38.97,42.92 38.37,42.92 38.28,42.83 38.28,42.25 38.37,42.15 38.37,42.15 38.46,42.06 38.77,42.06 38.87,41.95 38.87,41.79 38.75,41.66 38.46,41.66 38.37,41.57 38.37,41.36 38.48,41.25 38.77,41.25 38.83,41.19 38.83,40.99 v2(38.63,40.79)
  IN3 w0.102: v2(37.6,90.13) 37.64,90.18 37.64,96.54 37.45,97.65 37.14,97.87 v1(37.07,98.28)
  IN3 w0.14: v2(72.23,60.68) 71.83,60.29 71.83,60.11 72.04,59.9 72.33,59.9 72.46,60.04 72.46,60.29 72.6,60.43 72.77,60.43 72.91,60.29 72.91,60.05 73.06,59.9 73.45,59.9 74.01,59.33 74.01,59.08 73.86,58.92 73.61,58.92 73.14,59.39 71.97,59.39 71.8,59.23 71.8,58.6 71.62,58.42 70.72,58.42 70.47,58.17 68.85,58.17 68.06,58.95 66.75,58.95 66.21,58.42 61.44,58.42 60.95,58.91 59.06,58.91 58.47,58.32 56.74,58.32 56.67,58.39 50.62,58.39 49.3,59.71 48.23,59.71 48.12,59.83 48.12,60.16 48.02,60.26 47.81,60.26 47.49,59.94 47.34,59.94 47.18,60.1 47.18,60.26 47.57,60.65 47.57,60.79 47.21,61.15 41.63,61.15 38.98,58.49 38.98,55.78 38.75,55.55 38.75,54.33 40.24,52.83 40.24,49.8 41.06,48.98 42.65,48.98 42.99,48.64 42.99,48.47 42.77,48.26 39.77,48.26 38.86,47.34 38.86,44.86 39.02,44.7 39.92,44.7 40.25,45.03 42.04,45.03 42.71,44.36 42.71,43.21 43.24,42.67 43.24,40.27 43.87,39.65 43.87,37.7 43.63,37.46 41.58,37.46 40.98,38.06 40.98,41.49 40.41,42.06 40.18,42.06 40.04,42.21 40.04,42.68 39.8,42.91 39.41,42.91 39.18,42.68 39.18,41.86 38.76,41.43 38.76,40.91 v2(38.63,40.79)
  BOTTOM w0.076: U2030.AW44 76.39,60.65 75.68,60.65 75.46,60.87 75.24,60.87 74.97,60.87 73.98,60.87 73.29,60.18 72.73,60.18 v2(72.23,60.68)
M_B_ACT#: length 173.2
  TOP w0.102: U2011.L3 38.7,56.72 v2(39.48,56.72) ; v2(39.79,40.96) 39.71,40.96 38.27,42.4 U2012.L3 ; U2010.L3 38.2,77.62 38.2,77.05 38.81,76.44 v2(39.14,76.44) ; U2009.L3 38.47,90.96 38.88,90.54 39.31,90.54 v2(39.36,90.5)
  TOP w0.165: v2(39.56,95.93) 39.56,96.62 R2110.2
  IN1 w0.089: v2(39.36,90.5) 39.74,90.5 39.91,90.67 39.91,91.27 40.07,91.42 40.18,91.42 40.3,91.3 40.49,91.3 40.6,91.4 40.6,92.05 40.69,92.15 40.93,92.15 41.02,92.07 41.02,91.17 38.71,88.87 38.71,84.69 39.17,84.23 39.17,84.06 39.06,83.95 38.95,83.95 38.85,83.85 38.85,83.71 38.95,83.61 39.08,83.61 39.17,83.52 39.17,80.62 40.01,79.78 40.01,77.31 v2(39.14,76.44) 38.98,76.27 38.98,74.81 39.28,74.51 39.28,74.24 39.15,74.11 39.15,73.97 39.27,73.85 39.43,73.85 39.59,74.01 39.78,74.01 39.96,73.82 39.96,68.66 40.08,68.54 40.34,68.54 40.61,68.27 40.61,60.8 40.1,60.29 40.1,60.21 40.51,59.8 40.51,59.67 40.34,59.5 40.23,59.5 39.83,59.91 39.72,59.91 38.98,59.17 38.98,57.22 v2(39.48,56.72) 39.74,56.72 39.82,56.65 39.82,56.38 39.95,56.25 39.95,54.69 40.08,54.56 40.08,54.03 39.99,53.94 39.62,53.94 39.54,53.86 39.54,53.73 39.63,53.63 39.99,53.63 40.08,53.55 40.08,53.42 39.99,53.33 39.61,53.33 39.53,53.25 39.53,53.12 39.62,53.02 39.99,53.02 40.08,52.94 40.08,52.12 39.91,51.95 39.91,50.07 39.83,50 39.61,50 39.51,49.9 39.51,49.71 39.42,49.62 39.29,49.62 39.2,49.53 39.2,49.4 39.29,49.31 39.52,49.31 39.61,49.22 39.61,49.09 39.52,49.01 39.29,49.01 39.2,48.92 39.2,48.79 39.29,48.7 39.54,48.7 39.73,48.52 39.73,47.62 39.51,47.4 39.51,46.2 40.94,44.77 40.94,41.69 40.23,40.97 39.8,40.97 v2(39.79,40.96)
  IN3 w0.089: v2(80.22,66.23) 80.24,66.21 80.51,65.99 81.06,65.67 81.18,65.55 81.24,65.41 81.24,63.23 80.97,62.96 80.78,62.96
  IN3 w0.102: v2(39.36,90.5) 39.94,91.08 39.94,93.61 39.56,93.99 v2(39.56,95.93)
  IN3 w0.14: 80.78,62.96 80.36,62.96 80.22,63.1 77.57,63.1 76.75,62.82 76.08,62.82 75.5,63.21 73.64,63.21 72.7,62.28 69.71,62.28 68.48,63.51 68.48,63.67 68.18,63.97 67.12,63.97 65.69,65.4 58.09,65.4 57.12,66.37 54.85,66.37 54.83,66.39 53.32,66.39 53.05,66.66 52.31,66.66 51.97,66.32 46.3,66.32 45.38,65.39 39.84,65.39 38.6,64.16 38.08,64.16 34.87,60.94 34.1,60.94 30.11,56.96 30.11,54.92 30.34,54.7 30.34,52.36 30.2,52.23 30.2,50.79 30.41,50.58 30.41,45.62 31.19,44.84 31.19,44.12 32.48,42.84 32.48,42.76 32.48,42.76 32.48,41.94 32.67,41.75 32.67,40.27 32.59,40.19 32.59,37.69 33.97,36.31 34.68,36.31 34.91,36.54 37.67,36.54 39.22,38.09 39.63,38.09 39.87,38.32 39.87,40.61 v2(39.79,40.96)
  BOTTOM w0.102: U2030.AN53 80.46,65.78 80.22,66.02 v2(80.22,66.23)
M_B_ALERT#: length 143.9
  TOP w0.102: R2219.1 35.84,33.79 36,33.95 R2220.1 36.49,34.28 35.78,34.98 v2(35.78,35.54) 35.87,35.63 U2012.P9 ; v2(32.93,70.37) 34.24,70.37 35.87,72 U2010.P9 ; v2(33.39,51.79) 33.49,51.89 35.47,51.89 U2011.P9 ; v2(32.88,85.46) 33.26,85.84 33.26,86 33.82,86.57 35.46,86.57 U2009.P9
  IN1 w0.089: v2(35.78,35.54) 35.51,35.81 35.51,35.99 33.2,38.3 33.2,38.69 33.84,39.33 33.84,41.61 34.2,41.97 34.2,45.65 33.66,46.18 33.66,50.01 33.18,50.48 33.18,51.58 v2(33.39,51.79) 33.36,51.79 33.15,52 33.15,57.4 32.34,58.22 32.34,65.8 32.93,66.39 v2(32.93,70.37) 32.93,71.24 32.31,71.85 32.31,76.19 32.4,76.28 33.33,76.28 33.42,76.37 33.42,76.5 33.33,76.59 32.4,76.59 32.31,76.68 32.31,77.29 32.41,77.39 32.58,77.39 32.68,77.28 32.68,77.02 32.82,76.89 33.43,76.89 33.64,77.11 33.64,78.17 33.49,78.32 33.05,78.32 32.43,78.93 32.21,78.93 32.09,79.05 32.09,79.2 32.18,79.29 32.29,79.29 32.35,79.35 32.35,80.53 32.93,81.11 33.14,81.11 33.26,81.23 33.26,84.75 33.11,84.9 33.11,85.22 v2(32.88,85.46)
  IN3 w0.079: 79.11,66.68 79.23,66.68 79.33,66.78 81.4,66.78 81.6,66.59 81.6,62.96 80.86,62.22 v2(80.86,61.67)
  IN3 w0.089: v2(32.88,85.46) 32.93,85.4 35.41,85.4 36.79,84.03 36.79,76.72 41.71,71.8 49.69,71.8 50.85,72.95 52.85,72.95 53.48,72.32 58.24,72.32 58.89,71.68 66.6,71.68 67.6,70.68 70.57,70.68 71.17,70.08 72.44,70.08 73.7,68.82 74.7,68.82 76.84,66.68 79.11,66.68
  BOTTOM w0.102: v2(80.86,61.67) 80.8,61.61 80.8,60.63 U2030.AN43
M_B_BG#0: length 174.2
  TOP w0.102: U2011.M2 37.47,57.12 v2(37.86,57.51) ; U2012.M2 38.13,44.21 38.41,44.21 38.62,44 38.64,43.83 38.69,43.24 v2(38.69,42.52) ; U2009.M2 37.1,92.12 37.1,92.93 37.16,92.98 37.16,93.31 37.26,93.41 37.26,94.21 v2(36.97,94.5) ; v2(38.06,80.52) 38.06,80.47 37.62,80.02 37.62,79.69 37.87,79.43 37.87,78.89 37.48,78.5 U2010.M2
  TOP w0.165: R2089.2 35.77,100.77 v1(35.8,100.75)
  IN1 w0.089: v2(36.97,94.5) 38.31,94.5 38.41,94.4 38.41,94.15 38.28,94.03 37.64,94.03 37.53,93.92 37.53,92.85 37.69,92.68 38.32,92.68 38.43,92.58 38.43,91.82 38.3,91.69 38.3,90.68 38.01,90.39 38.01,84.4 37.81,84.2 37.81,81.65 37.6,81.44 37.6,80.98 v2(38.06,80.52) 37.68,80.02 37.68,79.64 37.82,77.94 37.95,76.57 37.95,72.14 38.63,70.97 38.63,63.74 38.47,62.8 38.04,60.16 38.04,58.43 v2(37.86,57.51) 37.86,56.93 38.28,56.52 38.28,56.3 38.38,56.2 38.62,56.2 38.68,56.13 38.68,55.98 38.62,55.92 38.37,55.92 38.28,55.83 38.28,55.7 38.37,55.61 38.72,55.61 38.81,55.53 38.81,55.37 38.75,55.31 38.37,55.31 38.28,55.22 38.28,55.09 38.37,55 38.65,55 38.74,54.91 38.74,54.78 38.63,54.66 38.37,54.66 38.29,54.58 38.29,47.22 38.38,47.13 38.57,47.13 38.66,47.03 38.66,46.94 38.57,46.86 38.35,46.86 38.29,46.8 38.29,46.67 38.39,46.57 38.54,46.57 38.61,46.5 38.61,44.84 38.85,44.6 38.85,43.83 38.95,43.72 39.11,43.72 39.2,43.82 39.2,44.18 39.3,44.28 39.41,44.28 39.84,43.85 39.84,43.17 39.7,43.02 39.39,43.02 39.15,42.79 39.15,42.39 39.06,42.3 38.91,42.3 v2(38.69,42.52)
  IN3 w0.079: v2(79.43,66.24) 79.43,66.35 79.7,66.63 81.22,66.63 81.44,66.41 81.44,63.13 80.48,62.16 80.48,61.2 80.63,61.05 80.63,60.62 80.41,60.4 80.07,60.4 79.83,60.64 79.83,60.91 79.58,61.16 78.41,61.16 78.41,61.16 77.42,61.16 77.27,61.01
  IN3 w0.089: 68.92,61.44 69.08,61.28 73.06,61.28 73.4,60.94 73.4,60.42 73.72,60.1 75.06,60.1 75.21,60.25 76.51,60.25 77.27,61.01
  IN3 w0.102: v1(35.8,100.75) 35.29,100.24 35.29,97.67 37.04,95.92 37.04,94.58 v2(36.97,94.5)
  IN3 w0.14: 68.92,61.44 68.33,62.04 66.43,62.04 65.8,62.67 56.13,62.67 55.7,63.1 55.02,63.1 54.3,62.37 52.36,62.37 52.17,62.55 51.46,62.55 50.47,63.54 40.69,63.54 39.16,62.02 38.56,62.02 35.66,59.12 35.66,58.75 36,58.41 36,57.44 35.66,57.1 35.2,57.1 35.04,57.26 35.04,58.11 34.89,58.26 34.46,58.26 34.01,57.81 34.01,57.35 33.84,57.18 33.09,57.18 32.91,57 32.91,56.41 33.13,56.19 33.13,53.02 32.55,52.44 32.55,51.27 32.27,50.99 32.27,46.47 33.16,45.58 33.16,45.22 33.28,45.1 33.64,45.1 33.89,44.85 33.89,43.66 34.16,43.38 34.16,38.48 34.57,38.08 36.48,38.08 38.19,39.79 38.31,39.91 38.52,39.91 38.65,40.05 38.65,40.25 38.53,40.37 38.31,40.37 38.15,40.54 38.15,41.08 38.41,41.35 38.41,42.23 v2(38.69,42.52)
  BOTTOM w0.102: U2030.AP52 79.49,65.19 79.49,66.18 v2(79.43,66.24)
