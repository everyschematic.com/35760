# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MODEM_CLKREQ_L: length 49.6
  TOP w0.102: U36.4 149.81,23.57 149.45,23.93 R678.1 150.13,24.22 v1(150.25,24.09)
  IN2 w0.089: v1(150.25,24.09) 150.68,24.52 151.01,24.52 151.41,24.92 152.26,24.92 152.73,24.45 154.89,24.45 155,24.56 156.51,24.56 156.83,24.88 156.83,26.09 157.79,27.05 157.79,27.36 158.22,27.79 158.22,28.68 158.76,29.22 162.17,29.22 163.01,28.38 165.76,28.38 166.26,28.87 168.23,28.87 168.4,29.05 171.52,29.05 172.13,28.44 175.8,28.44 177.14,27.11 186.76,27.11 186.98,27.33 187.93,27.33 v2(188.72,26.54)
  BOTTOM w0.102: CN17.14 189.37,27.88 188.72,27.23 v2(188.72,26.54)
MPHY_EXT_PWR: length 18
  TOP w0.079: 81.34,35.52 81.34,36.21 82.4,37.27 82.4,40.66 81.7,41.36 v4(81.62,41.36)
  TOP w0.102: 81.34,35.52 81.34,31.28 81.37,31.25 81.37,31.25 82.54,30.08 82.54,25.9 R2289.1
  BOTTOM w0.102: U2030.AM10 81.39,41.36 v4(81.62,41.36)
MX0: length 82.6
  TOP w0.102: U37.58 194.85,14.85 194.64,15.06 193.76,15.06 193.08,15.74 192.85,15.74 190.91,17.68 190.91,18.36 189.74,19.53 189.74,20 v2(189.43,20.31) ; v1(142.73,16.57) 142.73,17 142.84,17.11 143.08,17.11 145.9,19.93 145.9,24.27 143.06,27.11 142.89,27.11 v1(142.58,27.42) ; C725.1 165.54,19.29 v1(165.8,19.54)
  IN2 w0.089: v2(189.43,20.31) 189.7,20.03 189.7,19.5 189.32,19.11 188.25,19.11 187.53,19.83 181.74,19.83 181.35,20.22 178.97,20.22 178.76,20.02 177.99,20.02 177.57,19.6 172.87,19.6 172.15,20.31 170.51,20.31 170.32,20.12 166.63,20.12 166.05,19.54 v1(165.8,19.54)
  BOTTOM w0.102: CN18.10 166,19.75 v1(165.8,19.54) 165.08,18.83 164.41,18.83 164.21,18.63 162.85,18.63 161.63,17.41 152.13,17.41 151.6,17.94 147.94,17.94 146.82,19.06 146.82,20.08 146.72,20.18 143.83,20.18 142.73,19.08 v1(142.73,16.57) ; v1(142.58,27.42) 143.66,26.34 143.91,26.34 144.4,25.85 CN19.10
MX1: length 78.6
  TOP w0.102: C727.1 166.25,19.32 166.48,19.54 v1(166.81,19.54) ; v1(143.64,27.5) 143.64,26.86 146.13,24.38 146.13,19.83 143.37,17.08 v1(143.37,16.57) ; v2(192.51,18.08) 192.34,17.9 192.34,16.57 192.94,15.97 193.17,15.97 193.81,15.33 194.77,15.33 195.25,14.85 U37.59
  IN2 w0.089: v2(192.51,18.08) 192.33,17.9 189.19,17.9 187.45,19.64 181.66,19.64 181.61,19.69 181.21,19.69 180.92,19.39 179.9,19.39 179.88,19.42 178.21,19.42 178.2,19.41 172.79,19.41 172.08,20.12 170.59,20.12 170.4,19.93 167.2,19.93 v1(166.81,19.54)
  BOTTOM w0.102: CN18.9 167,19.74 v1(166.81,19.54) 166.3,19.04 165.61,19.04 165.18,18.6 164.58,18.6 164.2,18.22 164.2,17.49 162.7,15.99 153.15,15.99 151.42,17.72 147.64,17.72 146.07,16.14 145.05,16.14 144.21,16.98 143.78,16.98 v1(143.37,16.57) ; CN19.9 145.4,25.53 144.74,26.2 144.54,26.2 143.64,27.09 v1(143.64,27.5)
MX2: length 75.1
  TOP w0.102: C723.1 166.97,19.04 v1(167.45,19.52) ; v2(194.85,15.96) 194.85,15.66 195.65,14.87 U37.60 ; v1(144.79,26.66) 144.79,26.04 146.36,24.47 146.36,19.74 144,17.39 v1(144,16.55)
  IN2 w0.089: v1(167.45,19.52) 168.8,18.17 173.62,18.17 174.21,17.58 180.17,17.58 180.42,17.83 183.19,17.83 183.85,18.5 186.97,18.5 188.72,16.75 193.31,16.75 193.56,16.5 193.84,16.5 194,16.34 194.48,16.34 v2(194.85,15.96)
  BOTTOM w0.102: v1(144,16.55) 144.28,16.55 144.92,15.91 146.16,15.91 147.74,17.49 151.29,17.49 153.02,15.76 163.49,15.76 165.11,17.39 165.11,18.21 165.71,18.81 166.74,18.81 v1(167.45,19.52) 168,20.08 CN18.8 ; CN19.8 146.4,25.66 146.07,26 145.38,26 144.79,26.58 v1(144.79,26.66)
MX3: length 74.2
  TOP w0.102: v1(147.45,16.42) 146.58,17.28 146.58,24.57 145.22,25.93 v1(145.22,27.16) ; v2(194.68,16.78) 194.68,16.7 195.03,16.34 196.19,16.34 196.42,16.11 196.42,15.77 196.05,15.39 U37.61 ; C722.1 v1(168.16,19.49)
  IN2 w0.089: v1(168.16,19.49) 169.29,18.36 173.7,18.36 174.29,17.77 180.09,17.77 180.42,18.1 183.19,18.1 183.78,18.69 187.05,18.69 188.8,16.94 193.39,16.94 193.64,16.69 193.92,16.69 194.08,16.53 194.43,16.53 v2(194.68,16.78)
  BOTTOM w0.102: CN19.7 147.4,25.89 147.3,26 146.39,26 146.16,26.22 145.48,26.22 145.22,26.48 v1(145.22,27.16) ; v1(147.45,16.42) 148.28,17.26 150.96,17.26 152.69,15.53 163.66,15.53 165.97,17.84 165.97,18.38 166.18,18.58 166.83,18.58 167.2,18.95 167.61,18.95 v1(168.16,19.49) 168.65,19.98 168.9,19.98 169,20.08 CN18.7
MX4: length 73.4
  TOP w0.102: v1(168.79,19.49) 168.79,19.49 C720.1 ; v1(145.65,26.68) 145.65,25.82 146.81,24.66 146.81,17.72 v1(148.11,16.42) ; v2(195.26,16.78) 196.08,16.78 196.65,16.2 196.65,15.67 196.45,15.47 U37.62
  IN2 w0.089: v1(168.79,19.49) 169.64,18.65 173.73,18.65 174.41,17.96 177.83,17.96 178.52,18.66 179.47,18.66 179.83,18.29 183.11,18.29 183.7,18.88 187.13,18.88 188.88,17.13 193.73,17.13 194,17.4 194.63,17.4 v2(195.26,16.78)
  BOTTOM w0.102: CN19.6 148.4,25.61 148.27,25.75 148.09,25.75 147.86,25.98 147.65,25.98 147.4,26.22 146.54,26.22 146.09,26.68 v1(145.65,26.68) ; v1(148.11,16.42) 148.72,17.03 150.79,17.03 152.51,15.3 164.33,15.3 166.93,17.9 166.93,18.35 167.29,18.72 168.02,18.72 v1(168.79,19.49) 169.05,19.49 170,20.45 CN18.6
MX5: length 71.4
  TOP w0.102: v1(170.34,19.49) 170.31,19.46 C726.1 ; U37.63 196.85,14.95 197.06,15.16 v2(197.06,15.68) ; v1(146.76,26.67) 146.76,25.68 147.5,24.95 147.5,18.18 148.34,17.33 149.77,17.33 v1(150.73,16.37)
  IN2 w0.089: v2(197.06,15.68) 196.89,15.68 194.98,17.59 193.92,17.59 193.65,17.32 188.96,17.32 187.21,19.07 183.62,19.07 183.03,18.48 179.91,18.48 179.55,18.85 178.45,18.85 177.75,18.15 174.81,18.15 174.13,18.84 171,18.84 v1(170.34,19.49)
  BOTTOM w0.102: CN19.5 149.4,25.75 149.18,25.98 148.18,25.98 147.95,26.2 147.74,26.2 147.49,26.45 146.98,26.45 v1(146.76,26.67) ; v1(150.73,16.37) 152.03,15.07 165.09,15.07 169.09,19.07 169.92,19.07 v1(170.34,19.49) 170.34,19.7 171,20.36 CN18.5
MX6: length 74.7
  TOP w0.102: v1(171,19.49) 170.95,19.44 C721.1 ; v1(150.06,16.38) 150.06,16.61 149.57,17.11 148.25,17.11 147.27,18.08 147.27,24.85 146.32,25.81 146.32,27.07 v1(146.48,27.24) ; U37.64 197.25,14.9 197.51,15.16 197.51,16.07 197.31,16.27 v2(197.06,16.27)
  IN2 w0.089: v2(197.06,16.27) 196.57,16.27 195.05,17.79 193.84,17.79 193.57,17.51 189.04,17.51 187.29,19.26 183.54,19.26 182.95,18.67 179.99,18.67 179.63,19.04 178.37,19.04 178.36,19.03 171.47,19.03 v1(171,19.49)
  BOTTOM w0.102: v1(150.06,16.38) 151.6,14.85 165.18,14.85 169.18,18.85 170.53,18.85 171,19.32 v1(171,19.49) 171.08,19.49 172,20.42 CN18.4 ; CN19.4 150.4,25.71 149.27,26.84 148.29,26.84 148.14,26.69 v1(147.92,26.69) 147.36,26.69 146.8,27.24 v1(146.48,27.24)
MX7: length 78.3
  TOP w0.102: v1(149.41,16.42) 148.96,16.88 148.09,16.88 147.04,17.93 147.04,24.76 146.09,25.71 146.09,27.07 v1(145.84,27.32) ; v2(198.82,15.12) 198.9,15.2 U37.65 ; C724.1 171.66,19.47 v1(171.73,19.53)
  IN2 w0.089: v2(198.82,15.12) 197.3,16.64 196.47,16.64 195.13,17.98 193.77,17.98 193.49,17.7 189.11,17.7 187.37,19.45 183.46,19.45 182.87,18.86 180.07,18.86 179.7,19.23 178.29,19.23 178.28,19.22 172.04,19.22 v1(171.73,19.53)
  BOTTOM w0.102: v1(145.84,27.32) 146.2,27.67 146.7,27.67 147.25,27.12 149.31,27.12 150.39,26.05 150.91,26.05 151.4,25.55 CN19.3 ; CN18.3 173,19.89 172.64,19.53 v1(171.73,19.53) 170.81,18.62 169.35,18.62 165.35,14.62 150.35,14.62 149.41,15.56 v1(149.41,16.42)
MY0: length 67
  TOP w0.102: v2(186.02,16.82) 186.05,16.79 U37.36 ; v1(150.53,19.52) 151.04,19.01 C719.1
  IN2 w0.089: v1(150.53,19.52) 151.1,18.95 151.79,18.95 152.06,18.68 152.59,18.68 153.99,17.28 157.51,17.28 158.79,16.01 181.82,16.01 182.69,16.88 183.59,16.88 184.2,17.5 185.18,17.5 185.86,16.82 v2(186.02,16.82)
  BOTTOM w0.102: CN19.26 128.4,24.55 128.71,24.25 130.09,24.25 130.29,24.04 131.35,24.04 132.23,23.16 135.13,23.16 135.36,22.93 136.04,22.93 136.27,22.7 136.94,22.7 137.17,22.47 137.72,22.47 137.95,22.24 148.26,22.24 149.22,21.28 149.88,21.28 150,21.16 CN18.26 150,20.45 150.53,19.92 v1(150.53,19.52)
MY1: length 66.9
  TOP w0.102: v1(151.83,19.56) 151.83,19.1 C716.1 ; v2(185.99,17.4) 186.04,17.4 186.42,17.02 186.42,15.51 186.45,15.48 U37.37
  IN2 w0.089: v2(185.99,17.4) 185.55,17.4 185.26,17.69 184.13,17.69 183.51,17.07 180.73,17.07 180.35,16.69 180.35,16.45 180.1,16.2 170.87,16.2 170.17,16.9 169.39,16.9 168.7,16.2 158.87,16.2 157.28,17.79 157.28,18.25 157.02,18.5 153.48,18.5 153.1,18.87 152.53,18.87 v1(151.83,19.56)
  BOTTOM w0.102: v1(151.83,19.56) 151,20.39 CN18.25 151,21.05 150.78,21.28 150.21,21.28 149.93,21.55 149.27,21.55 148.35,22.47 138.04,22.47 137.81,22.7 137.27,22.7 137.04,22.93 136.36,22.93 136.13,23.16 135.46,23.16 135.23,23.38 132.33,23.38 131.44,24.27 130.39,24.27 130.18,24.47 129.53,24.47 129.4,24.6 CN19.25
MY2: length 66.7
  TOP w0.102: C717.1 152.48,19.17 v1(152.48,19.54) ; U37.38 186.85,16.21 186.88,16.24 186.88,16.98 v2(186.83,17.03)
  IN2 w0.089: v2(186.83,17.03) 186.42,17.44 186.42,17.51 186,17.92 184.09,17.92 183.43,17.26 180.65,17.26 180.16,16.77 180.16,16.52 180.02,16.39 171.01,16.39 170.31,17.09 169.32,17.09 168.62,16.39 158.95,16.39 157.47,17.87 157.47,18.32 157.1,18.69 153.56,18.69 153.18,19.06 152.96,19.06 v1(152.48,19.54)
  BOTTOM w0.102: v1(152.48,19.54) 152,20.02 CN18.24 152,21.14 151.64,21.5 150.3,21.5 150.03,21.78 149.37,21.78 148.45,22.7 138.14,22.7 137.91,22.93 137.36,22.93 137.13,23.16 136.46,23.16 136.23,23.38 135.55,23.38 135.32,23.61 132.42,23.61 131.54,24.5 130.51,24.5 130.4,24.6 CN19.24
MY3: length 65.2
  TOP w0.102: v2(187.16,17.51) 187.23,17.44 187.23,16.37 187.25,16.36 U37.39 ; C708.1 153.35,19.2 153.13,19.42 v1(153.13,19.54)
  IN2 w0.089: v1(153.13,19.54) 153.13,19.42 153.67,18.88 167.49,18.88 168.79,17.58 173.62,17.58 174,17.2 180.32,17.2 180.57,17.45 183.35,17.45 184.01,18.12 186.08,18.12 186.69,17.51 v2(187.16,17.51)
  BOTTOM w0.102: CN19.23 131.4,24.96 132.52,23.84 135.42,23.84 135.65,23.61 136.32,23.61 136.55,23.38 137.23,23.38 137.46,23.16 138,23.16 138.23,22.93 148.54,22.93 149.46,22.01 152.64,22.01 152.87,21.78 152.87,21.3 153,21.16 CN18.23 153,19.67 v1(153.13,19.54)
MY4: length 64.5
  TOP w0.102: C718.1 154.24,19.31 v1(154.48,19.54) ; U37.40 187.64,14.14 v2(187.64,17)
  IN2 w0.089: v1(154.48,19.54) 154.95,19.07 167.57,19.07 168.67,17.98 173.54,17.98 174.13,17.39 180.24,17.39 180.49,17.64 183.27,17.64 183.93,18.31 186.37,18.31 186.77,17.91 187.29,17.91 187.64,17.56 v2(187.64,17)
  BOTTOM w0.102: CN19.22 132.4,24.6 132.93,24.07 135.51,24.07 135.74,23.84 136.42,23.84 136.65,23.61 137.32,23.61 137.55,23.38 138.1,23.38 138.32,23.16 148.64,23.16 149.56,22.24 153.25,22.24 154,21.48 CN18.22 154,20.02 v1(154.48,19.54)
MY5: length 68.1
  TOP w0.102: v1(155.11,19.54) 154.95,19.38 C707.1 ; v2(185.46,22.52) 185.26,22.52 184.87,22.14 184.87,20.37 188.15,17.1 188.15,15.12 188.05,15.02 U37.41
  IN2 w0.089: v1(155.11,19.54) 155.74,19.54 156.71,20.52 158.47,20.52 159.1,21.15 162.74,21.15 162.86,21.28 163.49,21.28 164.43,22.22 169.45,22.22 169.64,22.41 173.02,22.41 173.58,21.85 175.96,21.85 176.88,22.77 184.35,22.77 184.54,22.59 184.82,22.59 184.88,22.52 v2(185.46,22.52)
  BOTTOM w0.102: v1(155.11,19.54) 155.08,19.58 155.08,20.48 CN18.21 155,20.81 153.35,22.47 149.65,22.47 148.73,23.38 138.42,23.38 138.19,23.61 137.65,23.61 137.42,23.84 136.74,23.84 136.51,24.07 135.84,24.07 135.61,24.3 133.69,24.3 133.4,24.58 CN19.21
MY6: length 65.9
  TOP w0.102: U37.42 188.45,15.16 188.4,15.21 188.4,17.17 185.48,20.09 185.48,21.82 185.38,21.92 v2(185.37,21.92) ; C706.1 156.32,19.4 156.31,19.42 v1(156.31,19.54)
  IN2 w0.089: v2(185.37,21.92) 185.21,21.92 184.74,22.4 184.46,22.4 184.27,22.58 176.96,22.58 176.04,21.66 173.5,21.66 172.94,22.22 169.72,22.22 169.53,22.03 164.51,22.03 163.57,21.09 162.94,21.09 162.82,20.96 159.18,20.96 158.55,20.33 157.09,20.33 v1(156.31,19.54)
  BOTTOM w0.102: v1(156.31,19.54) 156,19.85 CN18.20 156,20.85 155.41,21.45 154.68,21.45 153.44,22.69 149.74,22.69 148.83,23.61 138.51,23.61 138.29,23.84 137.74,23.84 137.51,24.07 136.84,24.07 136.61,24.3 135.93,24.3 135.7,24.53 134.55,24.53 134.4,24.67 CN19.20
MY7: length 71.3
  TOP w0.102: v2(186.04,22.49) 185.77,22.22 185.77,20.12 188.62,17.27 188.62,15.38 188.85,15.16 U37.43 ; C709.1 157.08,19.27 156.94,19.42 v1(156.94,19.54)
  IN2 w0.089: v1(156.94,19.54) 157.53,20.13 158.63,20.13 159.26,20.77 162.9,20.77 163.02,20.9 163.65,20.9 164.59,21.84 169.61,21.84 169.8,22.03 172.87,22.03 173.42,21.47 176.11,21.47 177.04,22.39 184.19,22.39 184.38,22.2 184.66,22.2 184.99,21.87 184.99,21.68 185.13,21.54 185.52,21.54 185.74,21.76 185.74,22.19 v2(186.04,22.49)
  BOTTOM w0.102: CN19.19 135.4,25.15 136.03,24.53 136.7,24.53 136.93,24.3 137.61,24.3 137.84,24.07 138.38,24.07 138.61,23.84 148.92,23.84 149.84,22.92 153.15,22.92 154.62,24.4 154.62,24.77 154.73,24.88 157.03,24.88 157.14,24.77 157.14,21.33 157,21.2 CN18.19 157,19.92 156.94,19.86 v1(156.94,19.54)
MY8: length 68.1
  TOP w0.102: v1(158.21,19.54) 158.21,19.3 C711.1 ; v2(186.18,21.54) 186.18,20.04 188.85,17.36 188.85,15.48 189.25,15.08 U37.44
  IN2 w0.089: v1(158.21,19.54) 158.61,19.94 158.82,19.94 159.43,20.56 163.01,20.56 163.16,20.71 163.73,20.71 164.67,21.65 169.68,21.65 169.88,21.84 172.79,21.84 173.35,21.28 176.19,21.28 177.12,22.2 184.12,22.2 184.3,22.01 184.58,22.01 184.8,21.79 184.8,21.6 185.05,21.35 185.99,21.35 v2(186.18,21.54)
  BOTTOM w0.102: CN19.18 136.4,25.15 137.03,24.53 137.7,24.53 137.93,24.3 138.48,24.3 138.7,24.07 149.01,24.07 149.93,23.15 153.05,23.15 154.39,24.49 154.39,24.87 154.63,25.11 157.13,25.11 157.37,24.87 157.37,21.75 158,21.11 CN18.18 158,19.9 158.21,19.69 v1(158.21,19.54)
MY9: length 68.7
  TOP w0.102: v1(158.85,19.54) 158.85,19.04 C713.1 ; U37.45 189.65,15.09 189.08,15.65 189.08,17.46 186.59,19.95 186.59,21.92 v2(186.44,22.06)
  IN2 w0.089: v2(186.44,22.06) 186.55,21.95 186.55,21.38 186.33,21.16 182.29,21.16 181.45,22.01 177.2,22.01 176.27,21.09 173.27,21.09 172.71,21.65 169.95,21.65 169.76,21.46 164.75,21.46 163.81,20.52 163.24,20.52 163.09,20.37 159.54,20.37 158.85,19.67 v1(158.85,19.54)
  BOTTOM w0.102: v1(158.85,19.54) 158.85,19.67 159,19.83 CN18.17 159,20.67 158.4,21.28 158.17,21.28 157.59,21.85 157.59,24.96 157.22,25.33 154.54,25.33 154.17,24.96 154.17,24.59 152.96,23.38 150.03,23.38 149.11,24.3 138.8,24.3 138.57,24.53 138.03,24.53 137.4,25.15 CN19.17
MY10: length 66.2
  TOP w0.102: v2(186.99,21.18) 186.99,19.87 189.31,17.55 189.31,15.75 190.05,15.01 U37.46 ; C714.1 160.12,19.14 v1(160.12,19.54)
  IN2 w0.089: v2(186.99,21.18) 186.79,20.97 182.21,20.97 181.37,21.82 177.28,21.82 176.35,20.9 173.19,20.9 172.63,21.46 170.03,21.46 169.84,21.26 164.83,21.26 163.89,20.33 163.31,20.33 163.17,20.18 160.62,20.18 160.12,19.67 v1(160.12,19.54)
  BOTTOM w0.102: CN19.16 138.4,25.02 138.89,24.53 149.2,24.53 150.12,23.61 152.86,23.61 153.94,24.68 153.94,25.06 154.44,25.56 157.32,25.56 157.82,25.06 157.82,21.94 158.26,21.5 158.5,21.5 158.73,21.28 159.38,21.28 160,20.65 CN18.16 160,19.66 v1(160.12,19.54)
MY11: length 68.7
  TOP w0.102: v2(187.8,21.01) 187.63,20.83 187.63,19.88 189.77,17.74 189.77,17.14 192.05,14.86 U37.51 ; C715.1 160.72,19.51 v1(160.75,19.54)
  IN2 w0.089: v2(187.8,21.01) 187.58,20.78 182.14,20.78 181.29,21.63 177.35,21.63 176.28,20.55 173.26,20.55 172.55,21.26 170.11,21.26 169.92,21.07 164.91,21.07 163.97,20.13 163.39,20.13 163.25,19.99 161.03,19.99 160.75,19.71 v1(160.75,19.54)
  BOTTOM w0.102: CN19.15 139.4,26.6 139.79,26.99 139.79,27.7 140.04,27.95 140.4,27.95 140.63,27.72 141.08,27.72 141.21,27.85 143.38,27.85 143.47,27.93 144.22,27.93 144.3,27.85 v1(145.01,27.85) 145.91,27.85 145.96,27.9 146.79,27.9 147.34,27.35 149.41,27.35 150.48,26.28 151.01,26.28 151.31,25.98 153.78,25.98 153.97,25.79 157.41,25.79 158.05,25.15 158.05,22.04 158.36,21.73 158.59,21.73 158.82,21.5 159.48,21.5 159.68,21.3 160.56,21.3 161,20.86 CN18.15 161,19.92 160.75,19.67 v1(160.75,19.54)
MY12: length 71.3
  TOP w0.102: v2(187.66,21.69) 187.7,21.69 188.21,21.18 188.21,20.84 187.86,20.49 187.86,19.98 190,17.84 190,17.3 192.45,14.85 U37.52 ; v1(161.48,19.49) C728.1
  IN2 w0.089: v2(187.66,21.69) 188.27,21.08 188.27,20.95 187.91,20.59 182.06,20.59 181.66,20.99 178.65,20.99 178.44,20.78 177.67,20.78 177.26,20.36 173.18,20.36 172.47,21.07 170.19,21.07 170,20.88 164.98,20.88 164.04,19.94 163.47,19.94 163.02,19.49 v1(161.48,19.49)
  IN3 w0.089: v1(140.23,27.47) 140.23,26.67 141.11,25.79 150.87,25.79 151.88,26.79 v1(151.88,26.96)
  BOTTOM w0.102: v1(161.48,19.49) 162,20.02 CN18.14 162,20.77 161.5,21.28 160.91,21.28 160.66,21.53 159.78,21.53 159.57,21.73 158.91,21.73 158.28,22.37 158.28,25.25 157.51,26.02 154.06,26.02 153.88,26.2 152.41,26.2 151.88,26.73 v1(151.88,26.96) ; v1(140.23,27.47) 140.23,26.29 140.4,26.12 CN19.14
MY13: length 81.4
  TOP w0.102: v1(140.83,16.57) 141.77,17.51 142.08,17.51 142.36,17.79 142.79,17.79 145.21,20.21 145.21,23.99 142.77,26.43 142.31,26.43 142.09,26.66 141.57,26.66 141.45,26.77 140.97,26.77 v1(140.72,27.02) ; v1(163.64,19.54) 163.64,19.42 163.22,19.01 C729.1 ; v2(188.31,20.37) 188.31,19.85 190.22,17.93 190.22,17.39 192.56,15.06 192.72,15.06 192.85,14.93 U37.53
  IN2 w0.089: v2(188.31,20.37) 188.27,20.4 181.98,20.4 181.58,20.79 178.73,20.79 178.52,20.59 177.75,20.59 177.34,20.17 173.1,20.17 172.39,20.88 170.27,20.88 170.08,20.69 165.06,20.69 163.91,19.54 v1(163.64,19.54)
  BOTTOM w0.102: CN18.13 163,20.18 v1(163.64,19.54) 162.14,19.54 161.66,19.06 161.3,19.06 161.27,19.09 151.09,19.09 150.63,18.63 148.22,18.63 147.51,19.34 147.51,20.37 147.01,20.87 143.55,20.87 141.21,18.53 141.21,16.95 v1(140.83,16.57) ; v1(140.72,27.02) 141.4,26.33 CN19.13
MY14: length 81.2
  TOP w0.102: v1(141.46,16.57) 141.46,16.67 142.07,17.28 142.17,17.28 142.45,17.56 142.89,17.56 145.44,20.12 145.44,24.08 142.87,26.66 142.41,26.66 142.18,26.88 141.72,26.88 v1(141.29,27.32) ; v2(188.86,20.17) 188.84,20.15 188.84,19.64 190.45,18.03 190.45,17.49 192.66,15.29 192.81,15.29 193.25,14.85 U37.54 ; v1(164.43,19.49) 163.94,19.01 C730.1
  IN2 w0.089: v1(164.43,19.49) 164.49,19.49 165.5,20.5 170.16,20.5 170.35,20.69 172.31,20.69 173.02,19.98 177.42,19.98 177.83,20.4 178.6,20.4 178.81,20.6 181.5,20.6 181.9,20.21 187.69,20.21 187.97,19.93 188.53,19.93 188.77,20.17 v2(188.86,20.17)
  BOTTOM w0.102: v1(141.46,16.57) 141.46,18.46 143.65,20.64 146.91,20.64 147.28,20.27 147.28,19.25 148.13,18.4 150.73,18.4 151.19,18.86 161.18,18.86 161.21,18.83 161.75,18.83 162.01,19.09 164.02,19.09 v1(164.43,19.49) 164,19.91 CN18.12 ; v1(141.29,27.32) 142.4,26.2 CN19.12
MY15: length 80.2
  TOP w0.102: v1(165.16,19.54) 165.16,19.29 164.88,19.01 C731.1 ; v2(189.33,19.73) 189.33,19.47 190.68,18.12 190.68,17.58 192.75,15.51 192.98,15.51 193.65,14.85 U37.55 ; v1(141.95,27.34) 142.05,27.34 142.5,26.88 142.96,26.88 145.67,24.18 145.67,20.02 142.98,17.33 142.55,17.33 142.1,16.88 v1(142.1,16.57)
  IN2 w0.089: v2(189.33,19.73) 189.04,19.44 188.18,19.44 187.61,20.02 181.82,20.02 181.43,20.41 178.89,20.41 178.68,20.21 177.91,20.21 177.5,19.79 172.95,19.79 172.23,20.5 170.43,20.5 170.24,20.31 165.93,20.31 v1(165.16,19.54)
  BOTTOM w0.102: CN18.11 165,19.96 165.16,19.8 v1(165.16,19.54) 164.68,19.06 164.32,19.06 164.12,18.86 162.11,18.86 161.85,18.6 161.11,18.6 161.08,18.63 151.28,18.63 150.82,18.17 148.03,18.17 147.05,19.15 147.05,20.18 146.82,20.41 143.74,20.41 142.1,18.77 v1(142.1,16.57) ; v1(141.95,27.34) 143.4,25.88 CN19.11
MY16: length 76.9
  TOP w0.102: v2(193.82,12.41) 193.82,13.19 194.05,13.41 U37.56 ; C732.1 147.96,19.09 v1(147.96,19.54)
  IN2 w0.089: v1(147.96,19.54) 148.94,18.57 151.2,18.57 152.77,17 153.72,17 155.09,15.63 181.54,15.63 182.34,14.83 183.48,14.83 183.72,14.59 186.41,14.59 186.64,14.83 191.98,14.83 193.82,12.98 v2(193.82,12.41)
  BOTTOM w0.102: v1(147.96,19.54) 148,19.59 CN18.28 148,20.95 147.85,21.1 142.6,21.1 141.95,21.75 137.79,21.75 137.53,22.01 136.98,22.01 136.76,22.24 136.08,22.24 135.85,22.47 135.17,22.47 134.94,22.7 132.04,22.7 131.16,23.58 130.11,23.58 129.9,23.79 128.52,23.79 128.05,24.26 127.72,24.26 127.45,24.52 126.56,24.52 126.4,24.67 CN19.28
MY17: length 76.7
  TOP w0.102: C733.1 148.6,19.16 v1(148.6,19.54) ; U37.57 194.45,13.16 194.41,13.12 v2(194.41,12.41)
  IN2 w0.089: v1(148.6,19.54) 149.38,18.76 151.71,18.76 151.98,18.49 152.5,18.49 155.17,15.82 182.31,15.82 182.37,15.88 184.67,15.88 185.53,15.02 192.27,15.02 194.41,12.88 v2(194.41,12.41)
  BOTTOM w0.102: CN19.27 127.4,24.89 127.81,24.48 128.14,24.48 128.61,24.02 129.99,24.02 130.2,23.81 131.26,23.81 132.14,22.93 135.04,22.93 135.27,22.7 135.94,22.7 136.17,22.47 136.85,22.47 137.08,22.24 137.62,22.24 137.85,22.01 148.16,22.01 149,21.17 CN18.27 149,19.95 v1(148.6,19.54)
N12E_SCL: length 9.4
  BOTTOM w0.102: U8.C9 100.51,94.23 100.51,93.7 100.34,93.53 100.34,93.15 99.85,92.65 99.85,92 99.17,91.32 96.44,91.32 95.72,90.61 95.02,90.61 94.55,90.14 R367.1
N12E_SDA: length 9.4
  BOTTOM w0.102: R368.1 94.78,90.82 95.64,90.82 96.35,91.53 99.07,91.53 99.58,92.04 99.58,94.14 U8.C8
NBSWON#: length 81.9
  TOP w0.102: v1(150.91,24.07) 150.94,24.04 C20024.1 150.4,22.75 150.4,22.16 150.93,21.63 R720.2 ; v2(193.4,23.88) 193.4,24.25 191.58,26.07 191.58,27.58 191.37,27.78 191.37,28.33 191.72,28.67 192.32,28.67 192.58,28.93 193.06,28.93 193.25,29.11 U37.107 193.25,30.55 193.28,30.58 193.28,31.61 R25314.1 193.31,31.87 193.15,32.02 193.15,33.17 193.73,33.74 195.29,33.74 v1(195.3,33.73) 196.24,33.73 197.33,32.64 197.33,31.34 v2(197.55,31.12)
  IN2 w0.089: v2(193.4,23.88) 193.4,24.03 191.78,25.65 189.36,25.65 188.84,26.17 188.43,26.17 188.18,26.42 188.18,26.66 187.71,27.14 187.06,27.14 186.84,26.92 177.06,26.92 175.72,28.25 172.05,28.25 171.44,28.86 168.48,28.86 168.31,28.68 166.34,28.68 165.84,28.19 162.93,28.19 162.09,29.02 158.84,29.02 158.41,28.6 158.41,27.71 157.98,27.28 157.98,26.97 157.02,26.01 157.02,24.8 156.59,24.37 155.08,24.37 154.97,24.26 152.65,24.26 152.18,24.73 151.57,24.73 v1(150.91,24.07)
  BOTTOM w0.102: v1(150.91,24.07) 151.12,23.86 152.79,23.86 153.4,24.47 CN19.1 ; R25313.1 197.14,29.12 197.62,28.64 SW1.2 198.54,28.24 198.54,26.09 SW1.1 ; R25313.1 196.83,29.78 196.76,29.86 C6615.2 ; R25313.1 197.37,29.78 197.57,29.98 197.57,31.1 v2(197.55,31.12)
NGFF_SATA_DET: length 104.6
  TOP w0.102: v1(14.34,3.26) 14.26,3.19 R653.1
  IN2 w0.089: v1(95.61,18.31) 90.81,18.31 88.45,20.66 84.07,20.66 78.44,15.03 64.5,15.03 63.26,16.27 48.35,16.27 47.14,15.06 47.14,14.58 46.64,14.08 44.99,14.08 42.78,11.87 41.31,11.87 38.49,9.05 26.98,9.05 26.53,8.6 26.53,8.09 26.17,7.73 20.18,7.73 17.38,4.94 15.58,4.94 14.34,3.69 v1(14.34,3.26)
  IN3 w0.089: v1(95.61,18.31) 95.61,18.92 95.67,18.98 95.67,23.18 96.56,24.07 v1(96.56,24.19)
  BOTTOM w0.102: v1(96.56,24.19) 96.56,24.27 96.4,24.43 96.4,24.92 96.56,25.09 R134.1 96.56,25.94 96.44,26.06 95.99,26.06 95.69,26.36 95.69,27.4 96.07,27.77 96.07,28.93 95.57,29.42 R2547.2
NV_PLLVDD: length 13.2
  TOP w0.381: C457.2 99.47,100.96 99.19,101.24 v2(99.1,101.24) 98.9,101.04 98.9,100.91 98.66,100.67 C458.2 98.41,100.66 98.41,100.77 98.05,101.12 97.6,101.12 97.29,101.44 96.44,101.44 95.74,102.14 93.74,102.14 92.89,102.98 90.9,102.98 L7.2 90.24,104 90.33,104.08 90.33,104.62 90.31,104.63 L31.2
  BOTTOM w0.254: U8.L6 98.5,101.12 98.98,101.12 v2(99.1,101.24)
ODD_PRSNT#: length 67.3
  IN1 w0.089: v1(134.4,21.98) 134.21,22.18 126.69,22.18 126.1,22.76 123.82,22.76 121.01,25.58 116.28,25.58 115.74,26.12 113.42,26.12 113.04,25.74 108.45,25.74 108.21,25.5 107.04,25.5 106.67,25.87 105.07,25.87 103.83,27.1 103.83,27.89 103.09,28.63 102.55,28.63 102.46,28.72 102.46,29.31 102.22,29.55 101.99,29.55 100.41,31.14 99.45,31.14 99.24,31.35 98.15,31.35 97.58,31.92 95.26,31.92 95.02,31.68 95.02,31.36 94.78,31.13 93.18,31.13 92.29,32.02 88.28,32.02 87.56,31.3 87.56,31.08 87.34,30.85 86.78,30.85 v2(86.65,30.97)
  BOTTOM w0.102: R25475.1 C780.1 137.92,21.53 136.57,21.53 R640.2 136.12,21.76 135.64,22.24 134.66,22.24 v1(134.4,21.98) ; U2030.AB2 85.91,36.13 86.35,35.68 86.35,34.97 86.68,34.64 87.48,34.64 87.76,34.36 87.76,33.49 87.23,32.97 87.23,31.86 86.65,31.28 v2(86.65,30.97)
ODD_PRSNT#_C: length 7.1
  BOTTOM w0.102: CN15.8 133.35,18.49 133.74,18.88 133.74,20.92 133.67,20.99 C779.1 134.62,21.29 135.1,21.76 R641.1 135.55,21.76 R640.1
PBA_FP_PWREN#: length 154
  TOP w0.102: v2(195.22,23.36) 195.22,22.84 195.49,22.57 195.49,21.1 196.21,20.38 196.74,20.38 196.95,20.18 U37.76
  IN3 w0.089: v2(195.22,23.36) 195.42,23.56 195.42,24.21 195.2,24.43 194.59,24.43 193.77,25.25 193.16,25.25 192.9,25.51 189.22,25.51 188.73,25.02 184.03,25.02 182.12,23.1 179.29,23.1 177.19,21 163.03,21 162.87,20.83 159.61,20.83 158.94,20.16 139.31,20.16 138.04,18.89 127.51,18.89 127.15,18.52 124.02,18.52 123.54,19 120.09,19 118.98,17.89 111.87,17.89 109.58,15.6 101.99,15.6 100.48,17.12 98.23,17.12 95.87,14.76 95.87,14.41 v1(95.82,14.36)
  BOTTOM w0.102: R609.1 66.71,24.4 v1(67.46,23.65) 67.68,23.43 67.68,20.26 69.61,18.32 76.43,18.32 77.53,17.23 79.53,17.23 80.17,17.88 80.17,18.32 83.6,21.75 88.81,21.75 92.22,18.35 93.35,18.35 94.52,17.17 94.61,17.17 95.82,15.96 v1(95.82,14.36)
PBA_PWR: length 0.6
  TOP w0.508: v1(63.64,22.01) 63.56,21.93 R25295.2
PBA_PWR_C: length 2.6
  BOTTOM w0.305: 56.65,21.63 56.82,21.63 56.95,21.5 CN14.8
  BOTTOM w0.508: 56.65,21.63 56.64,21.65 55.98,21.65 v1(55.97,21.65) 55.98,21.66 R614.2
PBA_PWR_R: length 12.4
  BOTTOM w0.508: R614.1 C753.2 54.17,22.04 v1(54.58,21.64) 54.98,21.24 54.98,21.13 56.36,19.75 61.33,19.75 62.42,20.84 62.42,22.01
PCBEEP_EC: length 59.8
  TOP w0.102: v2(206.7,10.53) 204.84,10.53 204.46,10.91 204.46,12.65 204.06,13.04 204.06,17.98 204.68,18.6 205.16,18.6 205.63,19.07 v2(205.63,19.29) ; U37.34 185.25,13.24 185.4,13.09 185.53,12.97 185.94,12.97 186.83,12.07 v2(186.83,10.55)
  IN2 w0.089: v2(205.63,19.29) 205.53,19.39 205.53,19.82 204.32,21.02 204.32,24.7 202.77,26.25 202.77,27.04 202.52,27.3 201.68,27.3 200.71,28.27 200.71,29.1 200.45,29.37 199.74,29.37 199.63,29.48 199.32,29.48 199.17,29.33 198.71,29.33 197.13,30.91 197.13,32.72 196.56,33.3 195.82,33.3 195.59,33.07 v2(195.59,32.81)
  BOTTOM w0.102: v2(206.7,10.53) 205.85,9.67 187.71,9.67 v2(186.83,10.55) ; D6543.2 194.21,32.11 194.98,32.88 195.52,32.88 v2(195.59,32.81)
PCBEEP_EC_C: length 14.1
  IN2 w0.089: v2(196.39,32.92) 196.15,32.69 196.15,31.08 199.28,27.95 v2(200.37,27.95)
  BOTTOM w0.102: C846.2 200.57,28.16 v2(200.37,27.95) 199.9,27.95 R734.1 ; C843.2 198.09,31.31 197.42,31.98 R735.1 196.33,31.09 C844.2 196.23,31.19 195.74,31.67 195.74,32.07 196.39,32.72 v2(196.39,32.92)
PCH_ACPRESENT: length 12.3
  BOTTOM w0.102: U2030.AY15 75.8,44.54 73.37,44.54 72.92,44.08 71.36,44.08 67.73,40.45 R2515.1 67.44,40.17 67.35,40.07 66.8,40.07 R2516.2
PCH_AZ_CODEC_BITCLK: length 209
  IN1 w0.089: v2(58.43,27.57) 58.43,25.2 58.93,24.7 59.45,24.7 59.88,24.27 59.88,23.86 61.7,22.04 61.7,21.55 64.75,18.5 66.33,18.5 67.66,17.18 81.41,17.18 81.92,17.69 81.95,17.69 84.31,20.05 88.07,20.05 90.23,17.89 90.23,17.77 93.18,14.81 97.6,14.81 97.65,14.76 99.77,14.76 100.46,14.08 114.67,14.08 115.28,14.69 117.82,14.69 118.93,13.57 181.91,13.57 185.84,9.64 202.55,9.64 203.64,10.73 203.8,10.88 203.8,11.27 204.53,12.01 204.53,13.01 203.77,13.77 203.77,15.61 203.2,16.18 203.2,19.3 v2(201.1,21.41)
  BOTTOM w0.102: v2(201.1,21.41) 201.36,21.66 201.36,22.12 201.57,22.34 201.57,23.93 201.76,24.13 201.76,25.03 202.02,25.28 204.7,25.28 204.93,25.52 204.93,26.57 C587.2 204.52,27.33 204.48,27.37 204.48,28.36 204.86,28.74 U20.6 ; v2(58.43,27.57) 58.79,27.93 58.79,28.56 59.48,29.25 59.48,31.67 59.61,31.79 59.61,45.51 62.55,48.45 64.7,48.45 65.03,48.12 C2573.2 R2496.1
PCH_AZ_CODEC_RST#: length 200.5
  TOP w0.102: Q21.1 206.48,20.98 205.04,19.55 v2(205.04,19.27)
  IN1 w0.089: v1(61,30.97) 60.36,30.34 60.36,28.79 60.51,28.64 60.51,27.34 61.34,26.52 61.81,26.52 62.82,25.51 62.82,22.01 65.21,19.62 66.8,19.62 67.55,18.87 81.46,18.87 83.81,21.22 88.63,21.22 93.36,16.5 100.42,16.5 101.72,15.19 110.05,15.19 110.92,16.07 118.02,16.07 119.4,14.69 147.01,14.69 182.37,14.69 183.52,13.54 185.45,13.54 185.84,13.15 189.03,13.15 189.8,12.38 189.8,11.8 190.23,11.37 198.64,11.37 199.25,10.76 200.88,10.76 202.65,12.53 202.65,15.15 201.32,16.48 201.32,18.23 199.65,19.9 199.65,21.13 v2(200.1,21.58) 200.44,21.91 201.26,21.91 201.61,21.56 202.49,21.56 204.78,19.27 v2(205.04,19.27)
  BOTTOM w0.102: v1(61,30.97) 61,31.25 60.37,31.88 60.37,42.89 62.77,45.3 64.43,45.3 64.48,45.25 R2498.1 ; v2(200.1,21.58) 199.91,21.77 R738.2
PCH_AZ_CODEC_SDIN0: length 209.6
  IN1 w0.089: v2(200.3,20.81) 200.15,20.81 199.86,20.53 199.86,19.99 201.53,18.32 201.53,16.57 202.87,15.24 202.87,12.44 200.97,10.54 199.16,10.54 198.55,11.15 189.86,11.15 189.26,10.54 187.83,10.54 186.53,11.85 186.53,12.16 185.36,13.32 183.43,13.32 182.28,14.47 175.39,14.47 119.31,14.47 117.93,15.85 111.01,15.85 110.14,14.98 101.63,14.98 100.33,16.28 93.24,16.28 88.53,20.99 83.91,20.99 81.55,18.63 67.48,18.63 66.71,19.4 65.12,19.4 62.6,21.92 62.6,25.42 61.72,26.3 61.15,26.3 60.13,27.32 v2(60.13,27.55)
  BOTTOM w0.102: U20.8 204.06,29.03 203.48,28.45 203.48,27.56 202.91,26.99 202.91,25.8 202.73,25.62 201.86,25.62 201.56,25.31 201.56,24.21 201.37,24.02 201.37,22.42 201.15,22.21 201.15,22.06 200.72,21.63 200.72,21.37 200.3,20.95 v2(200.3,20.81) ; v2(60.13,27.55) 60.13,28.51 60.77,29.15 60.77,30.16 61.4,30.8 61.4,31.2 60.57,32.03 60.57,42.26 63.13,44.82 67.25,44.82 68.58,46.15 72.69,46.15 73.5,46.96 74.11,46.96 74.37,47.22 75.67,47.22 U2030.BA21
PCH_AZ_CODEC_SDOUT: length 202.4
  IN1 w0.089: v2(201.27,20.42) 201.97,19.72 201.97,16.75 203.3,15.42 203.3,13.58 204.06,12.81 204.06,12.21 203.56,11.71 202.74,11.71 201.15,10.11 186.03,10.11 182.1,14.04 119.13,14.04 118.01,15.16 115.15,15.16 114.89,15.42 111.25,15.42 110.37,14.55 100.65,14.55 99.98,15.22 99.88,15.22 99.82,15.28 93.4,15.28 90.71,17.97 90.71,18.1 88.28,20.53 84.11,20.53 81.75,18.17 67.33,18.17 66.53,18.97 64.94,18.97 62.17,21.74 62.17,22.24 60.35,24.06 60.35,24.48 59.65,25.18 59.11,25.18 58.9,25.39 58.9,27.46 v2(59.02,27.57)
  BOTTOM w0.102: U20.5 205.26,28.73 204.68,28.15 204.68,27.54 205.13,27.1 205.13,25.43 204.78,25.08 203.68,25.08 202.91,24.32 202.24,24.32 201.78,23.85 201.78,22.25 201.56,22.04 201.56,21.12 201.27,20.83 v2(201.27,20.42) ; R2495.1 63.97,46.72 63.56,46.32 62.07,46.32 59.96,44.21 59.96,31.63 60.34,31.25 60.34,29.35 59.27,28.28 59.27,27.82 v2(59.02,27.57)
PCH_AZ_CODEC_SYNC: length 199.5
  IN1 w0.089: v2(200.24,20.26) 201.75,18.74 201.75,16.66 203.08,15.33 203.08,12.35 201.06,10.33 199.07,10.33 198.46,10.93 189.95,10.93 189.35,10.33 187.74,10.33 186.31,11.76 186.31,12.07 185.92,12.46 185.56,12.46 185.18,12.08 184.37,12.08 182.19,14.25 175.48,14.25 119.22,14.25 117.84,15.63 111.16,15.63 110.28,14.76 101.54,14.76 100.24,16.06 93.13,16.06 88.43,20.76 84.01,20.76 81.65,18.4 67.41,18.4 66.62,19.19 65.03,19.19 62.39,21.83 62.39,25.33 61.63,26.09 60.98,26.09 59.57,27.49 v2(59.57,27.55)
  BOTTOM w0.102: U20.10 203.26,29.06 202.65,28.45 202.65,28 201.94,27.29 201.94,27.14 201.36,26.56 201.36,25.45 200.8,24.89 200.8,24.29 201.17,23.93 201.17,22.51 200.95,22.29 200.95,22.15 200.51,21.71 200.51,21.45 200.26,21.2 200.09,21.2 199.92,21.02 199.92,20.58 v2(200.24,20.26) ; v2(59.57,27.55) 59.57,28.26 60.54,29.22 60.54,31.38 60.16,31.75 60.16,43.55 62.39,45.78 64.48,45.78 R2497.1
PCH_BATLOW#: length 14.3
  TOP w0.102: v4(77.58,42.45) 76.64,42.45 75.09,40.9 73.01,40.9 71.7,39.58 70.14,39.58 69.3,40.42 TP2040.1 66.17,40.11 R2225.2
  BOTTOM w0.127: U2030.AU13 77.58,42.64 v4(77.58,42.45)
PCH_BLON_C: length 10.9
  TOP w0.102: R440.2 R25369.1 59.04,111.78 59.04,111.16 59.22,110.98 59.22,110.17 58.58,109.54 Q6521.5 57.9,109.54 57.67,109.31 57.67,108.83 57.36,108.52 55.49,108.52 R25365.2 55.02,108.04 v1(55.02,107.17) 55.02,107.01 54.31,106.3 R25366.2
PCH_BLON_EC: length 227.1
  TOP w0.102: R25366.1 53.74,107.48 53.74,110.3 53.38,110.67 53.38,111.8 v1(53.45,111.87) ; U37.88 198.16,24.98 197.97,24.79 197.97,24.41 197.34,23.78 v2(197.05,23.78)
  IN2 w0.089: v2(197.05,23.78) 197.29,23.78 197.67,24.16 197.67,24.98 197.39,25.26 196.83,25.26 196.38,25.72 195.27,25.72 195,25.45 193.89,25.45 192.57,26.77 192.57,28.29 190.76,30.1 184.37,30.1 183.27,31.2 181.32,31.2 181.32,31.2 181.2,31.2 180.6,31.8 178.03,31.8 176.58,30.35 172.92,30.35 172.31,30.95 170.46,30.95 169.79,31.63 165.33,31.63 164.65,32.31 155.52,32.31 154.14,30.93 146.48,30.93 144.16,28.61 143.09,28.61 143.06,28.58 140.69,28.58 140.17,28.06 139.09,28.06 137.64,26.62 136.56,26.62 135.67,27.52 135.67,28.4 135.95,28.69 135.95,31.1 135.5,31.55 132.16,31.55 130.43,33.29 127.87,33.29 124.86,36.3 124.86,37.69 125.53,38.37 125.53,39.76 122.71,42.58 122.71,48.64 121.51,49.85 117.42,49.85 116.05,51.21 116.05,52.69 114.03,54.72 114.03,62.01 114.38,62.37 114.38,66.39 112.97,67.81 106.92,67.81 106.79,67.67 106.37,67.67 106.04,68 106.04,69.01 104.64,70.4 104.51,70.4 103.76,71.15 103.76,76.9 103.38,77.27 103.38,79.05 103.46,79.13 103.46,81.9 99.77,85.59 99.2,85.59 99.03,85.75 99.03,86.74 96.83,88.95 96.18,88.95 93.88,91.24 92.32,91.24 91.19,92.37 91.19,100.46 90.34,101.31 88.37,101.31 87.33,100.27 86.56,100.27 86.21,99.92 85.38,99.92 85.08,100.22 81.98,100.22 81.79,100.41 78.61,100.41 77.08,101.94 76.29,101.94 73.61,104.63 71.37,104.63 64.43,111.57 60.59,111.57 60.53,111.63 55.16,111.63 54.92,111.87 v1(53.45,111.87)
PCH_DISP_ON: length 59.5
  IN1 w0.089: v4(88.88,42.63) 88.57,42.94 88.57,48.27 87.82,49.01 87.41,49.01 87.37,48.96 87,48.96 86.78,49.18 86.78,50.05 85.53,51.31 85.53,70.5 85.27,70.76 85.27,74.17 86.03,74.93 86.03,81.23 86.6,81.8 86.6,83.45 86.31,83.75 86.31,84.25 85.61,84.95 85.61,85.5 85.97,85.86 85.97,87.28 87.26,88.57 87.26,90.81 v1(87.24,90.84)
  BOTTOM w0.102: U2030.U13 88.67,42.63 v4(88.88,42.63) ; v1(87.24,90.84) 86.99,90.84 86.28,91.55 86.28,91.62 85.73,92.17 85.73,93.31 85.5,93.53 84.64,93.53 84.57,93.61 83.15,93.61 R445.2
PCH_DPST_PWM: length 156.9
  TOP w0.102: v1(52.31,107.95) 52.26,107.9 52.26,106.57 52.11,106.42 52.11,106.03 52.39,105.75 R443.1
  IN1 w0.089: v4(89.89,41.4) 90.49,40.8 90.49,38.07 90.85,37.7 91.36,37.7 91.77,38.11 92.65,38.11 92.82,38.29 96.35,38.29 96.89,38.82 97.83,38.82 99.25,37.41 99.25,36.77 101.02,35 101.47,35 102.27,34.2 102.27,33.79 102.55,33.51 103.49,33.51 103.85,33.87 104.5,33.87 104.89,33.49 105.97,33.49 v1(106.19,33.27)
  IN3 w0.089: v1(106.19,33.27) 106.19,34.62 106.11,34.7 106.11,39.66 105.97,39.81 105.97,41.53 105.85,41.65 105.85,41.96 106.57,42.67 106.57,42.92 107.13,43.48 107.58,43.48 108.05,43.95 108.05,44.58 108.5,45.03 108.5,46.45 108.98,46.93 108.98,48.47 106.17,51.28 105.67,51.28 104.66,52.29 103.59,52.29 102.84,53.04 102.84,56.69 101.93,57.6 101.93,60.83 103.59,62.49 104.23,62.49 104.84,63.1 v1(104.84,63.95) 105.12,64.23 105.12,65.11 103.47,66.76 103.47,68.36 102.77,69.06 102.77,70.61 102.95,70.79 102.95,75.87 101.06,77.76 101.06,78.96 101.72,79.62 101.72,82.62 99.87,84.47 99.21,84.47 98.77,84.91 98.77,89.49 97.06,91.2 96.24,91.2 94.3,93.14 94.3,95.11 92.3,97.12 92.3,98.16 90.77,99.69 90.77,101.31 89.49,102.58 88.79,102.58 88.04,101.83 82.45,101.83 82.04,102.24 80.63,102.24 76.83,106.04 75.6,106.04 72.98,108.66 70.93,108.66 69.92,109.68 69.92,110.33 69.43,110.82 66.9,110.82 66.29,111.43 62.47,111.43 62.18,111.15 61.19,111.15 60.92,110.88 60.92,110.56 60.64,110.28 56.9,110.28 56.51,109.89 55.1,109.89 54.62,109.41 54.33,109.41 53.9,108.98 53.9,108.41 53.44,107.95 v1(52.31,107.95)
  BOTTOM w0.102: v1(104.84,63.95) 104.94,63.84 R2489.2 ; v4(89.89,41.4) 89.62,41.67 U2030.R11
PCH_LVDS_BLON: length 154.3
  TOP w0.079: v4(88.89,41.96) 88.91,41.96 89.04,42.09 91.16,42.09 91.82,41.43 91.82,39.5 91.87,39.45 91.87,38.59 92.61,37.85 92.61,37.31 94.16,35.76 97.21,35.76 97.83,35.14 98.08,35.14
  TOP w0.102: R25365.1 54.26,108.63 v1(54.3,108.67) ; 98.08,35.14 98.31,35.14 98.82,34.63 99.62,34.63 101.58,32.67 101.58,31.65 102.07,31.16 102.07,29.81 102.38,29.49 103.11,29.49 103.36,29.24 v1(103.7,29.24)
  IN3 w0.089: v1(54.3,108.67) 54.44,108.67 55.27,109.5 56.68,109.5 57.06,109.89 61.65,109.89 62.8,111.04 66.12,111.04 66.74,110.43 69.27,110.43 69.52,110.17 69.52,109.51 71.34,107.69 73.39,107.69 75.44,105.65 76.67,105.65 80.47,101.85 81.52,101.85 82.64,100.74 84.84,100.74 85.14,101.03 87.8,101.03 88.88,102.12 89.4,102.12 90.37,101.14 90.37,99.53 91.9,98 91.9,96.95 93.91,94.95 93.91,92.98 96.07,90.81 96.9,90.81 98.38,89.33 98.38,84.74 99.04,84.08 99.71,84.08 101.33,82.46 101.33,79.89 100.65,79.21 100.65,77.61 102.56,75.7 102.56,71.04 102.37,70.85 102.37,68.89 103.06,68.21 103.06,66.61 104.1,65.57 104.1,63.56 101.53,61 101.53,57.43 102.44,56.53 102.44,52.88 103.43,51.9 104.5,51.9 105.57,50.83 106.07,50.83 108.59,48.3 108.59,47.31 108.11,46.82 108.11,45.19 107.66,44.74 107.66,44.12 107.42,43.88 106.97,43.88 106.18,43.08 106.18,42.84 105.14,41.8 105.14,41.01 105.41,40.73 105.41,39.81 105.71,39.51 105.71,32.73 104.56,31.57 104.56,30.92 104.06,30.42 104.06,29.59 v1(103.7,29.24)
  BOTTOM w0.102: U2030.R12 89.04,41.96 v4(88.89,41.96)
PCH_MBCLK0_R: length 16.3
  TOP w0.079: v4(88.98,38.74) 89.5,38.22 89.5,37.92 90.17,37.25 90.17,36.37 92.01,34.52 92.97,34.52 93.45,34.05 94.13,34.05 95.98,32.19 96.61,32.19
  TOP w0.102: 96.61,32.19 98.54,32.19 v1(98.94,31.8)
  BOTTOM w0.102: v4(88.98,38.74) 89.31,39.06 U2030.R7 ; Q2026.6 99.9,31.08 99.73,31.25 R2606.2 98.94,31.61 v1(98.94,31.8)
PCH_MBDAT0_R: length 24.7
  TOP w0.079: v4(89.83,39.43) 89.44,39.05 89.44,38.49 89.65,38.29 89.65,37.99 90.33,37.31 90.33,36.43 92.08,34.68 93.04,34.68 93.51,34.21 94.19,34.21 96.02,32.37 96.7,32.37
  TOP w0.102: 96.7,32.37 96.7,32.38 99.02,32.38 v1(99.57,31.83)
  BOTTOM w0.102: Q2026.3 102.98,29.78 103.3,29.47 103.3,28.81 103.56,28.54 R2605.2 103.88,28.54 104.13,28.79 104.13,29.58 v1(103.87,29.84) 103.87,30.07 103.45,30.5 103.27,30.5 102.96,30.8 102.96,31.32 102.81,31.47 99.94,31.47 99.58,31.83 v1(99.57,31.83) ; U2030.R8 89.56,39.72 89.83,39.44 v4(89.83,39.43)
PCH_OPI_RCOMP: length 12.7
  TOP w0.079: v4(78.19,44.29) 77.77,44.63 77.53,44.72 76.57,44.72
  TOP w0.381: 76.57,44.72 73.09,44.72 72.83,44.46 R2202.2
  BOTTOM w0.102: U2030.AU16 v4(78.19,44.29)
PCH_PWRBTN#: length 13.8
  BOTTOM w0.079: U2030.BA15 75.11,43.94 74.53,43.94 74.32,44.16 73.88,44.16 73.75,44.02
  BOTTOM w0.102: 73.75,44.02 73.32,43.6 71.52,43.6 67.83,39.91 67.83,39.48 67.4,39.05 66.31,39.05 65.85,38.59 65.47,38.59 65.19,38.31 R2523.1
PCH_PWROK: length 186.2
  TOP w0.102: v1(103.55,22.5) 103.64,22.59 103.64,22.72 105.5,24.58 106.24,24.58 106.64,24.98 106.64,25.6 107.6,26.56 108.01,26.56 109.23,27.79 R2257.2 ; v2(197.59,20.82) 197.75,20.98 U37.78
  IN1 w0.089: v2(197.59,20.82) 197.11,20.34 196.65,20.34 196.02,20.98 196.02,21.33 195.29,22.06 195.29,22.37 195.08,22.57 194.34,22.57 193.88,23.03 193.26,23.03 192.87,23.42 191.82,23.42 189.99,21.59 189.99,19.59 189.36,18.96 188.86,18.96 188.06,19.76 187.62,19.76 187.27,20.1 185.01,20.1 184.61,20.5 182.87,20.5 181,22.38 177.76,22.38 176.98,21.6 167.24,21.6 166.94,21.9 164.59,21.9 163.04,23.46 161.94,23.46 160.38,21.9 154.35,21.9 153.72,22.53 147.25,22.53 146.62,21.9 137.27,21.9 136.75,21.39 134.08,21.39 133.67,21.8 126.53,21.8 125.95,22.38 123.09,22.38 123.06,22.35 122.13,22.35 121.88,22.6 120.64,22.6 120.25,22.21 114.67,22.21 114.49,22.4 111.46,22.4 111.28,22.21 105.29,22.21 104.61,22.9 103.95,22.9 v1(103.55,22.5) 103.4,22.5 101.66,24.25 100.45,24.25 99.21,25.48 94.73,25.48 92.04,28.18 85.51,28.18 84.69,27.37 83.12,27.37 80.76,29.73 79.94,29.73 78.85,30.82 78.85,31.38 78.45,31.79 76.13,31.79 73.37,34.56 72.25,34.56 71.49,35.32 69.4,35.32 68.57,36.16 68.11,36.16 67.14,35.19 67.14,34.38 64.46,31.7 62.91,31.7 62.42,31.2 61.94,31.2 61.5,30.77 61.5,30.49 61.23,30.21 v1(61.23,29.15)
  BOTTOM w0.102: v1(61.23,29.15) 61.25,29.12 61.71,29.12 62.59,30 62.59,31.62 61.83,32.38 61.83,40.66 64.09,42.91 64.88,42.91 65.06,42.74 R2505.1 65.19,42.51 R2507.1
PCH_RSMRST#: length 14.7
  BOTTOM w0.102: R2504.2 R2502.1 R2503.2 65.93,44.36 66.03,44.46 67.54,44.46 v1(67.69,44.61) 68.98,45.9 72.72,45.9 73.56,46.74 74.37,46.74 74.58,46.95 75.54,46.95 75.72,46.77 75.72,46.48 75.45,46.21 75.45,46 75.64,45.81 75.9,45.81 76.05,45.66 U2030.AY17
PCH_SLP_A#: length 3.4
  TOP w0.079: v4(80.74,44.28) 81.12,43.9 81.51,43.9 81.73,44.12 81.73,44.27 81.88,44.41 82.48,44.41 82.55,44.49 82.65,44.49 TP2032.1
  BOTTOM w0.102: v4(80.74,44.28) 80.46,44.56 U2030.AN16
PCH_SLP_LAN#: length 13.2
  TOP w0.102: v4(77.47,43.38) 76.97,43.38 76.86,43.27 76.09,43.27 75.57,42.76 72.29,42.76 71.55,42.02 TP2038.1
  BOTTOM w0.102: U2030.AW15 76.89,44.28 77.47,43.7 v4(77.47,43.38)
PCH_SLP_S0_N: length 116.5
  TOP w0.079: v4(78.83,42.54) 78.38,43 76.24,43 75.77,42.53 75.25,42.53
  TOP w0.102: 75.25,42.53 72.56,42.53 71.42,41.39 68.41,41.39 68.13,41.67 66.51,41.67 65.09,40.25 64.46,40.25 64.14,39.92 62.93,39.92 62.59,39.58 R38.1 61.84,39.28 61.73,39.17 60.8,39.17 59.7,38.07 59.7,32.9 58.63,31.84 58.63,28.79 58,28.15 58,26.94 v2(59.35,25.59) ; R592.1 125.87,16.55 125.64,16.78 123.51,16.78 v1(122.97,16.24)
  IN2 w0.089: v2(59.35,25.59) 59.35,25.36 60.18,24.52 60.18,24.29 60.56,23.91 61.61,23.91 63.23,25.54 66.56,25.54 67.52,24.57 73.8,24.57 75.15,25.92 81.51,25.92 81.97,26.38 86.96,26.38 87.59,27.01 92.55,27.01 92.71,26.86 93.65,26.86 94.36,26.15 98.97,26.15 100.68,24.44 102.73,24.44 104.05,23.11 104.42,23.11 104.86,22.67 104.86,22.41 106.67,20.6 119.53,20.6 121.83,22.91 v1(122.17,22.91)
  BOTTOM w0.102: U2030.AT11 78.51,42.22 v4(78.83,42.54) ; v1(122.17,22.91) 122.67,22.4 122.67,21.19 122.79,21.07 122.79,19.46 123.2,19.06 123.2,16.8 122.97,16.58 v1(122.97,16.24)
PCH_SLP_S5#: length 10.7
  BOTTOM w0.102: U2030.AY16 76.16,44.86 75.81,45.21 75.62,45.21 75.35,44.94 73.2,44.94 72.87,44.61 70.83,44.61 67.98,41.77 TP2079.1
PCH_SLP_SUS#: length 2
  TOP w0.102: TP2035.1 80.06,42.58 80.86,43.37 v4(80.86,43.37)
  BOTTOM w0.102: v4(80.86,43.37) 80.46,43.77 U2030.AN15
PCH_SLP_WLAN#: length 8.4
  BOTTOM w0.102: TP2078.1 68.24,43.14 70.26,45.16 72.85,45.16 73.11,45.43 U2030.BB17
PCH_SPI1_CLK: length 105.1
  TOP w0.102: R2622.2 159.09,31.14 C2606.1 159.07,30.9 v1(158.63,30.47) ; v1(121.07,24.29) 121.58,24.8 R596.1
  IN1 w0.089: v1(121.07,24.29) 121.07,24.19 120.38,23.5 113.28,23.5 112.85,23.93 109.19,23.93 108.59,23.33 106.66,23.33 106.02,23.96 104.42,23.96 102.75,25.63 101.69,25.63 100.37,26.95 99.86,26.95 99.6,27.22 99.6,27.92 99.07,28.44 99.07,28.74 98.97,28.84 96.48,28.84 95.99,29.32 93.18,29.32 92.88,29.02 91.55,29.02 91.04,29.53 90.66,29.53 90,28.87 88.02,28.87 87.92,28.97 85.3,28.97 84.36,28.03 83.45,28.03 80.81,30.67 79.97,30.67 79.54,31.1 79.54,31.66 79.01,32.19 78.28,32.94 78.28,33.43 78.03,33.68 78.03,33.69 77.99,33.73 77.99,34.1 78.03,34.14 v1(78.03,34.37)
  IN3 w0.089: v1(158.63,30.47) 159.68,29.41 159.68,27.56 159.95,27.28 159.95,25.92 159.45,25.41 159.45,25.14 158.51,24.2 158.09,24.2 158.02,24.14 153.48,24.14 153.25,23.91 152.2,23.91 150.79,22.5 148.93,22.5 148.58,22.85 136.89,22.85 135.27,24.48 125.89,24.48 125.82,24.42 121.2,24.42 v1(121.07,24.29)
  BOTTOM w0.076: 76.66,35.07 76.97,35.38 76.97,35.86 77.13,36.03 77.13,36.5 U2030.AV2
  BOTTOM w0.102: v1(78.03,34.37) 77.9,34.24 77.2,34.24 76.66,34.78 76.66,35.07
PCH_SPI1_CLK_R: length 40.6
  TOP w0.102: v1(160.53,30.47) 160.53,32.6 R2616.1 ; v2(191.98,28.08) 192.23,28.08 192.73,28.57 193.21,28.57 193.39,28.75 193.54,28.75 193.72,28.93 193.95,28.93 194.05,29.03 U37.105
  IN3 w0.089: v1(160.53,30.47) 160.53,30.85 160.64,30.95 161.98,30.95 162.76,30.17 163.19,30.17 163.72,29.65 164.18,29.65 166.32,27.51 171.16,27.51 171.92,28.28 176.72,28.28 177.54,27.47 185.8,27.47 187.05,28.72 188.37,28.72 188.76,28.33 191.23,28.33 191.48,28.08 v2(191.98,28.08)
PCH_SPI1_SI: length 107.7
  TOP w0.102: R597.1 121.43,20.1 120.66,20.86 120.66,21.75 121.3,22.38 121.3,23.02 121.49,23.21 121.49,23.69 121.29,23.88 120.49,23.88 120.28,24.09 v1(120.28,24.7) ; R2611.2 157.56,32.73 157.56,30.18 157.5,30.11 157.5,28.8 157.62,28.68 157.62,28.51 158.25,27.88 158.25,27.28 158.1,27.13 158.1,26.27 158.41,25.95 v1(158.41,25.73)
  IN1 w0.089: v1(120.28,24.7) 119.55,23.97 113.48,23.97 113.05,24.4 109,24.4 108.4,23.8 106.85,23.8 106.22,24.43 104.61,24.43 102.94,26.1 101.89,26.1 100.61,27.38 100.61,27.93 100.02,28.52 100.02,28.92 99.79,29.15 99.32,29.15 99.17,29.31 96.67,29.31 96.19,29.79 92.99,29.79 92.68,29.49 91.75,29.49 91.23,30.01 90.31,30.01 89.65,29.35 88.23,29.35 88.12,29.45 82.71,29.45 81.09,31.08 81.09,31.25 81.09,31.38 79.79,32.68 79.2,32.68 78.75,33.13 78.75,33.63 78.62,33.76 v1(78.47,33.91)
  IN3 w0.089: v1(158.41,25.73) 158.4,25.73 157.61,24.94 151.13,24.94 151.01,24.82 136.39,24.82 136.05,25.16 125.51,25.16 124.9,25.77 124,25.77 123.36,25.13 120.71,25.13 v1(120.28,24.7)
  BOTTOM w0.076: U2030.AV3 76.97,37.02 76.97,36.1 76.8,35.93 76.8,35.5 76.64,35.34
  BOTTOM w0.102: v1(78.47,33.91) 78.34,33.78 78.04,33.78 77.79,34.04 77.03,34.04 76.41,34.66 76.41,35.12 76.64,35.34
PCH_SPI1_SI_R: length 44.3
  TOP w0.102: v1(157.99,30.47) 158.05,30.52 R2617.1 ; R25303.1 194.62,32.04 194.89,31.78 194.89,31.13 v2(195.04,30.98) 195.25,30.78 U37.102
  IN3 w0.089: v1(157.99,30.47) 157.99,30.61 158.32,30.94 159.95,30.94 160.44,31.42 162.17,31.42 162.96,30.64 163.85,30.64 166.51,27.98 169.41,27.98 170.18,28.75 179.84,28.75 180.65,27.94 183.85,27.94 185.1,29.19 189.62,29.19 190.31,29.88 194.16,29.88 195.04,30.76 v2(195.04,30.98)
PCH_SPI1_SO: length 113.5
  TOP w0.102: v1(121.02,23.47) 121.09,23.4 121.09,22.47 120.36,21.73 120.36,18.25 R583.1 120.87,16.98 121.06,16.79 121.23,16.79 121.4,16.62 R598.1 ; v1(159.9,30.47) 159.85,30.42 R2619.1
  IN1 w0.089: v1(79.19,33.28) 79.56,32.9 79.93,32.9 81.33,31.49 81.33,31.16 82.82,29.68 88.35,29.68 88.91,30.24 91.3,30.24 91.84,29.7 92.59,29.7 92.9,30.01 95.79,30.01 96.34,30.55 96.86,30.55 97.89,29.53 99.26,29.53 99.41,29.37 99.88,29.37 100.24,29.01 100.24,28.61 100.83,28.02 100.83,27.47 101.98,26.32 103.03,26.32 104.7,24.65 106.31,24.65 106.94,24.01 108.31,24.01 108.91,24.62 113.14,24.62 113.57,24.19 118.74,24.19 119.66,25.1 120.82,25.1 121.54,24.38 121.54,23.8 121.22,23.47 v1(121.02,23.47)
  IN3 w0.089: v1(159.9,30.47) 159.9,30.44 160.66,29.68 160.66,25.96 159.92,25.22 159.92,24.93 158.72,23.74 158.5,23.74 158.32,23.55 154.07,23.55 153.96,23.44 152.4,23.44 150.99,22.03 148.74,22.03 148.38,22.38 136.7,22.38 135.13,23.95 121.5,23.95 v1(121.02,23.47)
  BOTTOM w0.102: v1(79.19,33.28) 79.14,33.23 78.03,33.23 77.62,33.63 76.75,33.63 75.93,34.45 75.93,35.16 75.54,35.55 75.54,35.82 75.72,36 75.72,36.44 75.9,36.62 76.02,36.62 76.03,36.63 76.37,36.63 U2030.AW3
PCH_SPI1_SO_R: length 41.6
  TOP w0.102: v1(161.8,30.47) 161.2,29.86 R2626.1 ; R25316.1 194.65,31.48 194.65,30.74 194.85,30.55 U37.103 194.85,29.09 194.45,28.69 v2(194.35,28.69)
  IN3 w0.089: v2(194.35,28.69) 192.92,28.69 192.7,28.46 192.7,27.47 192.31,27.08 191.78,27.08 191,27.86 188,27.86 187.97,27.83 186.83,27.83 185.99,27 177.34,27 176.53,27.81 174.19,27.81 173.34,26.96 170.06,26.96 169.81,26.71 164.95,26.71 161.8,29.86 v1(161.8,30.47)
PCH_SPI_CS0#: length 111.5
  TOP w0.102: R2628.2 161.63,28.92 v1(161.28,28.56)
  IN1 w0.089: v1(78.37,34.95) 78.54,35.13 82.17,35.13 82.5,34.8 82.52,34.77 82.52,30.86 83.25,30.14 87.82,30.14 88.45,30.77 91.38,30.77 92.02,30.14 92.41,30.14 92.72,30.44 95.62,30.44 96.31,31.14 97.39,31.14 97.87,30.66 98.95,30.66 99.21,30.4 100.08,30.4 100.31,30.17 100.31,29.55 100.67,29.19 100.67,28.79 101.52,27.95 102.66,27.95 103.15,27.46 103.15,26.82 104.88,25.08 106.49,25.08 107.12,24.45 108.13,24.45 108.73,25.05 113.32,25.05 113.7,25.43 114.52,25.43 v4(114.84,25.11)
  IN3 w0.089: v4(114.84,25.11) 114.84,25.03 114.77,24.95 114.77,22.91 115.31,22.38 120.47,22.38 120.95,22.86 121.31,22.86 121.97,23.52 125.76,23.52 125.97,23.31 127.34,23.31 127.98,22.67 132.37,22.67 132.61,22.91 135.56,22.91 136.52,21.95 148.2,21.95 148.56,21.6 151.17,21.6 152.58,23 154.14,23 154.25,23.12 158.5,23.12 158.68,23.3 160.32,23.3 161.54,24.53 162.88,24.53 163.21,24.85 163.21,26.02 161.28,27.95 v1(161.28,28.56)
  BOTTOM w0.076: v1(78.37,34.95) 77.96,35.36 77.86,35.36 77.66,35.55 77.66,36.22 77.69,36.44 77.71,36.49 U2030.AU3
  BOTTOM w0.102: v1(161.28,28.56) 161.17,28.46 161.17,27.85 161.89,27.14 163.13,27.14 163.26,27.01 U2031.1
PCH_SPI_CS0#_R: length 41.5
  TOP w0.102: v2(195.01,28.69) 195.21,28.89 195.43,28.89 195.65,29.11 U37.101 ; v1(161.99,28.54) 162.09,28.63 R2628.1 162.09,30.01 162.24,30.16 162.24,30.72 161.6,31.36 R2631.2
  IN3 w0.089: v1(161.99,28.54) 162.83,28.54 164.86,26.5 169.9,26.5 170.15,26.75 173.43,26.75 174.28,27.6 176.44,27.6 177.25,26.78 186.08,26.78 186.92,27.62 188.06,27.62 188.09,27.64 190.92,27.64 191.69,26.87 192.4,26.87 192.91,27.38 192.91,27.89 193.28,28.26 194.47,28.26 194.91,28.69 v2(195.01,28.69)
PCH_SPI_IO2: length 98.1
  TOP w0.102: v1(158.76,25.19) 158.85,25.28 158.85,26.01 158.35,26.5 158.35,27.06 158.48,27.19 158.48,27.98 157.92,28.54 R2621.1
  IN1 w0.089: v1(79.16,33.91) 79.27,33.91 80.44,32.74 81.55,31.64 81.55,31.34 82.98,29.91 87.92,29.91 88.48,30.47 91.38,30.47 91.93,29.92 92.5,29.92 92.81,30.22 95.7,30.22 96.25,30.77 96.95,30.77 97.98,29.74 99.57,29.74 99.72,29.59 99.97,29.59 100.45,29.1 100.45,28.7 101.05,28.11 101.05,27.56 102.07,26.54 103.12,26.54 104.79,24.87 106.4,24.87 107.03,24.23 108.22,24.23 108.82,24.83 113.23,24.83 113.66,24.4 116.76,24.4 117.46,25.11 v4(117.47,25.11)
  IN3 w0.089: v1(158.76,25.19) 158.49,25.19 158.02,24.72 151.25,24.72 151.14,24.61 136.3,24.61 135.96,24.95 125.42,24.95 124.81,25.56 124.09,25.56 123.45,24.92 121.08,24.92 120.61,24.45 120.61,24.17 120.48,24.04 118.4,24.04 117.47,24.97 v4(117.47,25.11)
  BOTTOM w0.102: v1(79.16,33.91) 79.05,33.91 78.62,33.48 78.06,33.48 77.71,33.83 76.88,33.83 76.2,34.51 76.2,35.82 U2030.AW2
PCH_SPI_IO3: length 110
  TOP w0.102: R2625.1 161.02,32.51 161.02,31.13 161.17,30.98 v1(161.17,30.47)
  IN1 w0.089: v4(116.06,25.13) 115.55,25.65 113.61,25.65 113.23,25.27 108.64,25.27 108.04,24.66 107.21,24.66 106.58,25.3 104.97,25.3 103.36,26.91 103.36,27.7 102.9,28.16 101.92,28.16 101.6,28.48 101.6,29.28 100.27,30.62 99.3,30.62 99.04,30.88 97.96,30.88 97.48,31.36 96.22,31.36 95.53,30.66 92.96,30.66 92.37,31.25 89.88,31.25 89.61,30.99 88.16,30.99 87.54,30.36 83.73,30.36 83.65,30.44 83.5,30.44 82.84,31.1 82.84,35.01 82.33,35.52 78.3,35.52 v1(77.74,34.95)
  IN3 w0.089: v4(116.06,25.13) 116.06,24.85 115,23.79 115,22.99 115.4,22.59 120.38,22.59 120.86,23.07 121.22,23.07 121.88,23.73 135.04,23.73 136.61,22.17 148.29,22.17 148.65,21.81 151.08,21.81 152.49,23.22 154.05,23.22 154.16,23.33 158.41,23.33 158.59,23.52 158.81,23.52 160.13,24.84 160.13,25.13 160.88,25.87 160.88,29 161.17,29.29 v1(161.17,30.47)
  BOTTOM w0.076: v1(77.74,34.95) 77.5,35.19 77.5,36.39 77.55,36.56 77.68,36.82 77.68,37.27 77.95,37.54 U2030.AU4
