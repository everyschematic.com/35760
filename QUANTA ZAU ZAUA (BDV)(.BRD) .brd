# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 69.58,125.77 69.58,125.03 69.53,124.98 68.74,124.98 68.72,124.98 68.71,124.99 68.34,125.36 68.13,125.36 68.03,125.46 68.03,125.77 68.14,125.87 69.48,125.87
GND on TOP (solid shape): 126.38,121.5 128.15,121.5 128.69,120.97 128.69,120.36 128.51,120.18 127.72,120.18 127.11,120.79 125.49,120.79 125.41,120.86 125.41,121.91 125.46,121.96 125.92,121.96
GND on TOP (solid shape): 127.44,50.05 127.44,49.97 128.14,49.27 128.14,47.93 128.07,47.87 124.7,47.87 124.31,48.26 124.31,49.81 124.09,50.02 124.09,50.89 124.15,50.95 126.54,50.95
GND on TOP (solid shape): 31.18,26.3 31.18,23.66 31.08,23.56 31.08,23.02 31,22.95 30.44,22.95 29.68,23.71 29.68,24.5 29.53,24.65 29.53,25.92 30.02,26.41 31.07,26.41
GND on TOP (solid shape): 115.25,55.41 115.25,53.68 115.14,53.57 114.93,53.57 114.92,53.55 111.36,53.55 111.09,53.83 110.15,53.83 110.04,53.94 110.04,55.33 110.37,55.66 115,55.66
GND on TOP (solid shape): 129.58,24.73 129.58,23.71 129.93,23.35 130.24,23.35 130.41,23.18 130.41,22.87 130.01,22.47 129.35,22.47 129.09,22.72 127.9,22.72 127.82,22.8 127.82,24.55 128.03,24.76 129.55,24.76
GND on TOP (solid shape): 155.18,18.68 155.18,17.96 154.96,17.74 151.31,17.74 150.95,18.1 150.95,18.68 150.97,18.72 151,18.73 155.13,18.73
GND on TOP (solid shape): 26.99,16.65 26.94,16.6 26.17,16.6 25.56,15.99 25.56,13.55 25.08,13.07 24.82,13.07 24.52,13.37 24.52,13.6 24.02,14.09 23.99,14.09 23.99,16.85 24.5,17.36 26.99,17.36
GND on TOP (solid shape): 48.8,122.59 48.8,120.37 48.64,120.2 47.14,120.2 47,120.34 47,120.77 47.05,120.82 47.05,122.64 47.18,122.77 48.62,122.77
GND on TOP (solid shape): 71.75,115.05 71.87,115.05 72.1,114.82 72.1,114.59 72.02,114.51 71.59,114.51 71.41,114.34 71.41,114.08 71.28,113.96 70.9,113.96 70.75,114.11 70.75,114.64 70.57,114.82 70.57,115.43 70.7,115.56 71.24,115.56
GND on TOP (solid shape): 87.18,68.74 87.18,67.42 87.59,67.02 87.59,66.08 87.2,65.68 87.2,64.16 86.85,63.82 86.85,62.95 86.63,62.72 85.36,62.72 85.18,62.9 85.18,69.33 85.41,69.56 86.37,69.56
GND on TOP (solid shape): 16.98,47.08 16.98,46.67 16.57,46.26 16.57,43.67 16.22,43.32 14.06,43.32 13.7,43.67 13.7,45.43 13.96,45.81 14.15,46.23 15.07,47.15 16.9,47.15
GND on TOP (solid shape): 25.76,5.18 25.79,5.2 25.83,5.18 26.27,4.74 26.27,2.93 26.1,2.75 25.03,2.75 24.93,2.86 24.93,3.26 25.08,3.42 25.08,4.2 25.16,4.28 25.16,5.02 25.26,5.12 25.69,5.12
GND on TOP (solid shape): 50.38,78.75 50.38,78.19 49.95,77.77 46.8,77.77 46.19,78.38 46.11,78.4 46.07,78.48 46.07,78.54 46.41,78.88 50.25,78.88
GND on TOP (solid shape): 128.55,30.64 128.55,29.16 128.73,28.99 129.23,28.99 129.5,28.71 129.5,27.89 129.33,27.72 128.38,27.72 128.15,27.95 128.15,28.64 127.8,28.99 127.57,28.99 126.87,29.7 126.87,30.25 126.75,30.36 126.75,30.65 126.91,30.81 128.38,30.81
GND on TOP (solid shape): 136.71,98.79 136.71,96.65 136.71,96.62 136.71,95.11 136.46,94.86 136.24,94.86 134.17,96.92 134.17,97.52 134.17,97.52 134.17,97.67 134.15,97.7 134.15,99.2 134.38,99.43 136.08,99.43
GND on TOP (solid shape): 87.49,85.61 87.92,85.61 88.14,85.83 93.71,85.83 94.09,85.45 94.09,84.5 93.79,84.2 91.63,84.2 91.57,84.26 90.74,84.26 90.69,84.3 86.61,84.3 85.76,85.15 85.76,85.43 85.91,85.58 86.24,85.58 86.8,86.14 86.96,86.14
GND on TOP (solid shape): 87.84,58 91.27,58 91.43,57.85 91.43,55.92 91.27,55.76 89.95,55.76 89.57,55.38 89.39,55.38 89.01,55.76 83.58,55.76 83.29,56.06 83.29,57.96 83.32,58 87.16,58 87.23,58.08 87.77,58.08
GND on TOP (solid shape): 111.48,111.73 111.48,110.72 111.31,110.55 111.11,110.55 110.98,110.68 110.98,110.83 110.86,110.96 109.92,110.96 109.79,110.83 109.79,110.37 109.74,110.32 109.13,110.32 109.08,110.37 109.08,111.29 109.33,111.54 110.86,111.54 111.16,111.85 111.36,111.85
GND on TOP (solid shape): 127.52,56.25 128.05,56.25 128.13,56.17 128.13,55.54 128.08,55.49 126.64,55.49 126.45,55.54 126.26,55.49 125.87,55.49 125.79,55.56 125.79,56.17 126.38,56.76 127.01,56.76
GND on TOP (solid shape): 16.19,115.07 16.19,113.24 15.82,112.88 14.91,112.88 14.9,112.89 14.15,113.46 13.31,113.88 13.31,115.9 13.55,116.14 15.12,116.14
GND on TOP (solid shape): 41.46,101.84 41.46,101.51 41.18,101.23 41.18,101.05 41.16,100.97 41.15,100.9 41.16,100.85 41.17,100.78 41.17,100.71 41.11,100.65 40.63,100.65 39.91,101.36 39.91,101.87 39.97,101.92 41.39,101.92
GND on TOP (solid shape): 41.16,110.98 41.16,109.87 41.67,109.36 41.67,109 41.15,108.48 41.15,108.02 41.03,107.91 40.86,107.91 40.79,107.93 40.73,107.94 40.63,107.94 40.51,108.05 40.51,108.46 40.65,108.6 40.65,111.01 40.78,111.14 41.01,111.14
GND on TOP (solid shape): 142.35,39.7 142.35,39.5 143.06,38.78 143.06,38.38 142.58,37.89 142.58,35.93 142.48,35.84 142.1,35.84 141.97,35.97 141.97,37.33 141.6,37.69 141.6,38.35 141.52,38.43 141.52,39.02 141.81,39.31 141.81,39.67 141.96,39.83 142.22,39.83
GND on TOP (solid shape): 16.7,86.22 16.93,86.22 17.08,86.07 17.08,86.04 17.49,85.63 18.6,85.63 18.81,85.43 18.81,85.15 18.65,85 16.37,85 16.23,84.86 16.23,84.07 15.71,83.55 15.17,83.55 15.07,83.65 15.07,85.08 15.23,85.23 15.99,85.23 16.24,85.48 16.24,86.1 16.37,86.23 16.69,86.23
GND on TOP (solid shape): 18.26,35.1 19.33,35.1 19.42,35.01 19.42,33.77 19.24,33.59 18.36,33.59 18.32,33.61 18.29,33.61 17.78,33.61 17.75,33.61 17.71,33.59 16.52,33.59 16.39,33.72 16.39,34.05 16.62,34.28 16.88,34.28 17.71,35.11 18.25,35.11
GND on TOP (solid shape): 100.82,108.65 100.82,108.29 100.51,107.97 99.08,107.97 98.36,107.25 98.36,103.75 98.07,103.45 94.55,103.45 94.04,103.96 94.04,107.38 94.56,107.9 98.53,107.9 98.91,108.28 99.02,108.28 99.3,108.56 100.18,108.56 100.32,108.7 100.77,108.7
GND on TOP (solid shape): 116.65,61.07 116.65,60.77 116.5,60.62 116.34,60.62 116.27,60.54 116.27,60.06 116.28,60.04 116.28,59.89 116.42,59.75 116.57,59.75 116.67,59.65 116.67,59.42 115.91,58.66 112.89,58.66 112.77,58.77 112.77,60.76 112.94,60.92 115,60.92 115.23,61.15 116.57,61.15
GND on TOP (solid shape): 158.08,27.72 158.08,27.39 157.48,26.8 157.48,26.36 157.39,26.28 153.43,26.28 153,26.71 152.39,26.71 152.31,26.78 152.31,27.7 152.41,27.8 152.81,27.8 153.4,27.21 157.34,27.21 157.44,27.32 157.44,27.72 157.54,27.82 157.97,27.82
GND on TOP (solid shape): 28.59,101.36 28.59,98.21 27.76,97.38 27.76,94.39 27.67,94.3 25.89,94.3 25.61,94.58 25.61,96.86 25.63,96.87 25.63,97 26.2,97.57 26.63,97.57 26.81,97.75 26.89,97.75 27.04,97.9 27.06,97.9 27.75,98.59 27.75,98.69 27.77,98.72 27.77,101.48 27.93,101.64 28.31,101.64
GND on TOP (solid shape): 146.07,31.35 146.37,31.35 146.49,31.23 146.49,30.72 143.7,27.93 143.14,27.93 141.69,29.37 141.69,29.6 141.84,29.75 142.99,29.75 143.22,29.98 143.22,30.31 143.52,30.62 143.98,30.62 144.18,30.82 144.18,31.25 144.28,31.36 146.04,31.36
GND on TOP (solid shape): 46.47,97.75 47.08,97.75 47.23,97.6 47.23,97.37 47.1,97.24 44.99,97.24 44.92,97.32 40.42,97.32 40.3,97.45 40.3,98 40.52,98.23 41.82,98.23 42.23,98.64 42.23,98.94 42.34,99.06 42.52,99.06 42.53,99.07 42.53,99.58 42.66,99.71 44.51,99.71
GND on TOP (solid shape): 18.45,29.93 18.45,28.89 18.73,28.61 18.73,26.66 18.63,26.55 18.05,26.55 17.89,26.71 17.89,27.93 17.86,27.95 17.86,27.96 17.78,28.09 17.65,28.18 17.64,28.18 17.61,28.21 17.49,28.21 16.72,28.21 16.42,28.51 16.42,28.87 17.66,30.11 18.27,30.11
GND on TOP (solid shape): 65.9,45.68 65.9,44.18 65.48,43.76 63.96,43.76 63.41,43.22 62.42,43.22 61.96,43.67 61.96,45.17 62.01,45.22 64.02,45.22 64.2,45.15 64.38,45.12 64.65,45.17 64.87,45.32 65.28,45.74 65.84,45.74
GND on TOP (solid shape): 109.03,124.45 109.03,121.91 108.47,121.35 108.47,120.03 108.39,119.95 107.74,119.95 107.59,120.1 107.59,120.78 107.84,121.04 107.84,121.71 107.65,121.91 105.42,121.91 105.22,122.11 105.22,122.13 105.14,122.21 105.14,123.84 105.78,124.47 105.78,124.88 105.88,124.98 108.49,124.98
GND on TOP (solid shape): 51.24,28.26 51.24,28 51.28,27.97 51.28,27.96 51.34,27.84 51.45,27.78 51.47,27.78 51.5,27.75 52,27.75 52.41,27.34 52.41,26.99 52.31,26.88 51.85,26.88 51.48,27.25 50.14,27.25 49.64,27.75 48.6,27.75 48.17,27.32 47.76,27.32 47.71,27.37 47.71,27.85 48.58,28.71 50.79,28.71
GND on TOP (solid shape): 124.55,80.3 124.55,80.1 124.56,80.08 124.66,79.9 124.83,79.81 124.84,79.8 124.9,79.74 124.9,79.18 123.86,78.14 123.63,78.14 123.35,78.42 123.35,78.65 123.61,78.9 123.61,79.21 122.79,80.02 122.79,80.3 122.95,80.45 124.39,80.45
GND on TOP (solid shape): 135.22,77.23 135.22,76.62 134.66,76.06 132.27,76.06 131.78,76.55 131.76,76.6 131.73,76.65 131.73,76.7 131.71,76.77 131.64,76.83 131.63,76.86 131.63,77.23 131.83,77.42 132.1,77.42 132.15,77.43 135.01,77.43
GND on TOP (solid shape): 26.94,86.8 26.94,82.64 27.11,82.46 27.11,82.16 26.94,81.98 26.65,81.98 26.63,81.98 26.47,82.11 26.3,82.16 26.21,82.14 26.12,82.11 26.09,82.1 26.06,82.12 25.61,82.56 25.61,87.01 25.69,87.08 26.66,87.08
GND on TOP (solid shape): 33.36,34.43 33.36,32.78 33.95,32.19 33.95,31.61 34.17,31.38 35.57,31.38 35.77,31.58 35.77,32.17 35.88,32.27 36.49,32.27 36.56,32.19 36.56,31.23 35.9,30.57 35.9,29.7 35.8,29.6 33.62,29.6 33.31,29.91 33.31,31.63 32.83,32.12 32.83,32.88 32.54,33.17 32.54,33.73 32.27,34 31.3,34 31.13,34.17 31.13,34.33 31.51,34.71 33.08,34.71
GND on TOP (solid shape): 107.07,27.14 107.07,26.88 106.16,25.97 106.16,25.21 106.08,25.13 104.89,25.13 104.58,24.83 104.56,24.8 104.56,24.27 104.46,24.17 104.13,24.17 104.09,24.18 104.07,24.22 104.07,25.87 104.23,26.02 104.66,26.02 104.74,26.1 104.74,26.86 104.99,27.11 106.31,27.11 106.59,27.39 106.82,27.39
GND on TOP (solid shape): 137.47,43.08 138.53,43.08 139.33,42.28 139.33,41.21 138.57,40.45 138.36,40.45 138.24,40.57 138.24,40.68 138.07,40.85 137.63,40.85 137.39,41.1 137.39,41.11 137.26,41.23 137.26,41.46 137.17,41.56 136.18,41.56 136.04,41.41 136.04,40.79 135.72,40.47 135.04,40.47 134.58,40.94 133.89,40.94 133.79,41.04 133.79,41.67 134.4,42.29 135.7,42.29 136.35,42.94 136.36,42.94 136.51,43.09 137.46,43.09
GND on TOP (solid shape): 99.27,28.73 99.27,28.71 99.32,28.57 99.43,28.46 99.45,28.44 99.45,28.41 99.45,27.38 98.82,26.75 96.15,26.75 95.9,27 95.9,27.92 95.95,28.1 95.9,28.29 95.9,28.52 95.95,28.61 95.97,28.71 95.97,28.73 96.12,28.88 99.11,28.88
GND on TOP (solid shape): 168.49,19.14 168.49,18.68 168.29,18.48 168.21,18.48 167.96,18.23 167.96,17.37 167.64,17.05 167.27,17.05 166.99,17.33 166.99,18.1 166.71,18.38 166.71,18.63 166.81,18.73 167.88,18.73 167.98,18.83 167.99,18.88 167.99,18.91 167.99,19.05 168.05,19.11 168.08,19.12 168.12,19.11 168.16,19.11 168.26,19.12 168.35,19.16 168.36,19.16 168.46,19.16
GND on TOP (solid shape): 44.92,20.6 44.92,19.12 44.46,18.67 43.25,18.67 43.14,18.78 43.14,19.94 42.94,20.14 40.7,20.14 40.45,19.89 39.94,19.89 39.31,19.26 38.35,19.26 38.05,18.97 38.05,17.75 38.12,17.68 38.12,15.4 38.08,15.35 37.38,15.35 37.25,15.49 37.25,16.24 37.44,16.43 37.44,17.63 37.26,17.81 37.26,18.55 37.34,18.63 37.34,19.21 37.15,19.41 37.15,20.42 37.53,20.8 39.93,20.8 40.35,21.22 44.3,21.22
GND on TOP (solid shape): 50.38,110.58 50.38,109.18 50.61,108.95 51.24,108.95 51.47,108.73 51.48,108.7 51.47,108.67 51.44,108.36 51.64,108.12 51.67,108.1 51.67,108.08 51.67,107.61 51.12,107.05 49.03,107.05 48.91,107.17 48.91,107.66 49.13,107.89 49.72,107.89 49.92,108.09 49.92,110.55 50.02,110.65 50.3,110.65
GND on TOP (solid shape): 91.35,53.86 91.48,53.73 91.48,53.22 91.27,53.01 91.27,52.71 91.27,52.49 91.26,52.48 91.26,52.32 91.12,52.18 90.55,52.18 90.51,52.19 90.21,52.19 90.17,52.18 87.01,52.18 86.88,52.31 84.77,52.31 84.52,52.56 84.01,52.56 83.5,53.07 83.5,53.76 83.6,53.86 88.11,53.86
GND on TOP (solid shape): 65,63.07 65.08,63.04 65.29,62.42 65.82,62.18 65.88,62.18 66.15,61.91 66.15,59.52 66.05,59.42 61.3,59.42 61.15,59.57 61.15,60.03 61.3,60.18 62.01,60.18 62.23,60.4 62.23,61.92 62.29,61.99 62.9,61.99 62.94,62.03 63.13,62.03 64.17,63.07
GND on TOP (solid shape): 93.93,59.89 93.93,59.87 93.95,59.78 93.99,59.69 93.99,59.03 93.98,59.01 93.86,58.89 92.52,58.89 92.42,58.99 92.42,59.35 92.72,59.65 92.75,59.67 92.78,59.66 93.15,59.67 93.34,59.98 93.37,60.05 93.44,60.08 93.74,60.08
GND on TOP (solid shape): 80.47,58.86 80.48,58.84 80.55,58.69 80.68,58.58 80.7,58.56 80.71,58.53 80.71,57.48 80.7,57.46 80.69,57.44 80.4,57.15 80.4,56.85 80.28,56.72 79.94,56.72 79.82,56.85 79.82,56.89 79.83,56.96 79.84,57.01 79.83,57.07 79.82,57.14 79.82,58.68 79.88,58.82 79.88,58.96 79.88,58.98 79.89,59 80.05,59.16 80.17,59.16
GND on TOP (solid shape): 23.89,31.53 23.89,30.8 23.23,30.14 22.62,30.14 22.49,30.01 22.49,29.71 22.46,29.68 22.46,27.95 22.49,27.92 22.49,26.61 22.49,25.97 22.44,25.92 22.26,25.92 22.11,25.77 22.11,25.28 21.93,25.11 21.93,24.67 21.93,24.52 22.26,24.19 22.26,23.53 22.19,23.46 21.35,23.46 21.35,24.62 21.4,24.67 21.4,25.11 21.55,25.26 21.55,26.56 21.55,28.66 21.8,28.91 21.83,28.94 21.83,31.33 21.91,31.41 22.9,31.41 23.1,31.61 23.81,31.61
GND on TOP (solid shape): 44.95,31.51 44.98,31.5 45,31.47 45.09,31.28 45.26,31.17 45.29,31.15 45.3,31.12 45.3,30.39 45.25,30.34 44.82,30.34 44.8,30.33 43.03,30.33 43.01,30.3 41.93,30.3 41.79,30.16 41.79,28.51 41.62,28.33 39.89,28.33 39.82,28.4 39.82,29.1 39.82,29.11 40.71,29.11 40.71,29.12 40.74,29.15 40.77,29.16 40.93,29.32 40.93,30.44 41.13,30.64 41.13,31.33 41.31,31.51
GND on TOP (solid shape): 74.06,20.35 74.06,20.32 74.06,20.3 74.03,20.22 74.01,20.13 74.03,20.04 74.06,19.95 74.06,19.92 74.05,19.9 73.85,19.7 73.85,19.06 73.11,18.32 72.2,18.32 72.15,18.38 72.15,18.81 72.25,18.91 72.68,18.91 72.78,19.01 72.78,19.16 72.8,19.22 72.8,19.26 72.8,19.54 72.8,19.59 72.78,19.64 72.78,19.94 72.83,20.07 72.82,20.21 72.82,20.24 72.84,20.26 73.01,20.43 73.98,20.43
GND on TOP (solid shape): 137.02,32.37 137.02,32.05 136.84,31.87 136.54,31.87 136.33,31.66 136.33,31.05 136.45,30.94 137.09,30.94 137.23,31.08 137.91,31.08 137.97,31.02 137.97,30.69 137.88,30.6 137.48,30.6 136.98,30.1 136.98,29.39 136.64,29.05 136.64,28.59 136.61,28.56 135.9,28.56 135.41,28.08 133.82,28.08 133.18,27.43 132.82,27.43 132.72,27.53 132.72,27.87 132.84,27.98 132.84,28.29 132.56,28.56 132.2,28.56 132.01,28.37 132.01,27.7 131.92,27.62 131.57,27.62 131.45,27.73 131.45,28.49 132.12,29.16 132.43,29.16 132.65,29.38 132.65,32.22 132.81,32.38 135.41,32.38 135.55,32.52 136.87,32.52
GND on TOP (solid shape): 117.05,41.69 117.05,41.69 117.13,41.62 117.13,40.8 117,40.68 114.18,40.68 113.98,40.47 113.98,39.41 114.77,38.62 115.28,38.62 115.45,38.44 115.45,37.96 115.63,37.78 116.27,37.78 116.37,37.68 116.37,36.92 116.65,36.64 117.49,36.64 117.69,36.44 117.69,35.72 117.59,35.62 116.95,35.62 116.93,35.6 116.7,35.37 115.99,35.37 115.1,34.48 114.44,34.48 114.42,34.45 114.41,34.45 113.67,33.72 112.95,33.72 112.62,34.05 112.62,40.44 112.43,40.63 109.84,40.63 109.59,40.88 109.59,41.31 109.74,41.46 110.12,41.46 110.27,41.62 110.65,41.62 110.81,41.46 111.31,41.46 111.62,41.77 111.87,41.77 112.18,41.46 115.39,41.46 115.73,41.81 116.94,41.81
GND on TOP (solid shape): 108.88,50.84 114.49,50.84 114.51,50.83 114.53,50.82 114.94,50.41 114.97,50.41 114.97,50.41 117.38,50.41 117.61,50.18 117.61,49.16 117.94,48.83 118.48,48.83 118.65,49.01 118.65,49.39 118.78,49.52 119.24,49.52 119.44,49.31 119.82,49.31 119.86,49.3 119.87,49.26 119.87,49.04 119.91,48.95 120,48.92 121.36,48.92 122.06,48.21 122.06,46.32 121.8,46.06 120.74,46.06 120.01,46.8 115.28,46.8 114.6,47.48 114.59,47.48 114.2,47.88 113.47,47.88 112.58,48.77 112.58,49.52 112.33,49.77 111.31,49.77 111.2,49.66 110.97,49.66 110.96,49.64 109.18,49.64 108.19,50.63 107.63,50.63 107.63,51.27 107.66,51.29 108.42,51.29
GND on TOP (solid shape): 76.68,125.87 76.71,125.86 77.62,124.42 79.2,123.87 79.21,123.86 80.66,123.86 81.19,123.33 81.19,117.86 80.96,117.63 79.39,117.63 79.03,117.99 79.03,118.38 78.5,118.91 75.4,118.91 74.93,118.44 74.93,117.98 74.81,117.87 74.46,117.87 74.36,117.97 74.36,118.52 74.22,118.65 74.22,120.22 73.21,121.22 73.21,122.19 72.78,122.62 72.78,125.59 73.07,125.87
GND on TOP (solid shape): 62.59,119.39 62.62,119.38 62.62,118.58 62.75,118.45 63.56,118.45 63.57,118.43 63.57,117.47 63.08,116.98 62.11,116.98 62.1,116.97 61.28,116.97 60.81,117.44 59.65,117.44 59.47,117.26 59.47,116.98 59.27,116.78 58.81,116.78 58.58,117 58.58,117.5 62.97,117.5 62.97,117.51 63.37,117.51 63.37,118.29 63.17,118.29 63.17,117.51 62.97,117.51 62.97,118.29 62.77,118.29 62.77,117.5 58.58,117.5 58.58,118.6 62.46,118.6 62.46,118.8 61.67,118.8 61.67,118.6 58.58,118.6 58.58,119 62.46,119 62.46,119.2 61.68,119.2 61.68,119 58.58,119 58.58,119.14 58.84,119.39
GND on TOP (solid shape): 86.64,50.33 86.65,50.33 86.7,50.28 87.48,50.28 87.65,50.1 88.93,50.1 90.13,48.9 90.13,47.62 90.13,47.61 90.12,47.59 90.08,47.55 90.08,46.64 89.95,46.51 89.44,46.51 89.17,46.79 89.17,47.7 88.35,48.52 87.99,48.52 87.6,48.12 87.59,48.11 87.59,47.92 87.44,47.75 87.16,47.75 87.03,47.88 87.03,48.6 86.97,48.66 85.11,48.66 85.02,48.75 84.93,48.82 83.04,48.82 82.95,48.92 82.95,49.29 83.09,49.43 83.34,49.43 83.41,49.5 83.45,49.5 83.45,49.54 83.51,49.59 83.56,49.65 83.63,49.72 83.81,49.72 84.09,49.43 84.52,49.43 84.82,49.74 84.82,50.23 85.02,50.43 86.54,50.43
GND on TOP (solid shape): 17.61,90.89 17.61,89.91 17.6,89.89 16.11,88.4 16.11,87.84 16.06,87.79 15.12,87.79 14.67,88.25 14.11,88.25 13.98,88.38 13.98,88.89 14.06,88.96 15.35,88.96 15.36,88.91 15.37,88.85 15.39,88.8 15.42,88.75 15.45,88.71 15.49,88.67 15.53,88.64 15.58,88.61 15.64,88.59 15.69,88.58 15.75,88.58 15.8,88.59 15.86,88.6 15.91,88.62 15.96,88.65 16,88.69 16.04,88.73 16.07,88.78 16.09,88.83 16.11,88.88 16.11,88.93 16.11,88.99 16.11,89.05 16.09,89.1 16.07,89.15 16.04,89.2 16,89.24 15.96,89.27 15.91,89.3 15.86,89.32 15.8,89.34 15.75,89.34 15.69,89.34 15.64,89.33 15.58,89.31 15.53,89.29 15.49,89.26 15.45,89.22 15.42,89.17 15.39,89.12 15.37,89.07 15.36,89.02 15.35,88.96 14.06,88.96 14.49,89.39 14.74,89.39 16.56,91.21 17.3,91.21
GND on TOP (solid shape): 134.17,69.07 136.99,69.07 137.17,68.9 137.17,68.19 137.02,68.03 136.33,68.03 135.9,67.6 135.9,63.71 136.38,63.23 136.74,63.23 136.89,63.08 136.89,62.6 135.42,61.12 133.64,61.12 133.48,60.97 133.31,60.97 133.19,60.84 133.03,60.84 132.88,60.69 132.24,60.69 132.19,60.64 131.08,60.64 130.81,60.91 130.7,60.94 129.05,61.92 128.07,63.57 128.05,63.66 128.03,63.74 128.03,69.18 128.15,69.3 130.14,69.3 130.87,70.04 133.21,70.04
GND on TOP (solid shape): 81.11,61.04 81.11,60.68 81.11,60.66 81.1,60.64 80.79,60.33 80.69,60.33 80.53,60.17 80.45,60.17 80.43,60.18 80.4,60.2 79.99,60.2 79.97,60.18 79.95,60.17 79.61,60.17 79.21,60.58 79.21,60.84 79.34,60.96 79.8,60.96 79.84,60.95 79.87,60.93 79.89,60.91 79.89,60.88 79.87,60.83 79.87,60.77 80.23,60.42 80.58,60.77 80.57,60.84 80.55,60.91 80.55,60.93 80.55,60.96 80.71,61.11 81.04,61.11
GND on TOP (solid shape): 21.98,69.66 21.98,66.97 17.92,62.9 17.92,61.81 16.29,60.18 12.99,60.18 12.76,60.41 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.44,62.19 8.17,61.79 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99 6.72,67.99 7.64,67.07 8.75,67.07 9.61,67.93 9.61,70.65 9.77,70.8 11.7,70.8 13.04,72.15 14.57,72.15 15.3,72.88 18.76,72.88
GND on TOP (solid shape): 22.13,73.32 22.49,73.32 22.82,72.99 22.82,72.71 23.13,72.4 23.51,72.4 24.04,71.87 25.13,71.87 25.28,71.72 25.28,70.75 25.11,70.57 23.87,70.57 23.85,70.58 23.76,70.63 23.68,70.64 23.38,70.64 23.3,70.63 23.23,70.59 23.21,70.57 23.15,70.57 23.12,70.59 22.83,70.72 22.54,70.59 22.52,70.57 22.46,70.57 22.4,70.64 22.39,70.65 21.71,71.69 20.81,72.54 20.8,72.55 20.79,72.57 20.79,73.09 20.8,73.14 20.8,73.19 20.8,73.23 20.79,73.29 20.79,73.6 20.99,73.8 21.65,73.8
GND on TOP (solid shape): 13.6,88.53 12.38,87.31 11.64,87.31 10.48,86.14 10.48,85.1 11.19,84.39 12,84.39 12.74,83.65 12.74,83.09 12.2,82.56 11.24,82.56 11.06,82.38 10.15,82.38 10.02,82.51 9.61,82.51 9.61,84.49 8.77,85.33 7.61,85.33 6.69,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.7,88.7 11.91,89.2 11.91,89.63 13.6,89.63
GND on TOP (solid shape): 58.56,19.8 58.56,19.56 58.55,19.53 58.54,19.52 58.51,19.51 57.63,19.51 57.63,19.31 58.51,19.31 58.54,19.31 58.55,19.29 58.55,19.03 58.54,19.02 58.51,19.01 57.63,19.01 57.49,19.01 57.36,18.88 57.36,18.43 58.38,17.41 61.23,17.41 61.35,17.28 61.35,15.07 60.77,14.49 57.29,14.49 57.19,14.59 57.19,16.22 56.93,16.47 56.93,17.16 56.93,17.17 57.43,17.17 57.43,18.11 57.23,18.11 57.23,17.17 56.93,17.17 56.93,18.11 56.88,18.11 56.86,18.13 56.85,18.16 56.83,18.19 56.81,18.21 56.78,18.23 56.75,18.23 56.73,18.24 56.42,18.24 56.41,18.23 56.38,18.23 56.35,18.21 56.32,18.19 56.31,18.16 56.28,18.12 56.23,18.11 56.23,17.21 56.22,17.18 56.21,17.16 56.18,17.16 55.94,17.16 55.93,17.17 55.93,18.11 55.92,18.11 55.89,18.14 55.89,19.75 55.99,19.85 58.51,19.85
GND on TOP (solid shape): 52.54,71.13 52.54,70.73 52.67,70.6 52.87,70.6 53.07,70.39 53.07,69.84 53.35,69.56 53.35,69.02 53.63,68.74 53.64,68.73 53.71,68.57 53.82,68.43 54.09,68.16 54.09,66.61 54.54,66.15 54.54,64.27 54.43,64.16 54.36,64.15 54.29,64.12 53.66,64.12 52.99,64.79 52.99,65.32 53,65.8 52.52,65.86 52.46,65.84 52.4,65.87 52.37,65.9 52.33,65.92 52.32,65.94 52.31,65.96 52.31,66.31 52.74,66.74 52.74,66.85 52.75,66.87 52.75,67.45 52.74,67.47 52.74,68.67 52.75,68.68 52.75,69.14 52.21,69.68 52.21,70.65 52.06,70.8 52.06,71.08 52.21,71.23 52.44,71.23
GND on TOP (solid shape): outline of 82 points within 202.5,28.76 209.69,39.84
GND on TOP (solid shape): 15.35,111.19 15.35,104.58 13.98,103.21 12.01,103.21 11.9,103.33 11.65,103.74 11.2,103.91 7.31,103.91 7.31,104.4 7.1,104.9 6.6,105.11 5.2,105.11 4.7,104.9 4.49,104.4 4.49,103.91 0.71,103.91 0.51,104.11 0.51,105.19 0.51,105.19 2.11,105.19 2.11,111.21 0.51,111.21 0.51,111.21 0.51,112.59 0.71,112.79 3.3,112.79 3.6,112.57 3.97,112.49 5.93,112.49 6.31,112.58 6.62,112.81 7.28,112.82 8,112.4 8.76,112.74 10.05,112.74 10.81,113.5 13.04,113.5
GND on TOP (solid shape): outline of 113 points within 35.98,62.7 48.56,68.19
GND on TOP (solid shape): 15.38,48.3 15.38,47.94 13.55,46.11 13.4,45.87 13.22,45.65 13.22,44.03 13.23,44.02 13.23,43.51 15.48,41.26 15.48,40.22 15.15,39.89 13.65,39.89 13.47,40.07 12.99,40.07 12.76,40.3 12.76,41.84 12.01,42.81 10.88,42.35 8.9,42.35 8.44,42.19 8.17,41.79 8.16,41.75 3.45,41.75 3.25,41.95 3.25,46.93 3.45,47.13 8.16,47.13 8.17,47.09 8.44,46.69 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,48.55 12.94,48.73 14.95,48.73
GND on TOP (solid shape): 6.46,13.02 6.46,11.82 6.62,11.67 8.39,11.67 8.67,11.39 8.67,10.02 10.63,8.06 10.63,2.01 11.11,1.52 40.48,1.52 40.48,3.19 40.47,3.19 40.47,3.28 40.5,3.35 40.58,3.38 40.98,3.46 41.32,3.69 41.43,3.72 41.49,3.62 41.49,1 41.35,0.65 41,0.51 1,0.51 0.65,0.65 0.51,1 0.51,10.64 3.23,10.64 4.36,10.18 5.11,11.15 5.11,12.74 5.14,12.81 5.21,12.84 5.53,12.93 5.74,13.17 5.74,13.18 5.78,13.22 6.26,13.22
GND on TOP (solid shape): 9.46,120.89 14.49,120.89 14.49,119.4 14.79,118.69 15.5,118.39 32.7,118.39 32.97,118.43 33.23,118.54 33.45,118.54 33.87,118.12 33.87,117.75 33.31,117.47 32.7,117.38 15.5,117.38 14.62,117.58 13.91,118.14 13.4,118.65 10.91,118.65 10.5,118.25 8.76,118.25 8.56,118.45 8.56,119.14 8.69,120.54 7.29,120.39 6.62,120.39 6.31,120.62 5.93,120.71 3.97,120.71 3.6,120.63 3.3,120.41 0.71,120.41 0.51,120.61 0.51,122.39 7.96,122.39
GND on TOP (solid shape): 140.5,26.71 140.6,26.66 140.72,26.64 140.76,26.64 140.8,26.65 140.83,26.65 140.85,26.64 140.89,26.6 141.37,26.6 141.49,26.48 142.01,26.48 142.24,26.25 142.7,26.25 145.04,23.91 145.04,20.29 142.72,17.97 142.29,17.97 142.01,17.69 141.69,17.69 140.96,16.96 140.94,16.94 140.91,16.94 140.87,16.95 140.83,16.95 140.56,16.84 140.45,16.57 140.45,16.53 140.42,16.45 140.35,16.42 139.58,16.42 139.51,16.49 139.49,16.59 139.56,16.66 139.76,16.8 139.84,17.03 139.73,17.3 139.46,17.41 139.35,17.39 139.25,17.35 138.87,17.35 136.17,20.05 136.17,20.15 136.18,20.16 136.22,20.25 136.23,20.36 136.13,20.62 135.84,20.75 135.82,20.79 135.82,21.2 135.95,21.32 135.95,24.02 138.53,26.59 138.95,26.59 139.12,26.69 139.13,26.7 139.15,26.71
GND on TOP (solid shape): outline of 104 points within 97.53,72.68 107.5,77.06
GND on TOP (solid shape): 158.23,23.51 158.61,23.12 158.61,21.83 158.41,21.63 157.06,21.63 156.93,21.5 156.93,21.48 156.92,21.45 156.83,21.38 156.81,21.31 156.81,21.17 156.73,21.09 156.73,20.59 156.81,20.51 156.81,20.38 156.85,20.29 156.94,20.25 157.09,20.25 157.16,20.18 158.33,20.18 158.79,20.64 159.52,20.64 159.75,20.41 159.75,19.66 159.75,19.65 159.73,19.54 159.75,19.44 159.75,19.43 159.75,19.37 159.66,19.28 159.31,19.28 159.22,19.37 159.23,19.5 159.23,19.54 159.23,19.58 159.22,19.7 159.12,19.81 158.99,19.93 158.83,19.93 158.23,19.93 158.05,19.93 157.85,19.72 157.85,19.66 157.83,19.6 157.83,19.54 157.83,19.5 157.85,19.43 157.84,19.41 157.72,19.29 157.39,19.29 157.31,19.37 157.32,19.5 157.32,19.54 157.21,19.81 156.94,19.93 156.88,19.92 156.8,19.9 156.44,19.9 156.4,19.91 156.35,19.92 156.25,20.03 156.25,21.98 156.12,22.11 154.67,22.11 154.3,21.74 154,21.73 153.96,21.77 153.96,21.83 153.63,22.16 153.4,22.16 153.02,22.54 152.26,22.54 152.18,22.62 152.18,23.38 152.31,23.51 156.42,23.51
GND on TOP (solid shape): 157.43,38.53 157.46,38.54 157.49,38.53 157.57,38.44 159.96,36.89 162.47,35.52 162.48,35.51 163.56,34.43 163.58,34.35 163.61,34.29 163.61,33.31 163.49,33.18 162.93,33.18 162.85,33.26 162.85,34.3 162.12,35.03 161.98,35.23 161.75,35.31 161.71,35.3 161.65,35.29 161.2,35.29 161.14,35.3 161.09,35.31 161.04,35.3 160.95,35.29 160.91,35.26 160.77,35.12 160.71,34.93 160.72,34.85 160.71,34.83 159.75,33.87 159.75,33.52 159.75,33.5 159.74,33.48 159.54,33.29 159.54,32.45 159.57,32.42 159.57,32.4 159.57,31.79 159.35,31.56 158.79,31.56 158.68,31.66 158.68,32.17 158.99,32.47 158.99,33.35 158.99,33.37 159.12,33.52 159.16,33.69 159.13,33.84 159.04,33.97 159.01,34.03 159.03,34.1 159.09,34.21 159.1,34.33 159.08,34.47 159,34.59 158.99,34.6 158.99,34.68 159.12,34.81 159.12,35.98 158.71,36.38 158.13,36.38 157.36,35.62 155,35.62 154.93,35.7 154.93,36.74 154.93,36.77 154.95,36.79 155.41,37.05 155.84,37.35
GND on TOP (solid shape): outline of 93 points within 134.94,50.15 141.79,58.03
GND on TOP (solid shape): outline of 178 points within 48.27,30.72 54.11,34.48
GND on TOP (solid shape): 35.37,14.72 35.37,13.7 34.1,12.43 33.28,12.43 33.15,12.54 32.99,12.58 32.82,12.54 32.69,12.44 32.67,12.43 32.6,12.39 32.51,12.44 32.38,12.54 32.21,12.58 31.94,12.46 31.84,12.2 31.87,12.05 31.95,11.92 31.98,11.81 31.88,11.75 31.05,11.75 30.47,12.33 30.39,12.33 30.36,12.35 30.36,12.37 30.22,12.58 29.98,12.67 29.82,12.63 29.68,12.52 29.6,12.48 29.52,12.52 29.39,12.63 29.22,12.67 28.95,12.56 28.84,12.29 28.84,12.24 28.84,12.14 28.87,12.01 28.85,11.99 28.56,11.7 26.22,11.7 26.19,11.71 26.17,11.75 26.17,12.05 26.44,12.31 26.52,12.34 26.6,12.29 26.74,12.13 26.94,12.07 26.95,12.07 27.11,12.11 27.24,12.21 27.25,12.22 27.32,12.26 27.4,12.22 27.41,12.21 27.54,12.11 27.71,12.07 27.95,12.16 28.08,12.38 28.95,13.24 30.69,13.24 31.41,13.96 31.41,14.74 31.61,14.95 35.14,14.95
GND on TOP (solid shape): outline of 169 points within 93.07,35.01 101.74,38.75
GND on TOP (solid shape): outline of 111 points within 107.65,61.76 122.64,73.53
GND on TOP (solid shape): 105.84,46.8 105.91,46.77 105.94,46.69 105.94,46.69 106.05,46.42 106.32,46.3 106.46,46.33 106.6,46.41 106.62,46.42 106.8,46.42 106.81,46.41 106.83,46.4 107.09,46.3 107.34,46.4 107.36,46.41 107.38,46.42 109.23,46.42 109.91,45.73 112.12,45.73 113.35,44.51 113.35,43.65 113.27,43.57 112.51,43.57 112.36,43.42 111.52,43.42 111.26,43.67 110.4,43.67 110.09,43.37 109.59,43.37 109.36,43.14 108.19,43.14 108.09,43.24 108.09,44.08 108.1,44.11 108.14,44.13 108.38,44.13 108.4,44.13 108.53,44.04 108.67,44.02 109.05,44.4 108.67,44.78 108.53,44.75 108.4,44.67 108.38,44.66 108.02,44.66 107.51,45.17 107.49,45.17 107.4,45.22 107.39,45.31 107.4,45.37 107.41,45.43 107.3,45.7 107.03,45.81 106.86,45.77 106.73,45.66 106.65,45.62 106.57,45.66 106.43,45.77 106.27,45.81 106,45.7 105.88,45.43 105.95,45.22 106.12,45.08 106.13,45.07 106.15,45.03 106.13,44.99 106.09,44.96 105.48,44.96 105.24,45.19 105.24,45.89 105.25,45.91 105.38,46.07 105.42,46.24 105.39,46.39 105.31,46.51 105.29,46.55 105.31,46.58 105.52,46.8
GND on TOP (solid shape): outline of 278 points within 51.83,48.07 66.43,54.37
GND on TOP (solid shape): outline of 251 points within 94.58,58.84 100.29,60.92
GND on TOP (solid shape): outline of 270 points within 92.15,39 101.18,43
GND on TOP (solid shape): outline of 289 points within 91.96,50.33 97.67,54.62
GND on TOP (solid shape): outline of 342 points within 0.51,18.58 15.3,28.97
GND on TOP (solid shape): outline of 1442 points within 36.54,5.62 219.29,127.49
GND on BOTTOM (solid shape): 25.56,16.88 25.56,14.36 25.46,14.26 24.01,14.26 23.94,14.34 23.94,16.88 23.99,16.93 25.51,16.93
GND on BOTTOM (solid shape): 30.67,21.12 30.67,19.82 30.54,19.7 28.87,19.7 28.66,19.9 28.66,20.85 29.12,21.31 30.48,21.31
GND on BOTTOM (solid shape): 68.79,125.77 68.79,123.79 68.67,123.66 68.16,123.66 68.08,123.73 68.08,125.74 68.26,125.92 68.64,125.92
GND on BOTTOM (solid shape): 112.79,86.75 112.79,84.11 112.38,83.7 109.79,83.7 109.69,83.81 109.69,86.85 109.99,87.16 112.38,87.16
GND on BOTTOM (solid shape): 131.6,43.92 131.6,42.41 131.35,42.15 130.3,42.15 130.1,42.35 130.1,43.86 130.22,43.98 131.55,43.98
GND on BOTTOM (solid shape): 133.82,80.83 133.82,79.39 133.72,79.28 132.19,79.28 131.96,79.51 131.96,80.4 132.62,81.06 133.59,81.06
GND on BOTTOM (solid shape): 135.82,31.18 135.82,28.66 135.72,28.56 133.26,28.56 133.11,28.71 133.11,31.2 133.16,31.25 135.75,31.25
GND on BOTTOM (solid shape): 136.64,80.91 136.64,79.51 136.46,79.34 135.7,79.34 135.47,79.56 135.47,80.96 135.57,81.06 136.49,81.06
GND on BOTTOM (solid shape): 141.01,56.58 141.01,52.39 140.85,52.23 136.61,52.23 136.46,52.39 136.46,56.53 136.61,56.68 140.9,56.68
GND on BOTTOM (solid shape): 206.89,34.81 206.89,30.49 206.77,30.36 202.53,30.36 202.4,30.49 202.4,34.78 202.5,34.89 206.82,34.89
GND on BOTTOM (solid shape): 65.49,111.26 65.49,109.41 65.37,109.28 64.53,109.28 64.45,109.36 62.95,109.36 62.62,109.69 62.62,111.29 62.85,111.52 65.24,111.52
GND on BOTTOM (solid shape): 92.39,82 92.39,79.72 92.29,79.62 91.4,79.62 90.89,79.11 89.95,79.11 89.55,79.51 89.55,81.95 89.8,82.21 92.19,82.21
GND on BOTTOM (solid shape): 109.8,22.03 109.8,16.78 109.16,16.14 106.14,16.14 106.02,16.26 106.02,17.26 106.42,17.66 106.42,21.91 106.61,22.1 109.73,22.1
GND on BOTTOM (solid shape): 48.73,122.59 48.73,118.93 48.73,118.93 48.73,118.64 48.57,118.49 47.39,118.49 47.05,118.82 47.05,122.67 47.23,122.85 48.47,122.85
GND on BOTTOM (solid shape): 73.34,96.63 73.34,95.82 73.19,95.66 73.19,94.8 72.45,94.07 70.52,94.07 70.32,94.27 70.32,97.62 70.42,97.73 72.25,97.73
GND on BOTTOM (solid shape): 107.22,121.01 107.22,118.76 107,118.53 107,117.66 106.92,117.59 105.34,117.59 105.22,117.72 105.22,120.13 106.14,121.06 107.18,121.06
GND on BOTTOM (solid shape): 124.27,95.49 124.27,94.22 123.76,93.71 120.46,93.71 120.33,93.84 120.33,94.55 120.03,94.85 120.03,95.71 120.19,95.87 123.89,95.87
GND on BOTTOM (solid shape): 126.83,121.73 126.83,119.67 126.73,119.57 125.94,119.57 125.84,119.67 125.84,120.31 125.33,120.81 125.33,121.78 125.49,121.93 126.63,121.93
GND on BOTTOM (solid shape): 130.34,78.01 130.34,77.46 130.11,77.23 126.78,77.23 126.65,77.36 126.65,77.64 126.82,77.81 128.81,77.81 129.42,78.42 129.93,78.42
GND on BOTTOM (solid shape): 112.16,55.55 112.16,53.46 111.86,53.16 108.33,53.16 108.24,53.25 108.24,53.95 108.32,54.02 108.84,54.02 110.55,55.74 111.97,55.74
GND on BOTTOM (solid shape): 126.17,36.69 126.17,35.67 126.05,35.55 125.79,35.55 125.78,35.55 125.48,35.55 125.47,35.55 123.63,35.55 123.38,35.8 123.38,36.56 123.63,36.82 126.05,36.82
GND on BOTTOM (solid shape): 101.91,78.73 102.24,78.73 102.36,78.61 102.36,78.27 102.32,78.23 102.32,77.51 101.61,76.8 101.31,76.8 101.15,76.95 101.15,78.78 101.26,78.88 101.75,78.88
GND on BOTTOM (solid shape): 106.95,27.27 106.98,27.27 107.07,27.27 107.48,26.86 107.48,25.94 107.2,25.67 104.72,25.67 104.61,25.77 104.61,26.59 105.3,27.28 106.92,27.28
GND on BOTTOM (solid shape): 120.33,69.46 120.33,69 120.04,68.7 117.64,68.7 117.16,68.23 116.73,68.23 116.69,68.27 116.69,68.67 117.66,69.64 120.14,69.64
GND on BOTTOM (solid shape): 42.51,111.29 42.51,109.41 42.43,109.33 41.03,109.33 40.64,109.73 40.64,111.02 40.74,111.12 41.38,111.12 41.62,111.37 42.43,111.37
GND on BOTTOM (solid shape): 146.59,20 146.63,19.99 146.64,19.95 146.64,18.98 146.72,18.91 146.72,17.05 145.99,16.32 145.17,16.32 144.21,17.28 144.21,19.87 144.34,20
GND on BOTTOM (solid shape): 209.51,17.3 211.5,17.3 212.02,16.78 212.02,15.06 211.73,14.77 207.25,14.77 207.17,14.85 207.17,18.02 207.25,18.1 207.26,18.1 207.67,18.5 208.3,18.5
GND on BOTTOM (solid shape): 75.11,112.32 75.11,108.89 74.94,108.72 72.91,108.72 72.63,109 72.63,111.92 72.83,112.13 73.52,112.13 73.8,112.41 73.8,112.71 73.87,112.79 74.64,112.79
GND on BOTTOM (solid shape): 77.85,100.66 77.85,98.02 77.79,97.95 77.38,97.95 77.25,98.08 77.25,99.53 77.07,99.71 77.07,100.21 76.57,100.72 76.57,101.15 76.73,101.32 76.86,101.32 76.88,101.34 77.17,101.34
GND on BOTTOM (solid shape): 111.71,121.14 112.44,121.14 112.48,121.14 112.84,121.14 112.96,121.02 112.96,117.72 112.71,117.46 110.68,117.46 110.42,117.72 110.42,121.02 110.55,121.14 111.68,121.14
GND on BOTTOM (solid shape): 82.35,25.63 83.54,25.63 83.63,25.54 83.63,25.06 83.32,24.75 80.78,24.75 79.84,23.81 78.69,23.81 78.55,23.96 78.55,24.4 78.27,24.67 77.79,24.67 77.53,24.93 77.53,25.56 77.61,25.64 82.33,25.64
GND on BOTTOM (solid shape): 115.68,18.45 115.68,18.32 116.24,17.77 118.93,17.77 119.7,18.53 121.22,18.53 121.88,17.87 121.88,17.13 121.04,16.29 118.38,16.29 117.79,15.71 115.38,15.71 114.5,16.59 114.34,16.75 114.34,18.5 114.39,18.55 115.58,18.55
GND on BOTTOM (solid shape): 142.84,73.98 142.84,71.94 142.53,71.64 141.81,71.64 141.74,71.67 141.54,71.87 141.54,72.5 141.36,72.68 137.55,72.68 137.32,72.91 137.3,72.91 137.12,73.09 137.12,73.98 137.37,74.23 142.58,74.23
GND on BOTTOM (solid shape): 53.91,15.1 53.91,14.59 53.35,14.03 51.4,14.03 50.96,14 50.54,13.91 50.53,13.91 50.1,13.91 49.92,14.08 49.92,15.02 50.07,15.18 52.44,15.18 52.54,15.28 53.73,15.28
GND on BOTTOM (solid shape): 104.85,32.21 104.85,32.1 104.85,32.1 104.85,30.8 104.83,30.77 104.79,30.75 103.8,30.75 103.48,31.08 103.47,31.09 103.47,31.11 103.47,31.69 103.48,31.7 103.48,31.84 103.99,32.36 104.7,32.36
GND on BOTTOM (solid shape): 156.96,24.67 156.96,21.76 156.95,21.74 156.94,21.73 156.91,21.69 154.7,21.69 153.99,22.4 153.99,23.48 154.75,24.24 154.75,24.27 154.8,24.32 154.8,24.65 154.82,24.69 154.85,24.7 156.93,24.7
GND on BOTTOM (solid shape): 116.66,60.98 116.66,59.31 116.29,58.94 116.29,58.13 116.09,57.92 112.91,57.92 112.76,58.08 112.76,59.45 112.89,59.57 114.9,59.57 115.25,59.93 115.25,60.95 115.43,61.12 116.52,61.12
GND on BOTTOM (solid shape): 44.84,15.04 44.84,14.45 44.27,13.88 44.27,13.88 44.21,13.82 44.17,13.79 44.14,13.75 43.5,13.11 42.03,13.11 41.97,13.17 41.97,13.85 42.07,13.94 42.76,13.94 43.29,14.47 43.29,15.02 43.42,15.15 44.72,15.15
GND on BOTTOM (solid shape): 104.58,76.39 105.93,76.39 107.55,74.76 107.55,74.05 107.32,73.81 107.28,73.82 107.22,73.84 107.15,73.85 107.01,73.82 106.89,73.75 103.21,73.75 103.08,73.87 103.08,75.96 102.83,76.21 103.8,77.18
GND on BOTTOM (solid shape): 154.01,27.97 154.05,27.96 154.06,27.92 154.06,27.62 153.83,27.39 153.45,27.39 153.35,27.29 153.35,26.81 153.22,26.68 152.39,26.68 152.28,26.78 152.28,27.21 152.49,27.42 152.49,27.92 152.5,27.96 152.54,27.97
GND on BOTTOM (solid shape): 129.02,18.01 129,17.94 129,17.11 129.01,17.11 129.04,17.08 129.04,16.55 128.76,16.27 128.2,16.27 128.08,16.39 128.08,17.11 128.7,17.11 128.7,17.94 128.5,17.94 128.5,17.11 128.08,17.11 128.08,17.97 128.18,18.07 128.97,18.07
GND on BOTTOM (solid shape): 127.2,43.66 128.09,43.66 128.23,43.52 128.23,43.19 127.89,42.85 127.89,42.39 127.84,42.29 127.82,42.18 127.84,42.07 127.89,41.96 127.89,41.45 127.57,41.13 125.01,41.13 124.92,41.22 124.92,42.83 124.52,43.23 124.52,43.6 124.59,43.67 127.19,43.67
GND on BOTTOM (solid shape): 72.83,77.35 72.83,77.1 73.14,76.8 74.87,76.8 74.93,76.78 74.99,76.78 75.02,76.78 75.41,76.38 75.41,76.08 75.25,75.92 75.2,75.89 75.16,75.84 74.93,75.61 74.21,75.61 73.48,76.34 73.01,76.34 72.15,77.2 72.15,77.41 72.32,77.58 72.6,77.58
GND on BOTTOM (solid shape): 108.67,125.57 108.67,124.53 108.9,124.3 108.9,122.8 108.49,122.39 108.49,121.89 108.34,121.74 107.74,121.74 107.32,122.17 105.23,122.17 105.12,122.28 105.12,123.26 105.12,123.3 105.12,123.86 105.27,124.01 105.65,124.01 106.01,124.37 106.01,124.75 106.13,124.88 106.77,124.88 107,125.11 107,125.54 107.17,125.72 108.52,125.72
GND on BOTTOM (solid shape): 128,75.04 131.28,75.04 131.3,75.02 131.61,74.86 131.91,75.02 133.74,75.02 134.02,74.74 134.02,73.85 133.93,73.76 127.71,73.76 127.6,73.87 127.6,74.74 127.9,75.04
GND on BOTTOM (solid shape): 157.53,38.46 157.55,38.46 157.57,38.44 158.07,38.09 158.58,37.75 159.34,37.27 160.11,36.8 160.29,36.62 160.29,35.32 160.19,35.23 160.15,35.18 160.13,35.17 159.73,35.17 159.57,35.32 159.57,35.83 159.42,35.98 156.11,35.98 155.92,36.17 155.92,37.37 156.05,37.51 157.33,38.46
GND on BOTTOM (solid shape): 24.45,114.67 24.45,113.91 23.35,112.81 22.36,112.81 20.99,114.18 18.5,114.18 16.62,112.3 15.53,112.3 14.64,113.19 14.64,113.96 15.56,114.87 21.3,114.87 22.01,115.58 22.03,115.59 22.23,115.69 22.33,115.89 22.33,115.91 22.46,116.04 23.07,116.04
GND on BOTTOM (solid shape): 36.92,122.47 36.92,122.31 37.3,121.93 38.87,121.93 39.03,121.78 39.03,121.12 39.28,120.86 41.84,120.86 42.12,121.14 42.12,122.35 42.25,122.48 42.92,122.48 43.11,122.29 43.11,120.48 42.59,119.96 39.27,119.96 38.37,120.86 37.57,120.86 36.81,121.62 36.7,121.7 36.58,121.74 36.57,121.75 36.33,121.98 36.33,122.44 36.49,122.59 36.79,122.59
GND on BOTTOM (solid shape): 81.65,94.52 84.12,94.52 84.15,94.51 84.17,94.48 84.92,94.48 84.94,94.51 84.97,94.52 85.49,94.52 85.76,94.26 86.56,94.26 86.68,94.14 86.68,93.81 86.57,93.71 85.53,93.71 85.45,93.79 82.91,93.79 82.46,93.34 81.46,93.34 80.73,94.07 80.73,94.42 80.17,94.98 80.17,95.39 80.22,95.44 80.73,95.44
GND on BOTTOM (solid shape): 21.47,57 22.68,57 23.68,55.99 23.68,52.1 23.12,51.53 22.78,51.53 22.41,51.91 21.88,51.91 21.8,51.83 21.42,51.83 21.27,51.98 21.27,54.01 21.27,54.03 21.29,54.05 21.29,54.3 21.16,54.43 21.16,54.63 21.27,54.75 21.27,55.08 21.45,55.25 21.45,55.26 21.52,55.33 21.52,56.09 21.02,56.6 20.41,56.6 20.25,56.76 20.25,57.14 20.41,57.29 21.18,57.29
GND on BOTTOM (solid shape): 193.91,31.1 193.91,30.82 194.12,30.62 194.58,30.62 195.11,30.09 196.1,30.09 196.18,30.01 196.18,29.63 196.65,29.16 196.65,28.32 196.57,28.24 195.88,28.24 195.85,28.28 195.85,28.69 195.51,29.02 195.01,29.53 195.01,29.7 194.86,29.86 194.86,29.86 194.68,30.03 192.62,30.03 192.56,30.1 192.56,30.63 192.67,30.75 192.85,30.75 192.97,30.86 193.01,30.91 193.31,31.2 193.81,31.2
GND on BOTTOM (solid shape): 66.08,125.87 66.08,125.85 65.97,125.59 66.08,125.33 66.08,124.12 65.97,124.01 65.24,124.01 65.14,124.12 65.14,125.2 65.15,125.23 65.17,125.23 65.35,125.37 65.42,125.59 65.41,125.68 65.37,125.77 65.37,125.87 65.46,125.92 66.03,125.92
GND on BOTTOM (solid shape): 60.74,125.13 60.77,125.13 62.03,123.87 62.02,123.87 62.02,123.66 62.03,123.64 62.04,123.61 62.04,118.45 62.39,118.1 62.39,117.75 62.04,117.4 58.32,117.4 57.14,118.58 57.14,122.41 57.21,122.49 57.21,123.36 57.19,123.38 57.19,123.41 57.15,123.5 57.06,123.54 56.75,123.54 56.72,123.57 51.36,123.57 51.27,123.66 51.27,124.26 51.27,125.03 51.46,125.22 51.46,125.22 51.56,125.29 51.64,125.39 51.64,125.4 51.98,125.74 60.13,125.74
GND on BOTTOM (solid shape): 68.16,114.31 68.16,114.15 68.15,114.14 68.12,114.05 68.11,113.96 68.12,113.88 68.14,113.81 68.14,113.79 68.14,113.77 68.12,113.7 68.11,113.63 68.12,113.53 68.15,113.45 68.16,113.43 68.16,113.4 68.01,113.24 67.55,113.24 67.32,113.47 67.02,113.47 67,113.45 66.92,113.42 66.86,113.37 66.08,113.37 66.05,113.4 66.05,114.16 66.18,114.29 67.42,114.29 67.59,114.45 68.02,114.45
GND on BOTTOM (solid shape): 117.16,41.97 117.16,40.91 117.16,40.88 117.2,40.74 117.28,40.63 117.35,40.56 117.35,39.71 117.33,39.68 117.29,39.66 117.14,39.66 117.11,39.68 117.09,39.71 117.09,40.48 117.05,40.52 116.98,40.52 116.92,40.58 116.83,40.68 115.72,40.68 115.62,40.78 115.62,41.73 115.73,41.84 115.93,41.84 116.27,42.18 116.95,42.18
GND on BOTTOM (solid shape): 14.44,25.08 14.47,25.07 14.49,25.03 14.49,24.88 14.6,24.61 14.87,24.5 15.07,24.55 15.21,24.7 15.21,24.71 15.24,24.73 15.43,24.73 15.63,24.52 15.63,24.01 15.53,23.91 12.48,23.91 12.23,24.17 12.23,24.51 12.27,24.56 12.29,24.56 12.85,24.76 13.36,25.08
GND on BOTTOM (solid shape): 80,59.57 80.19,59.49 80.4,59.54 80.55,59.54 80.62,59.47 80.62,59.19 80.46,58.86 80.67,58.56 80.66,58.53 80.63,58.48 80.63,58.46 80.6,58.38 80.55,58.32 80.22,58.32 80.09,58.45 80.09,58.66 79.92,58.83 79.92,59.03 79.63,59.31 79.63,59.47 79.74,59.57
GND on BOTTOM (solid shape): 78.14,93.59 78.14,93.18 78.34,92.98 79.06,92.98 79.36,93.28 80.05,93.28 81.34,91.98 81.88,91.98 81.95,91.91 81.95,90.92 81.77,90.74 76.21,90.74 74.94,89.47 74.94,88.53 73.19,86.78 73.19,85.23 72.99,85.03 70.98,85.03 70.47,84.52 69.4,84.52 69.15,84.26 69.15,83.91 69.07,83.83 67.91,83.83 67.67,84.06 67.67,87.16 68.88,88.37 68.88,88.85 68.75,89.75 68.88,90.65 68.88,91.64 70.32,93.08 74.23,93.08 74.71,92.59 76.03,92.59 76.39,92.95 77.13,92.95 77.4,93.23 77.4,93.61 77.51,93.71 78.01,93.71
GND on BOTTOM (solid shape): 140.65,35.26 140.67,35.26 140.68,35.24 140.73,35.2 140.73,35.19 140.83,35.09 140.83,31.87 141.11,31.59 141.11,30.89 141.29,30.71 143.03,30.71 143.37,31.05 145.63,31.05 145.71,30.97 145.71,30.67 144.66,29.63 143.32,29.63 142.94,29.25 142.63,29.25 142.55,29.22 142.5,29.15 142.5,29.14 142.35,28.99 142.35,28.38 142.28,28.31 141.26,28.31 141.12,28.45 141.08,28.49 140.83,28.74 140.83,29.42 140.78,29.48 140.78,29.66 140.55,29.88 140.14,29.88 140.02,30.01 140.02,30.34 139.81,30.55 139.62,30.55 139.33,30.84 139.32,30.85 139.31,30.87 139.31,32.88 138.96,33.23 138.31,33.23 138.23,33.32 138.23,34.8 138.69,35.26
GND on BOTTOM (solid shape): 138.32,42.85 138.4,42.85 138.44,42.81 139.24,42.81 139.39,42.66 139.39,41.78 139.36,41.7 139.35,41.61 139.36,41.52 139.39,41.44 139.39,41.32 139.66,41.05 139.66,39.65 139.58,39.57 139.58,39.5 139.56,39.42 139.55,39.34 139.56,39.26 139.58,39.19 139.58,39.05 139.74,38.89 141.38,38.89 141.81,39.31 141.81,39.67 141.96,39.83 142.22,39.83 142.35,39.7 142.35,39.5 142.47,39.38 142.47,39 142.69,38.78 142.9,38.78 143.14,38.54 143.14,37.61 143,37.48 138.73,37.48 138.37,37.84 138.37,39.24 138.75,39.62 138.82,39.67 138.87,39.74 138.9,39.77 138.9,40.29 138.89,40.3 138.83,40.37 138.77,40.43 137.42,40.43 137.35,40.5 137.35,43.01 137.45,43.12 138.05,43.12
GND on BOTTOM (solid shape): 27.71,27.02 27.72,27 27.71,26.95 27.71,26.91 27.82,26.64 28.09,26.53 28.14,26.53 28.18,26.54 28.2,26.54 28.23,26.52 28.55,26.2 29.88,26.2 29.92,26.24 29.96,26.25 29.99,26.24 30.14,26.1 30.14,25.46 29.48,24.8 29.48,22.91 28.73,22.16 26.13,22.16 26.02,22.27 26.02,22.64 26.81,23.43 26.81,25.03 26.55,25.28 26.25,25.28 25.74,25.79 24.22,25.79 24.2,25.8 24.18,25.81 24.1,25.87 24.01,25.91 24,25.91 23.89,26.02 23.89,26.55 24.42,27.09 27.65,27.09
GND on BOTTOM (solid shape): 76.71,125.94 76.71,125.93 77.18,124.87 78.07,124.14 78.07,124.13 80.44,124.13 81.19,123.38 81.19,117.92 81.04,117.77 80.11,117.77 79.92,117.96 79.92,122.19 79.39,122.72 76.95,122.72 75.83,121.6 75.83,118.02 75.75,117.94 75.12,117.94 74.92,117.74 74.92,116.97 75.02,116.87 75.02,116.86 75.05,116.81 75.1,116.78 75.11,116.78 75.78,116.11 75.78,115.74 75.71,115.67 75.36,115.67 75.28,115.75 75.28,115.93 74.3,116.91 73.26,116.91 73.11,117.05 73.11,121.36 72.23,122.25 72.23,124.83 72.76,125.36 72.76,125.61 73.11,125.97 76.68,125.97
GND on BOTTOM (solid shape): 125.87,25.82 125.87,24.57 126.17,24.27 127.39,24.27 127.6,24.07 127.95,24.07 128.47,23.54 129.89,23.54 130.03,23.4 130.03,23.4 130.11,23.33 130.24,23.33 130.41,23.15 130.41,22.87 130.74,22.54 131.95,22.54 131.97,22.52 132.54,22.52 132.55,22.52 133.82,22.52 134.01,22.33 134.01,21.87 133.87,21.73 133.16,21.73 132.93,21.5 132.47,21.5 132.24,21.73 122.9,21.73 122.85,21.77 122.85,22.48 122.69,22.63 122.69,24.78 122.79,24.88 124.39,24.88 124.51,24.8 124.65,24.78 124.92,24.89 125.03,25.16 125,25.3 124.92,25.43 124.9,25.45 124.9,25.51 124.88,25.54 124.88,25.97 124.98,26.07 125.61,26.07
GND on BOTTOM (solid shape): 44.66,31.1 44.66,27.29 44.46,27.09 43.63,27.09 43.61,27.09 43.46,27.21 43.29,27.25 43.16,27.22 43.04,27.15 43.02,27.13 43.01,27.13 42.95,27.13 42.9,27.15 42.62,27.25 42.35,27.11 42.34,27.09 42.31,27.09 40.63,27.09 40.59,27.11 40.58,27.11 40.45,27.21 40.3,27.24 40.19,27.23 40.09,27.18 40.07,27.17 40.04,27.17 40.02,27.19 39.91,27.29 39.91,31.28 40.05,31.41 44.35,31.41
GND on BOTTOM (solid shape): 6.49,12 6.77,11.72 8.49,11.72 9.64,10.58 9.64,1.94 10.06,1.52 20.36,1.52 20.53,1.35 20.53,0.57 20.47,0.51 1,0.51 0.65,0.65 0.51,1 0.51,10.64 3.23,10.64 4.36,10.18 5.11,11.15 5.11,12.85 5.56,12.95 5.78,13.35 5.83,13.4 6.49,13.4
GND on BOTTOM (solid shape): 131.92,34.81 131.92,33.46 131.9,33.38 131.89,33.31 131.9,33.24 131.92,33.16 131.92,32.47 131.33,31.88 130.12,31.88 130.03,31.96 129.47,32.14 129.52,31.55 129.52,30.93 129.4,30.82 129.06,30.82 128.88,30.82 128.59,30.52 128.59,29.18 127.84,28.43 126.74,28.43 126.61,28.56 126.61,30.93 126.74,31.06 127.41,31.06 127.6,31.25 127.6,31.74 128.02,32.15 128.8,32.15 128.87,32.23 128.91,32.26 128.94,32.3 130.12,33.48 130.12,34.88 130.17,34.93 131.8,34.93
GND on BOTTOM (solid shape): 21.78,70.62 21.78,65.57 19.62,63.41 16.7,63.41 15.86,62.57 15.86,60.49 15.45,60.08 12.94,60.08 12.76,60.26 12.76,61.84 12.01,62.81 10.88,62.35 8.9,62.35 8.42,62.18 8.16,61.75 2.31,61.75 2.11,61.95 2.11,67.79 2.31,67.99 6.72,67.99 7.64,67.07 8.75,67.07 9.61,67.93 9.61,71.05 9.95,71.05 10.14,71.04 10.32,71.1 11.94,71.1 12.99,72.15 14.51,72.15 15.07,72.71 19.7,72.71
GND on BOTTOM (solid shape): 115.52,38.54 115.56,38.53 115.57,38.49 115.57,38.46 116.37,38.46 116.4,38.45 116.42,38.41 116.42,38.26 116.4,38.22 116.37,38.21 115.57,38.21 115.57,37.96 116.37,37.96 116.4,37.95 116.42,37.91 116.42,37.76 116.4,37.72 116.37,37.71 115.57,37.71 115.57,37.46 116.37,37.46 116.4,37.45 116.42,37.41 116.42,37.26 116.4,37.22 116.37,37.21 115.57,37.21 115.57,36.96 116.37,36.96 116.4,36.95 116.42,36.91 116.42,35.42 116.52,35.32 117.28,35.32 117.41,35.19 117.41,33.67 117.05,33.31 116.22,33.31 116.09,33.44 116.09,34.15 115.81,34.43 113.19,34.43 112.89,34.12 112.89,32.4 112.56,32.07 111.59,32.07 111.36,32.29 111.36,34.91 112.71,36.26 113.7,36.26 114.26,36.82 114.26,38.42 114.39,38.54
GND on BOTTOM (solid shape): 13.22,90.26 13.22,87.67 11.77,86.22 11.77,84.77 12.74,83.81 12.74,83.27 12.13,82.66 11.01,82.66 10.7,82.36 10.7,81.68 10.62,81.6 9.61,81.6 9.61,84.49 8.77,85.33 7.61,85.33 6.69,84.41 2.21,84.41 2.01,84.61 2.01,87.41 0.51,87.41 0.51,88.29 0.71,88.49 4.49,88.49 4.49,88 4.7,87.5 5.2,87.29 6.6,87.29 7.1,87.5 7.31,88 7.31,88.49 11.2,88.49 11.7,88.7 11.91,89.2 11.91,90.36 12.21,90.66 12.81,90.66
GND on BOTTOM (solid shape): outline of 82 points within 31.26,18.66 51.92,22.3
GND on BOTTOM (solid shape): 77.98,46.77 78.19,46.7 78.39,46.77 78.63,46.77 78.84,46.7 79.04,46.77 79.26,46.77 79.46,46.7 79.67,46.77 79.91,46.77 80.11,46.7 80.32,46.77 80.53,46.77 80.66,46.65 80.66,46.42 80.16,45.92 80.16,45.74 79.89,45.48 79.74,45.48 79.34,45.88 79.29,45.88 79.22,45.91 79.16,45.92 79.06,45.89 78.95,45.81 78.93,45.81 78.75,45.81 78.72,45.81 78.62,45.89 78.51,45.92 78.45,45.91 78.37,45.88 78.32,45.83 78.07,45.83 78.05,45.84 77.99,45.88 77.68,46.19 77.68,46.65 77.81,46.77
GND on BOTTOM (solid shape): 22.26,43.03 22.26,42.61 22.26,42.51 23.02,41.74 23.02,36.34 23.01,36.27 23,36.21 23.01,36.16 23.02,36.09 23.02,35.58 23.01,35.51 23,35.45 23.01,35.39 23.02,35.33 23.02,33.8 23.01,33.78 22.44,33.21 21.32,33.21 20.98,33.55 20.98,33.72 21.07,33.81 21.07,34.13 20.79,34.4 20.48,34.4 20.08,34.81 20.08,36.82 20.19,36.93 20.21,36.94 20.25,36.94 20.33,36.95 20.43,36.98 20.52,37.05 20.6,37.15 20.6,37.16 20.79,37.35 20.79,38.07 20.79,38.09 20.8,38.1 20.89,38.19 21.95,38.19 22.31,38.55 22.31,39.28 22.1,39.49 22.1,41.26 21.68,41.68 21.54,41.82 21.35,41.87 21.1,41.78 20.97,41.56 20.97,41.54 20.94,41.52 20.2,41.52 20.13,41.59 20.13,42.25 20.66,42.79 20.66,43.37 20.92,43.62 21.67,43.62
GND on BOTTOM (solid shape): 32.29,14.87 32.29,14.06 32.42,13.93 32.93,13.93 33.29,13.58 34.2,13.58 34.35,13.42 34.35,12.61 34.87,12.09 34.87,12.07 34.91,11.95 34.97,11.85 34.99,11.83 34.99,11.8 34.96,11.75 34.93,11.73 34.91,11.69 34.78,11.57 34.5,11.57 33.54,12.53 33.17,12.53 33.15,12.54 33.04,12.57 32.93,12.58 32.87,12.56 32.8,12.53 32.41,12.53 32.39,12.54 32.28,12.57 32.17,12.58 32.11,12.56 32.04,12.53 30.3,12.53 30.28,12.54 30.26,12.55 29.98,12.67 29.71,12.55 29.69,12.54 29.67,12.53 29.53,12.53 29.51,12.54 29.5,12.55 29.22,12.67 28.94,12.55 28.93,12.54 28.91,12.53 28.28,12.53 27.82,12.99 27.52,12.99 27.39,13.12 27.39,13.83 27.52,13.96 28.41,13.96 28.51,13.85 28.51,13.55 28.84,13.22 30.11,13.22 30.62,13.73 30.62,14.82 30.77,14.97 32.19,14.97
GND on BOTTOM (solid shape): 15.02,48.45 15.02,47.76 14.77,47.51 14.77,41.64 15.23,41.18 15.23,40.68 14.9,40.35 12.91,40.35 12.76,40.5 12.76,41.84 12.01,42.81 10.88,42.35 8.9,42.35 8.42,42.18 8.16,41.75 3.45,41.75 3.25,41.95 3.25,46.93 3.45,47.13 8.16,47.13 8.42,46.7 8.9,46.53 10.88,46.53 12.01,46.07 12.76,47.04 12.76,48.8 12.86,48.9 14.56,48.9
GND on BOTTOM (solid shape): 191.02,11.29 194.3,11.29 194.42,11.16 194.42,11.01 194.64,10.79 194.64,10.21 194.53,10.1 194.11,10.1 194.01,10.17 194.03,10.28 194.12,10.39 194.14,10.53 193.79,10.89 193.43,10.53 193.43,10.5 193.44,10.45 193.43,10.43 193.1,10.1 192.6,10.1 192.51,10.17 192.53,10.28 192.61,10.39 192.64,10.53 192.28,10.89 191.93,10.53 191.95,10.39 192.03,10.28 192.06,10.17 191.96,10.1 190.12,10.1 189.95,10.27 189.95,11.09 190.16,11.29 191.02,11.29
