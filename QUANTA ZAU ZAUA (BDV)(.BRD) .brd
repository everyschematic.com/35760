# Allegro board QUANTA ZAU ZAUA (BDV)(.BRD) .brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ30: length 32.4
  IN1 w0.089: v2(55.86,76.72) 56.28,77.13 57.38,77.13 57.55,76.96 57.55,75.89 57.68,75.76 61.33,75.76 62.33,76.76 62.46,76.76 62.62,76.59 62.62,76.47 62.08,75.93 62.08,75.8 62.22,75.67 62.42,75.67 62.94,76.19 63.06,76.19 63.2,76.05 63.2,75.92 62.66,75.39 62.66,75.22 62.76,75.13 62.94,75.13 63.5,75.69 63.62,75.69 63.77,75.55 63.77,75.42 63.58,75.23 63.58,75.12 63.66,75.04 64.36,75.04 66.13,73.27 66.2,73.27 66.84,72.63 68.12,72.63 v2(68.54,72.21)
  BOTTOM w0.076: 71.81,70.21 72.27,70.21 73.87,68.61 74.84,68.61 74.99,68.67 U2030.BA59
  BOTTOM w0.102: v2(55.86,76.72) 55.86,76.63 56.78,75.7 JDIM2000.83 ; 71.81,70.21 69.53,70.21 68.4,71.34 68.4,72.07 v2(68.54,72.21)
M_A_DQ31: length 32.9
  IN1 w0.089: v2(67.96,72.23) 66.83,72.23 66.13,72.93 65.97,72.93 64.21,74.7 62.71,74.7 61.99,75.41 53.26,75.41 53.14,75.54 53.14,75.79 53.24,75.89 57.01,75.89 57.15,76.03 v2(57.15,76.73)
  BOTTOM w0.076: U2030.AY59 75.84,68.88 75.79,68.82 75.7,68.74 75.58,68.61 75.38,68.61 74.95,68.48 74.88,68.45 73.8,68.45 72.4,69.85 71.81,69.85
  BOTTOM w0.102: v2(67.96,72.23) 67.96,71.22 69.33,69.85 71.81,69.85 ; JDIM2000.79 57.18,76.7 v2(57.15,76.73)
M_A_DQ32: length 30.5
  IN1 w0.089: v2(51.56,50.98) 52.73,52.15 56.93,52.15 57.45,52.67 57.45,54.33 59.26,56.14 60.59,56.14 61.85,57.41 66.48,57.41 66.81,57.08 v2(67.4,57.08)
  BOTTOM w0.076: U2030.AY39 75.74,58.14 75.25,58.14 75.09,58.2 75.05,58.2 74.83,58.31 73.78,58.31 73.53,58.06 73.02,58.06 72.85,58.22
  BOTTOM w0.102: JDIM2000.174 51.53,50.95 v2(51.56,50.98) ; 72.85,58.22 72.69,58.38 69.53,58.38 69.23,58.08 68.38,58.08 67.66,57.36 67.66,57.35 v2(67.4,57.08)
M_A_DQ33: length 28.2
  IN1 w0.089: v2(72.14,57.09) 71.67,57.56 68.46,57.56 68.26,57.76 67.27,57.76 66.94,58.09 61.57,58.09 60.92,57.44 59.59,57.44 55.88,53.73 55.68,53.73 55.59,53.64 55.59,53.4 55.68,53.31 56.2,53.31 v2(56.59,52.91)
  BOTTOM w0.076: v2(72.14,57.09) 72.49,56.74 74.31,56.74 74.47,56.89 74.52,56.94 74.87,56.94 75,56.89 75.12,56.89 75.34,56.96 75.48,56.96 75.64,56.9 75.82,56.9 75.98,56.98 76.49,56.98 76.7,57.18 U2030.AW39
  BOTTOM w0.102: v2(56.59,52.91) 56.59,52.6 56.99,52.2 JDIM2000.169
M_A_DQ34: length 30.4
  IN1 w0.089: v2(71.55,57.08) 70.58,56.11 67.73,56.11 67.59,55.97 66.06,55.97 65.82,55.73 62.55,55.73 61.41,54.59 60.06,54.59 59.03,53.56 59.03,52.1 56.81,49.87 56.17,49.87 55.85,49.55 54.75,49.55 54.64,49.44 54.64,49.27 54.75,49.16 55.48,49.16 v2(55.89,48.75)
  BOTTOM w0.076: v2(71.55,57.08) 72.07,56.57 74.38,56.57 74.59,56.78 74.84,56.78 74.97,56.72 75.11,56.72 75.34,56.78 75.47,56.78 75.69,56.71 75.94,56.71 U2030.AY37
  BOTTOM w0.102: JDIM2000.187 56.93,47.71 v2(55.89,48.75)
M_A_DQ35: length 31.1
  IN1 w0.089: v2(57.06,48.77) 57.06,49.16 57.03,49.18 56.31,49.18 56.2,49.29 56.2,49.41 56.31,49.53 56.95,49.53 59.79,52.37 59.79,52.49 59.43,52.86 59.43,53 59.54,53.12 59.67,53.12 60.04,52.75 60.17,52.75 60.29,52.87 60.29,53 60.11,53.18 60.11,53.31 60.23,53.43 60.36,53.43 60.54,53.25 60.67,53.25 60.8,53.38 60.8,53.5 60.32,53.98 60.32,54.11 60.44,54.23 60.57,54.23 61.05,53.75 61.17,53.75 62.81,55.39 65.81,55.39 66.18,55.76 67.67,55.76 67.84,55.92 69.49,55.92 69.58,55.83 69.58,55.67 v2(69.25,55.35)
  BOTTOM w0.076: 69.5,55.95 69.63,56.08 74.52,56.08 75.4,56.08 75.62,56.3 76.17,56.3 76.48,56.61 U2030.AW37
  BOTTOM w0.102: JDIM2000.183 57.12,48.71 v2(57.06,48.77) ; v2(69.25,55.35) 69.25,55.7 69.5,55.95
M_A_DQ36: length 29.1
  IN1 w0.089: v2(68.58,57.09) 68.18,57.5 67.14,57.5 66.89,57.75 61.71,57.75 60.74,56.78 60.49,56.78 60.17,57.1 59.73,57.1 57.09,54.45 57.09,54.01 56.98,53.9 56.5,53.9 56.38,53.77 56.38,53.63 56.51,53.5 57.06,53.5 57.11,53.45 57.11,52.82 56.79,52.49 55.53,52.49 55.41,52.61 v2(55.41,52.88)
  BOTTOM w0.076: U2030.BB39 74.64,57.94 73.87,57.94 73.66,57.73 72.79,57.73 72.54,57.97 72.45,57.97
  BOTTOM w0.102: 72.45,57.97 69.96,57.97 69.5,57.52 69,57.52 v2(68.58,57.09) ; JDIM2000.173 56.77,51.2 55.41,52.56 v2(55.41,52.88)
M_A_DQ37: length 30
  IN1 w0.089: v2(52.74,51.01) 53.54,51.81 57.07,51.81 57.8,52.53 57.8,54.19 59.4,55.8 60.73,55.8 61.84,56.91 66.5,56.91 66.75,56.67 67.52,56.67 67.73,56.88 67.76,56.88 v2(67.98,57.09)
  BOTTOM w0.076: U2030.BA39 75.25,57.83 75.11,57.97 75.1,57.98 75.1,57.99 74.8,58.13 73.84,58.13 73.6,57.89 72.92,57.89 72.64,58.18 72.48,58.18
  BOTTOM w0.102: v2(52.74,51.01) 51.79,51.95 JDIM2000.170 ; v2(67.98,57.09) 68.7,57.81 69.42,57.81 69.78,58.18 72.48,58.18
M_A_DQ38: length 30.1
  IN1 w0.089: v2(52.75,48.1) 57.27,48.1 57.52,48.35 57.52,49.62 62.95,55.04 65.8,55.04 66.28,55.53 67.73,55.53 67.93,55.73 68.29,55.73 v2(68.67,55.35)
  BOTTOM w0.076: U2030.BA37 75.18,56.51 74.92,56.24 74.9,56.24 74.9,56.24 74.59,56.24 74.59,56.24 69.48,56.24
  BOTTOM w0.102: v2(68.67,55.35) 68.67,55.53 69.39,56.24 69.48,56.24 ; JDIM2000.182 51.89,48.95 v2(52.75,48.1)
M_A_DQ39: length 29.2
  IN1 w0.089: v2(51.58,48.08) 52.02,47.64 57.29,47.64 57.87,48.21 57.87,49.47 63.09,54.7 65.76,54.7 66.33,55.27 68.01,55.27 v2(68.09,55.35)
  BOTTOM w0.076: U2030.BB37 74.55,56.51 74.45,56.41 70.06,56.41 70.04,56.42 70.01,56.45 69.5,56.45
  BOTTOM w0.102: 69.5,56.45 69.19,56.45 v2(68.09,55.35) ; JDIM2000.186 51.45,47.95 v2(51.58,48.08)
M_A_DQ40: length 33.9
  IN1 w0.089: v2(52.9,45.99) 53.28,45.61 54.3,45.61 54.41,45.72 54.41,46.61 54.5,46.7 54.68,46.7 54.79,46.59 54.79,45.84 54.88,45.75 55.06,45.75 55.15,45.84 55.15,46.57 55.28,46.7 57.68,46.7 58.81,47.82 58.81,49.09 63.43,53.71 65.37,53.71 66.44,54.78 70.44,54.78 v2(71.01,55.35)
  BOTTOM w0.076: v2(71.01,55.35) 71.57,54.79 72.4,54.79 73.03,55.42 74.07,55.42 74.28,55.21 74.85,55.21 74.94,55.25 74.95,55.25 75.2,55.25 75.29,55.21 75.5,55.21 75.58,55.24 75.58,55.24 75.68,55.28 75.94,55.28 U2030.AY35
  BOTTOM w0.102: JDIM2000.190 51.93,46.95 v2(52.9,45.99)
M_A_DQ41: length 34.5
  IN1 w0.089: v2(51.72,45.98) 51.72,46.04 52.72,47.04 52.85,47.04 52.94,46.95 52.94,46.5 53.03,46.4 53.2,46.4 53.29,46.49 53.29,46.94 53.38,47.03 53.56,47.03 53.65,46.94 53.65,46.12 53.74,46.03 53.91,46.03 54,46.13 54,46.95 54.09,47.04 57.54,47.04 58.46,47.96 58.46,49.23 63.32,54.09 65.5,54.09 66.43,55.02 67.27,55.02 67.35,54.94 70.02,54.94 v2(70.42,55.35)
  BOTTOM w0.076: U2030.AW35 76.51,55.38 76.18,55.7 75.64,55.7 75.43,55.91 75.04,55.91 75.04,55.91 74.45,55.91 74.45,55.91 70.99,55.91 v2(70.42,55.35)
  BOTTOM w0.102: v2(51.72,45.98) 51.66,45.98 51.64,45.95 JDIM2000.194
M_A_DQ42: length 34.4
  IN1 w0.089: v2(67.63,53.57) 66.86,53.57 60.89,47.6 60.89,47.27 60.53,46.91 60.53,46.5 60.94,46.09 60.94,45.96 60.81,45.84 60.69,45.84 60.34,46.19 60.21,46.19 60.08,46.06 60.08,45.94 60.44,45.58 60.44,45.45 60.32,45.33 60.19,45.33 59.83,45.69 59.7,45.69 59.57,45.57 59.57,45.44 59.91,45.11 59.91,44.98 59.78,44.86 59.66,44.86 59.19,45.32 59.04,45.32 58.93,45.21 58.93,45.08 59.37,44.64 59.37,44.52 59.25,44.39 59.12,44.39 58.72,44.79 58.57,44.79 58.43,44.65 58.43,44.52 58.88,44.07 58.88,43.94 58.69,43.75 56.27,43.75 v2(55.74,43.23)
  BOTTOM w0.076: 70.48,53.15 70.49,53.16 72.13,53.16 72.7,53.73 74.33,53.73 74.34,53.72 74.9,53.72 75.05,53.79 75.12,53.82 75.25,53.88 75.57,53.88 75.84,54.15 U2030.AY33
  BOTTOM w0.102: v2(55.74,43.23) 56.22,43.71 JDIM2000.203 ; 70.48,53.15 68.04,53.15 v2(67.63,53.57)
M_A_DQ43: length 33.3
  IN1 w0.089: v2(56.33,43.25) 56.56,43.02 56.9,42.68 58.36,42.68 61.55,45.87 61.55,46.09 61.2,46.44 61.2,46.85 61.92,47.57 61.92,47.7 61.75,47.87 61.75,48.02 61.87,48.15 61.97,48.15 62.25,47.87 62.38,47.87 62.5,47.99 62.5,48.12 62.23,48.4 62.23,48.5 62.35,48.62 62.51,48.62 62.7,48.43 62.83,48.43 62.95,48.55 62.95,48.68 62.77,48.86 62.77,48.98 62.9,49.11 63.02,49.11 63.22,48.91 63.35,48.91 63.47,49.04 63.47,49.17 63.25,49.38 63.25,49.53 66.81,53.09 67.74,53.09 v2(68.22,53.57)
  BOTTOM w0.076: 71.21,54.66 71.25,54.62 72.47,54.62 73.1,55.25 74.01,55.25 74.21,55.05 74.88,55.05 74.88,55.05 74.97,55.08 74.98,55.08 75.17,55.08 75.26,55.05 75.26,55.05 75.26,55.04 75.27,55.04 75.5,55.04 75.7,55.11 75.91,55.11 75.99,55.05 76.53,55.05 76.7,54.88 U2030.AW33
  BOTTOM w0.102: v2(68.22,53.57) 68.22,53.96 68.92,54.66 71.21,54.66 ; v2(56.33,43.25) 56.56,43.02 56.87,42.71 JDIM2000.207
M_A_DQ44: length 32.6
  IN1 w0.089: v2(71.59,55.34) 71.16,54.91 71.16,54.87 71.26,54.77 72.38,54.77 72.51,54.63 72.51,54.48 72.4,54.37 70.55,54.37 70.31,54.61 66.58,54.61 65.37,53.4 63.61,53.4 59.15,48.94 59.15,47.68 57.68,46.21 56.91,46.21 56.43,45.73 56.31,45.73 56.24,45.8 56.24,46.12 56.15,46.21 55.96,46.21 55.87,46.12 55.87,45.79 55.78,45.7 55.69,45.7 v2(55.21,45.22)
  BOTTOM w0.076: U2030.BB35 74.64,55.58 74.18,55.58 74.18,55.58 72.96,55.58 72.33,54.95 71.98,54.95 v2(71.59,55.34)
  BOTTOM w0.102: v2(55.21,45.22) 56.69,46.71 JDIM2000.191
M_A_DQ45: length 32.9
  IN1 w0.089: v2(72.17,55.35) 73.27,54.26 73.91,54.26 74,54.17 74,53.97 73.89,53.86 73.4,53.86 73.31,53.77 73.31,52.8 73.22,52.71 72.41,52.71 72.28,52.84 72.28,53.94 72.16,54.07 70.45,54.07 70.07,54.45 66.7,54.45 65.25,53 63.69,53 59.49,48.8 59.49,47.54 57.75,45.8 56.94,45.8 v2(56.37,45.23)
  BOTTOM w0.076: v2(72.17,55.35) 72.57,55.75 74.24,55.75 74.25,55.75 74.59,55.75 74.9,55.75 74.92,55.73 74.93,55.73 75.17,55.48 U2030.BA35
  BOTTOM w0.102: JDIM2000.195 56.85,45.71 v2(56.37,45.23)
M_A_DQ46: length 32.8
  IN1 w0.089: v2(71.78,53.64) 70.64,52.5 67.17,52.5 64.32,49.66 64.32,48.82 62.9,47.4 62.9,46.25 59.32,42.67 59.32,42.12 59.2,42 56.15,42 55.75,41.59 54.11,41.59 54.02,41.68 54.02,41.95 53.94,42.04 53.76,42.04 53.67,41.95 53.67,41.68 53.58,41.59 52.42,41.59 v2(51.54,42.48)
  BOTTOM w0.076: v2(71.78,53.64) 72.03,53.9 74.45,53.9 74.46,53.89 74.85,53.89 75.05,53.97 U2030.BA33
  BOTTOM w0.102: JDIM2000.208 51.51,42.45 v2(51.54,42.48)
M_A_DQ47: length 32.5
  IN1 w0.089: v2(70.61,53.65) 70.61,53.65 69.77,52.81 66.97,52.81 63.98,49.82 63.98,48.96 62.55,47.54 62.55,46.39 58.5,42.34 55.63,42.34 55.54,42.25 55.54,41.99 55.46,41.9 55.28,41.9 55.19,41.99 55.19,42.25 55.1,42.34 54.92,42.34 54.83,42.25 54.83,41.99 54.74,41.9 54.57,41.9 54.48,41.99 54.48,42.25 54.39,42.34 52.87,42.34 v2(52.71,42.51)
  BOTTOM w0.076: v2(70.61,53.65) 70.61,53.84 70.83,54.06 74.47,54.06 74.56,54.15 U2030.BB33
  BOTTOM w0.102: JDIM2000.204 51.76,43.45 v2(52.71,42.51)
M_A_DQ48: length 35.9
  IN1 w0.089: v2(67.93,51.7) 67.49,51.7 65.26,49.47 65.26,47.94 63.9,46.58 63.9,45.93 61.72,43.74 61.72,42.97 59.74,40.99 56.55,40.99 56.17,40.61 54.32,40.61 53.77,40.06 53.77,39.79 53.68,39.7 53.49,39.7 53.4,39.79 53.4,40.04 53.34,40.1 53.15,40.1 53.05,40 53.05,39.72 52.96,39.63 52.73,39.63 52.64,39.72 52.64,40.3 v2(52.84,40.5)
  BOTTOM w0.076: U2030.AY31 75.84,52.85 75.6,53.1 75.51,53.18 75.16,53.18 75.01,53.24 74.97,53.28 74.52,53.28 73.4,53.28 73.05,52.93 72.19,52.93 72.13,53 70.79,53 70.74,52.95
  BOTTOM w0.102: v2(67.93,51.7) 67.93,52.11 68.76,52.95 70.74,52.95 ; v2(52.84,40.5) 51.89,41.45 JDIM2000.212
M_A_DQ49: length 35.8
  IN1 w0.089: v2(72.65,51.83) 72.31,52.17 67.54,52.17 64.92,49.56 64.92,48.08 63.51,46.67 63.51,46.02 61.37,43.88 61.37,43.11 61.13,42.87 61,42.87 60.78,43.1 60.65,43.1 60.52,42.97 60.52,42.84 60.75,42.62 60.75,42.49 60.51,42.25 60.38,42.25 60.13,42.5 59.98,42.5 59.85,42.38 59.85,42.28 60.13,42 60.13,41.87 59.62,41.36 56.27,41.36 55.91,41 52.1,41 51.61,40.5 v2(51.61,40.48)
  BOTTOM w0.076: U2030.AW31 76.7,52.2 76.49,52 75.98,52 75.82,51.92 75.64,51.92 75.48,51.98 75.34,51.98 75.12,51.91 75,51.91 74.92,51.95 74.87,51.97 74.31,51.97 74,51.66 72.82,51.66 v2(72.65,51.83)
  BOTTOM w0.102: JDIM2000.216 51.56,40.45 51.58,40.48 v2(51.61,40.48)
M_A_DQ50: length 34.7
  IN1 w0.089: v2(56.72,37.67) 59.11,37.67 63.31,41.86 64.14,41.86 67.18,44.91 67.18,46.65 67.09,46.74 67.09,48.59 67.92,49.42 67.92,50.2 68.2,50.47 72.91,50.47 73.02,50.58 73.02,50.71 72.93,50.8 71.04,50.8 70.95,50.89 70.95,51.05 71.06,51.17 71.93,51.17 72.08,51.32 v2(72.08,51.7)
  BOTTOM w0.076: U2030.AY29 75.94,51.73 75.69,51.73 75.47,51.8 75.34,51.8 75.11,51.74 74.97,51.74 74.85,51.8 74.37,51.8 74.07,51.5 72.96,51.5 72.88,51.42 72.36,51.42 v2(72.08,51.7)
  BOTTOM w0.102: JDIM2000.229 57.19,37.2 v2(56.72,37.67)
M_A_DQ51: length 36.3
  IN1 w0.089: v2(51.54,38.48) 53.45,36.57 59.81,36.57 63.56,40.32 63.89,40.32 63.89,40.32 68.24,44.67 68.24,46.95 67.88,47.31 67.88,48.26 68.7,49.08 68.95,49.08 v2(69.91,50.03)
  BOTTOM w0.076: U2030.AW29 76.48,51.63 76.17,51.32 75.62,51.32 75.4,51.09 74.37,51.09 74.28,51 73.29,51 73,50.72 72.81,50.72
  BOTTOM w0.102: JDIM2000.224 51.52,38.45 v2(51.54,38.48) ; 72.81,50.72 70.31,50.72 69.91,50.31 v2(69.91,50.03)
M_A_DQ52: length 34.7
  IN1 w0.089: v2(55.17,40.1) 54.89,39.82 54.27,39.82 54.18,39.73 54.18,39.53 54.27,39.43 57.41,39.43 57.57,39.27 58.99,39.27 62.77,43.06 63.54,43.06 65.25,44.77 65.25,44.9 64.6,45.55 64.6,46.3 66,47.71 66,49.28 67.79,51.06 68.46,51.06 v2(69.09,51.7)
  BOTTOM w0.076: U2030.BB31 73.44,52.85 73.18,52.6 72.05,52.6 71.99,52.67 71.17,52.67 71.05,52.55
  BOTTOM w0.102: v2(55.17,40.1) 55.17,40.3 56.57,41.71 JDIM2000.211 ; 71.05,52.55 69.66,52.55 69.09,51.98 v2(69.09,51.7)
M_A_DQ53: length 35
  IN1 w0.089: v2(56.34,40.12) 56.87,40.65 57.44,40.65 57.54,40.55 57.54,39.88 57.63,39.8 57.81,39.8 57.9,39.89 57.9,40.55 57.99,40.64 58.17,40.64 58.25,40.55 58.25,39.84 58.35,39.74 58.52,39.74 58.61,39.83 58.61,40.55 58.71,40.65 58.89,40.65 58.96,40.59 58.96,40 59.05,39.91 59.14,39.91 59.33,40.09 59.33,40.55 59.41,40.64 59.87,40.64 62.06,42.83 62.06,43.6 63.68,45.22 63.86,45.22 64.47,44.6 64.6,44.6 64.74,44.75 64.74,44.92 64.25,45.41 64.25,46.44 65.61,47.8 65.61,49.31 67.38,51.08 67.54,51.08 67.72,51.26 68.07,51.26 v2(68.51,51.7)
  BOTTOM w0.076: 70.89,52.75 70.97,52.83 72.06,52.83 72.12,52.76 73.11,52.76 73.47,53.12 74.59,53.12 74.59,53.12 74.9,53.12 74.93,53.09 75.1,53.01 75.1,53 75.11,52.99 75.25,52.85 U2030.BA31
  BOTTOM w0.102: v2(68.51,51.7) 68.51,52.05 69.21,52.75 70.89,52.75 ; v2(56.34,40.12) 56.92,40.71 JDIM2000.215
M_A_DQ54: length 35
  IN1 w0.089: v2(52.71,38.49) 54.29,36.91 59.54,36.91 63.3,40.66 63.8,40.66 67.87,44.73 67.87,46.9 67.61,47.16 67.61,48.38 68.9,49.67 68.96,49.67 v2(69.32,50.03)
  BOTTOM w0.076: U2030.BA29 75.17,51.53 74.9,51.26 74.3,51.26 74.21,51.17 73.16,51.17 72.96,50.96 72.52,50.96
  BOTTOM w0.102: JDIM2000.228 51.68,37.45 v2(52.71,38.49) ; 72.52,50.96 69.91,50.96 69.32,50.38 v2(69.32,50.03)
M_A_DQ55: length 33.5
  IN1 w0.089: v2(68.74,50.03) 68.32,49.62 68.32,49.44 67.33,48.44 67.33,46.98 67.52,46.78 67.52,44.82 63.71,41.01 63.05,41.01 59.3,37.25 54.65,37.25 54.53,37.37 54.53,37.54 54.66,37.66 v2(55.55,37.66)
  BOTTOM w0.076: U2030.BB29 74.33,51.53 74.14,51.33 73.05,51.33 72.88,51.17 72.45,51.17
  BOTTOM w0.102: v2(55.55,37.66) 56.38,38.49 57.18,38.49 57.47,38.2 JDIM2000.225 ; v2(68.74,50.03) 68.74,50.45 69.46,51.17 72.45,51.17
M_A_DQ56: length 40.7
  IN1 w0.089: v2(57.1,35.23) 57.16,35.29 61.69,35.29 64.24,37.84 64.7,37.84 66.19,39.33 66.19,39.46 65.7,39.95 65.7,40.07 65.83,40.2 65.95,40.2 66.45,39.71 66.57,39.71 66.74,39.87 66.74,39.99 66.27,40.46 66.27,40.6 66.37,40.7 66.54,40.7 66.97,40.27 67.14,40.27 67.22,40.36 67.22,40.53 66.79,40.96 66.79,41.24 67.41,41.87 67.54,41.87 67.9,41.51 68.01,41.51 68.14,41.63 68.14,41.77 67.79,42.12 67.79,42.25 67.92,42.37 68.04,42.37 68.57,41.85 68.71,41.85 68.84,41.97 68.84,42.08 68.29,42.62 68.29,42.75 68.42,42.87 68.54,42.87 69.09,42.33 69.2,42.33 69.32,42.46 69.32,42.6 68.59,43.33 68.59,43.43 68.72,43.56 68.87,43.56 69.47,42.95 69.62,42.95 69.74,43.08 69.74,43.18 69.3,43.63 69.3,43.75 69.39,43.84 69.66,43.84 69.74,43.93 69.74,44.07 69.66,44.16 69.54,44.16 69.44,44.26 69.44,47.83 69.29,47.99 v2(69.29,48.24)
  BOTTOM w0.076: U2030.AY27 75.94,50.3 75.68,50.3 75.58,50.26 75.58,50.26 75.5,50.23 75.3,50.23 75.15,50.29 75.08,50.29 74.99,50.28 74.96,50.28 74.93,50.27 74.85,50.23 74.59,50.23 74.48,50.34 73.66,50.34 72.76,49.44 71.85,49.44
  BOTTOM w0.102: JDIM2000.237 57.12,35.2 v2(57.1,35.23) ; 71.85,49.44 70.01,49.44 69.29,48.72 v2(69.29,48.24)
M_A_DQ57: length 41.4
  IN1 w0.089: v2(71.08,50.03) 71.08,49.74 71,49.67 70.7,49.67 70.62,49.59 70.62,49.43 70.71,49.34 71.28,49.34 71.36,49.26 71.36,49.12 71.27,49.03 70.71,49.03 70.62,48.94 70.62,48.8 70.71,48.72 72.5,48.72 72.64,48.58 72.64,45.36 71.93,44.65 71.93,42.53 68.5,39.1 68.5,38.65 65,35.16 64.44,35.16 64.13,34.85 64.13,34.3 62.91,33.08 57.55,33.08 57.28,32.81 56.22,32.81 55.98,33.05 v2(55.98,33.23)
  BOTTOM w0.076: 72.91,50.51 73.1,50.51 73.42,50.84 74.35,50.84 74.44,50.93 75.43,50.93 75.64,50.72 76.18,50.72 76.51,50.4 U2030.AW27
  BOTTOM w0.102: JDIM2000.249 56.82,32.2 55.98,33.05 v2(55.98,33.23) ; 72.91,50.51 71.56,50.51 v2(71.08,50.03)
M_A_DQ58: length 40.5
  IN1 w0.089: v2(51.54,35.48) 52.03,35.97 61.41,35.97 61.57,36.13 61.57,36.26 61.07,36.75 61.07,36.88 61.2,37 61.32,37 61.82,36.51 61.94,36.51 62.06,36.62 62.06,36.77 61.57,37.26 61.57,37.38 61.7,37.51 61.82,37.51 62.3,37.03 62.47,37.03 62.57,37.14 62.57,37.26 62.08,37.76 62.08,37.88 62.2,38.01 62.33,38.01 62.8,37.54 62.94,37.54 63.06,37.66 63.06,37.78 62.58,38.26 62.58,38.39 63.92,39.72 64.49,39.72 66.15,41.39 66.15,41.47 67.93,43.25 67.93,43.66 68.83,44.56 68.83,47.27 v2(68.25,47.85)
  BOTTOM w0.076: U2030.AY25 75.84,49.17 75.57,48.9 75.22,48.9 75.12,48.85 74.81,48.7 73.62,48.7 72.41,47.49
  BOTTOM w0.102: 72.41,47.49 68.62,47.49 v2(68.25,47.85) ; v2(51.54,35.48) 51.51,35.45 JDIM2000.236
M_A_DQ59: length 41.3
  IN1 w0.089: v2(69.87,48.24) 69.87,48.03 69.97,47.93 70.13,47.93 70.21,47.85 70.21,47.69 70.14,47.62 69.84,47.62 69.75,47.53 69.75,47.35 69.84,47.26 70.11,47.26 70.2,47.17 70.2,47 70.11,46.91 69.84,46.91 69.75,46.82 69.75,46.64 69.84,46.55 69.96,46.55 70.05,46.46 70.05,46.29 69.96,46.2 69.84,46.2 69.75,46.11 69.75,45.93 69.84,45.84 69.96,45.84 70.05,45.75 70.05,45.57 69.96,45.49 69.84,45.49 69.75,45.4 69.75,45.22 69.84,45.13 69.96,45.13 70.05,45.04 70.05,44.86 69.96,44.77 69.84,44.77 69.75,44.69 69.75,44.51 69.84,44.42 69.96,44.42 70.05,44.33 70.05,42.75 64.79,37.5 64.39,37.5 61.83,34.94 61.51,34.94 61.42,34.85 61.42,34.69 61.3,34.57 61.13,34.57 61.04,34.66 61.04,34.89 60.95,34.98 60.77,34.98 60.68,34.89 60.68,34.66 60.6,34.57 60.42,34.57 60.33,34.66 60.33,34.89 60.24,34.98 60.06,34.98 59.97,34.89 59.97,34.66 59.88,34.57 59.71,34.57 59.62,34.66 59.62,34.89 59.53,34.98 59.35,34.98 59.26,34.89 59.26,34.66 59.17,34.57 59,34.57 58.91,34.66 58.91,34.89 58.82,34.98 58.64,34.98 58.55,34.89 58.55,34.66 58.46,34.57 58.28,34.57 58.2,34.66 58.2,34.89 58.11,34.98 57.93,34.98 57.84,34.89 57.84,34.67 57.74,34.57 57.56,34.57 57.47,34.66 57.47,34.8 57.4,34.86 57.17,34.86 57.11,34.8 57.11,34.66 57.02,34.57 56.52,34.57 v2(55.88,35.21)
  BOTTOM w0.076: U2030.AW25 76.7,49.9 76.53,50.06 75.93,50.06 75.84,50.13 75.7,50.13 75.5,50.06 75.27,50.06 75.26,50.06 75.26,50.07 75.26,50.07 75.15,50.11 74.99,50.11 74.88,50.07 74.88,50.07 74.52,50.07 74.41,50.18 73.73,50.18 72.78,49.23 71.85,49.23
  BOTTOM w0.102: JDIM2000.233 56.88,36.2 v2(55.88,35.21) ; 71.85,49.23 70.48,49.23 69.87,48.62 v2(69.87,48.24)
M_A_DQ60: length 39.2
  IN1 w0.089: v2(52.82,32.57) 53.27,33.02 55,33.02 55.56,32.47 57.36,32.47 57.67,32.78 63.09,32.78 64.57,34.25 64.74,34.25 70.3,39.81 70.3,40.47 72.27,42.44 72.27,44.56 72.96,45.25 72.96,48.66 71.66,49.96 v2(71.66,50.03)
  BOTTOM w0.076: 72,49.63 72.71,49.63 73.59,50.51 74.74,50.51 U2030.BB27
  BOTTOM w0.102: 72,49.63 71.66,49.96 v2(71.66,50.03) ; v2(52.82,32.57) 52.41,32.98 51.24,32.98 51.22,32.95 JDIM2000.246
M_A_DQ61: length 39.4
  IN1 w0.089: v2(52.23,32.54) 52.65,32.12 57.45,32.12 57.8,32.47 63.39,32.47 64.83,33.91 64.83,33.91 70.68,39.76 70.68,40.42 72.63,42.38 72.63,44.49 73.29,45.15 73.29,48.98 v2(72.25,50.03)
  BOTTOM w0.076: U2030.BA27 75.17,50.5 74.91,50.76 74.51,50.76 74.41,50.67 73.53,50.67 72.88,50.03 v2(72.25,50.03)
  BOTTOM w0.102: JDIM2000.250 51.65,31.95 v2(52.23,32.54)
M_A_DQ62: length 40
  IN1 w0.089: v2(68.7,48.22) 68.7,47.92 69.14,47.49 69.14,44.44 68.23,43.53 68.23,43.12 66.48,41.37 66.48,41.29 65.12,39.92 65.12,39.76 65.52,39.36 65.52,39.14 65.05,38.68 64.88,38.68 64.55,39 64.44,39 64.32,38.89 64.32,38.72 64.65,38.39 64.65,38.28 64.57,38.19 64.15,38.19 64.02,38.06 63.89,38.06 63.36,38.59 63.24,38.59 63.11,38.46 63.11,38.34 63.61,37.84 63.61,37.69 61.55,35.63 53.36,35.63 53.09,35.36 53.09,34.83 53,34.75 52.78,34.75 52.71,34.82 v2(52.71,35.49)
  BOTTOM w0.076: 72.32,47.69 73.5,48.87 74.78,48.87 75.1,49.02 75.25,49.17 U2030.BA25
  BOTTOM w0.102: JDIM2000.232 51.75,36.45 v2(52.71,35.49) ; v2(68.7,48.22) 68.7,47.92 68.94,47.69 72.32,47.69
M_A_DQ63: length 38.4
  IN1 w0.089: v2(72.26,48.26) 72.26,47.92 72.16,47.82 71.44,47.82 71.36,47.74 71.36,47.61 71.44,47.53 72.15,47.53 72.25,47.43 72.25,47.33 72.16,47.24 71.42,47.24 71.36,47.18 71.36,47.03 71.44,46.95 72.2,46.95 72.29,46.86 72.29,46.74 72.19,46.63 71.47,46.63 71.4,46.56 71.4,46.42 71.5,46.32 72.22,46.32 72.3,46.24 72.3,46.09 72.22,46.01 71.45,46.01 71.38,45.95 71.38,45.77 71.47,45.68 72.21,45.68 72.3,45.59 72.3,45.45 72.2,45.35 71.33,45.35 71.23,45.25 71.23,44.94 71.32,44.86 71.52,44.86 71.61,44.77 71.61,44.59 71.52,44.5 71.32,44.5 71.23,44.41 71.23,44.23 71.32,44.14 71.52,44.14 71.61,44.06 71.61,43.88 71.52,43.79 71.32,43.79 71.23,43.7 71.23,43.52 71.32,43.43 71.52,43.43 71.61,43.34 71.61,43.17 71.52,43.08 71.32,43.08 71.23,42.99 71.23,42.27 67.95,38.98 67.95,38.53 64.92,35.5 64.3,35.5 63.61,34.81 63.61,34.69 63.76,34.54 63.76,34.41 63.64,34.3 63.49,34.3 63.35,34.44 63.23,34.44 63.1,34.31 63.1,34.18 63.25,34.03 63.25,33.91 63.13,33.78 63,33.78 62.85,33.94 62.72,33.94 62.17,33.39 57.32,33.39 v2(57.16,33.23)
  BOTTOM w0.076: v2(72.26,48.26) 72.61,48.26 73.39,49.03 74.61,49.03 U2030.BB25
  BOTTOM w0.102: JDIM2000.245 57.19,33.2 v2(57.16,33.23)
M_A_DQS0: length 51.3
  IN1 w0.089: v2(55.47,94.66) 55.73,94.92 55.73,95.29 55.94,95.5 58.28,95.5 59.99,93.79 67.38,93.79 68.18,92.98 73.23,92.98 75.13,91.08 75.13,86.54 75.56,86.11 75.69,86.11 76.15,86.56 76.48,86.56 76.78,86.26 76.78,85.89 76.36,85.47 76.36,85.31 76.57,85.1 76.77,85.1 77.19,85.52 77.54,85.52 77.85,85.22 77.85,84.87 77.4,84.42 77.4,84.27 77.64,84.03 77.79,84.03 78.26,84.5 78.61,84.5 78.92,84.2 78.92,83.85 78.45,83.38 78.45,83.23 78.81,82.86 80.33,82.86 v2(80.52,83.05)
  BOTTOM w0.076: 81.37,78.06 81.37,78.04 81.35,78.02 81.35,76.75 81.3,76.7 81.3,76.22 81.36,76.06 81.36,75.91 81.3,75.76 81.3,75.68 81.3,75.61 81.31,75.54 81.33,75.49 81.34,75.43 81.34,75.25 81.31,75.13 81.26,74.98 U2030.AM69
  BOTTOM w0.102: 81.38,81.94 81.38,81.92 81.37,81.9 81.37,78.06
  BOTTOM w0.114: v2(55.47,94.66) 55.64,94.49 55.64,93.84 56.28,93.21 JDIM2000.13 ; v2(80.52,83.05) 80.71,82.85 81.08,82.85 81.38,82.55 81.38,81.94
M_A_DQS1: length 40.1
  IN1 w0.089: v2(78.28,77.58) 78.05,77.8 77.48,77.8 77.27,78.01 77.27,78.75 76.54,79.48 75.78,79.48 75.52,79.21 74.04,79.21 70.58,82.68 69.3,82.68 62.58,89.39 58.62,89.39 58.41,89.59 58.41,90.04 58.33,90.13 53.56,90.13 53.4,89.97 53.4,89.86 v2(53.73,89.53)
  BOTTOM w0.076: U2030.AT70 78.55,75.03 78.5,74.99 78.42,74.99 78.36,75.07 78.33,75.12 78.29,75.22 78.29,75.23 78.27,75.26 78.27,75.31 78.27,75.39 78.31,75.53 78.32,75.62 78.33,75.7 78.31,75.82 78.28,75.9 78.28,76.08 78.33,76.21 78.33,76.55 78.2,76.68 78.2,76.94 77.88,77.26 77.88,77.7 78.01,77.83 78.2,77.83 78.26,77.77 78.28,77.75 v2(78.28,77.58)
  BOTTOM w0.102: JDIM2000.34 51.13,87.95 51.43,88.25 52.85,88.25 53.39,88.79 53.39,89.19 v2(53.73,89.53)
M_A_DQS2: length 34
  IN1 w0.089: v2(55.27,84.31) 55.47,84.51 55.47,84.79 55.69,85.01 57.1,85.01 57.6,84.5 62.31,84.5 68.5,78.31 68.77,78.31 68.86,78.4 68.86,78.58 69.07,78.79 69.62,78.79 69.89,78.52 69.89,77.9 v2(70.09,77.71)
  BOTTOM w0.076: U2030.AY64 76.3,71.99 76.05,72.24 75.86,72.33 75.58,72.33 75.5,72.29 75.29,72.29 75.18,72.34 74.99,72.34 74.85,72.29 74.07,72.29 72.65,73.71 72.65,74.84 72.16,75.33 72.16,76.12 71.56,76.72 70.3,76.72 69.85,77.17 69.85,77.47 v2(70.09,77.71)
  BOTTOM w0.114: JDIM2000.55 57.5,82.7 57.39,82.82 55.86,82.82 55.47,83.21 55.47,84.11 v2(55.27,84.31)
M_A_DQS3: length 32.5
  IN1 w0.089: v2(70.95,72.22) 70.72,72.45 70.71,72.57 70.71,72.88 69.71,73.88 67.46,73.88 62.83,78.5 54.27,78.5 53.89,78.12 52.75,78.12 52.66,78.21 52.66,78.33 v2(52.91,78.59)
  BOTTOM w0.076: v2(70.95,72.22) 70.74,72 70.74,71.62 71.21,71.15 72.03,71.15 73.99,69.19 74.4,69.19 74.52,69.31 74.88,69.31 75.02,69.26 75.13,69.26 75.17,69.27 75.26,69.31 75.53,69.31 75.62,69.27 75.83,69.27 75.96,69.33 75.97,69.35 75.97,69.5 75.93,69.54 75.72,69.54 U2030.BA60
  BOTTOM w0.102: v2(52.91,78.59) 52.64,78.31 52.64,78.08 52.18,77.63 51.29,77.63 51.12,77.46 JDIM2000.76
M_A_DQS4: length 30.3
  IN1 w0.089: v2(55.03,50.32) 55.27,50.56 55.27,50.92 55.63,51.28 57.25,51.28 58.35,52.38 58.35,53.84 59.78,55.27 61.12,55.27 62.27,56.42 67.51,56.42 67.71,56.61 69.84,56.61 69.97,56.75 69.97,56.87 v2(69.75,57.1)
  BOTTOM w0.076: U2030.AY38 76.24,57.27 76.16,57.35 76.13,57.41 76.13,57.43 76.11,57.47 76.06,57.5 75.97,57.56 75.92,57.58 75.84,57.61 75.59,57.61 75.5,57.57 75.29,57.57 75.18,57.62 74.96,57.62 74.85,57.57 74.59,57.57 74.42,57.74 73.91,57.74 73.69,57.52 72.65,57.52 72.47,57.71 70.2,57.71 69.95,57.46 69.95,57.3 v2(69.75,57.1)
  BOTTOM w0.102: v2(55.03,50.32) 55.23,50.12 55.23,49.95 55.47,49.71 JDIM2000.179
M_A_DQS5: length 34.2
  IN1 w0.089: v2(68.8,53.56) 69.04,53.79 69.04,53.93 68.96,54 66.92,54 65.03,52.12 64.03,52.12 62.8,50.89 62.8,50.29 60.35,47.84 60.35,47.42 57.34,44.42 55.1,44.42 53.91,43.23 52.75,43.23 52.51,43.46 52.51,43.67 v2(52.22,43.96)
  BOTTOM w0.076: v2(68.8,53.56) 68.9,53.56 69.06,53.72 69.06,54.22 69.23,54.4 74.3,54.4 74.5,54.6 74.85,54.6 75.02,54.53 75.14,54.53 75.3,54.61 75.48,54.61 75.62,54.55 75.83,54.55 75.92,54.59 75.99,54.66 75.99,54.75 75.93,54.82 75.72,54.82 U2030.BA34
  BOTTOM w0.102: v2(52.22,43.96) 52.51,44.25 52.51,44.5 52.38,44.63 51.4,44.63 51.23,44.45 JDIM2000.200
M_A_DQS6: length 35.2
  IN1 w0.089: v2(56.5,38.93) 56.29,38.93 56.18,38.82 56.18,38.54 56.29,38.42 58.89,38.42 63.03,42.56 63.74,42.56 65.95,44.77 65.95,44.9 65.11,45.74 65.11,46.03 65.46,46.38 65.74,46.38 66.23,45.89 66.36,45.89 66.5,46.02 66.5,48.98 67.4,49.88 67.4,50.3 67.99,50.89 68.67,50.89 68.87,51.09 70.26,51.09 70.49,51.33 70.49,51.46 v2(70.26,51.69)
  BOTTOM w0.076: U2030.AY30 76.37,52.29 76.3,52.29 arc(76.23,52.3) 76.18,52.34 76.18,52.34 arc(76.16,52.36) 76.16,52.39 arc(76.15,52.41) 76.14,52.43 76.09,52.48 arc(76.06,52.51) 76.04,52.53 75.97,52.58 75.95,52.59 75.84,52.62 75.84,52.63 75.79,52.63 arc(75.74,52.64) 75.69,52.63 75.61,52.62 arc(75.6,52.62) 75.58,52.62 arc(75.57,52.61) 75.56,52.61 75.5,52.59 arc(75.48,52.59) 75.46,52.59 75.37,52.59 arc(75.37,52.59) 75.37,52.59 75.33,52.59 arc(75.29,52.59) 75.25,52.6 arc(75.15,52.63) 75.05,52.64 75.01,52.64 arc(74.96,52.63) 74.92,52.62 74.88,52.6 arc(74.85,52.59) 74.82,52.59 74.24,52.59 74.21,52.62 73.44,52.62 73.26,52.43 71.53,52.43 71.41,52.31 71.39,52.31
  BOTTOM w0.102: 71.39,52.31 71.25,52.31 71.25,52.32 70.74,52.32 70.52,52.1 70.52,51.79 70.42,51.69 v2(70.26,51.69) ; v2(56.5,38.93) 56.27,38.93 56.12,39.07 56.12,39.34 56.22,39.44 57.24,39.44 57.48,39.2 JDIM2000.221
M_A_DQS7: length 40.5
  IN1 w0.089: v2(52.22,33.48) 52.58,33.84 52.58,34.05 52.78,34.25 53.5,34.25 53.59,34.34 53.59,34.75 53.8,34.96 54.26,34.96 54.46,34.76 54.46,34.09 54.57,33.99 54.83,33.99 54.96,34.11 54.96,34.5 55.16,34.71 55.63,34.71 55.83,34.5 55.83,34.16 55.92,34.07 61.89,34.07 64.38,36.56 65.01,36.56 67.04,38.6 67.04,39.05 70.54,42.55 70.54,45.99 70.72,46.16 70.72,48 v2(70.46,48.26)
  BOTTOM w0.076: 73.17,49.34 73.18,49.36 73.19,49.35 73.23,49.39 73.37,49.39 73.38,49.39 74.29,49.39 74.51,49.61 74.86,49.61 75.02,49.55 75.13,49.55 75.28,49.61 75.52,49.61 75.62,49.57 75.83,49.57 75.89,49.59 75.97,49.65 75.99,49.69 75.99,49.77 75.93,49.83 75.72,49.83 U2030.BA26
  BOTTOM w0.102: JDIM2000.242 51.16,33.95 51.33,34.13 52.35,34.13 52.53,33.95 52.53,33.79 v2(52.22,33.48) ; 73.17,49.34 72.78,48.96 70.84,48.96 70.66,48.78 70.66,48.46 v2(70.46,48.26)
M_A_DQS8: length 4.1
  TOP w0.102: v2(55.79,71.08) 55.79,70.76 R2177.2
  BOTTOM w0.102: JDIM2000.97 56.91,72.2 v2(55.79,71.08)
M_A_DQS#0: length 51.3
  IN1 w0.089: v2(56.23,94.66) 56.04,94.66 55.92,94.78 55.92,95.22 56.02,95.31 58.2,95.31 59.91,93.6 67.3,93.6 68.1,92.79 73.15,92.79 74.94,91 74.94,86.46 75.49,85.92 75.77,85.92 76.22,86.37 76.4,86.37 76.59,86.18 76.59,85.97 76.17,85.55 76.17,85.23 76.49,84.91 76.85,84.91 77.27,85.33 77.47,85.33 77.66,85.14 77.66,84.95 77.21,84.5 77.21,84.19 77.56,83.84 77.87,83.84 78.34,84.31 78.53,84.31 78.73,84.12 78.73,83.93 78.26,83.46 78.26,83.15 78.73,82.67 80.38,82.67 80.52,82.54 v2(80.52,82.4)
  BOTTOM w0.076: U2030.AM70 80.7,75.13 80.7,75.03 80.74,74.99 80.82,74.99 81.05,74.99 81.11,75.06 81.15,75.18 81.18,75.27 81.18,75.41 81.17,75.45 81.15,75.5 81.14,75.59 81.13,75.67 81.13,75.8 81.15,75.83 81.2,75.94 81.2,76.02 81.13,76.19 81.13,76.77 81.19,76.82 81.19,78.02 81.17,78.04 81.17,78.06
  BOTTOM w0.102: 81.15,81.94 81.17,81.93 81.17,78.06
  BOTTOM w0.114: 81.15,81.94 81.15,82.45 80.98,82.63 80.61,82.63 80.52,82.54 v2(80.52,82.4) ; JDIM2000.11 57.53,93.7 57.25,93.42 56.37,93.42 55.86,93.93 55.86,94.52 56,94.66 v2(56.23,94.66)
M_A_DQS#1: length 40
  IN1 w0.089: v2(78.28,78.21) 78.06,77.99 77.56,77.99 77.46,78.09 77.46,78.83 76.62,79.67 75.7,79.67 75.44,79.4 74.12,79.4 70.66,82.87 69.38,82.87 62.66,89.58 58.69,89.58 58.61,89.67 58.61,90.12 58.41,90.32 53.48,90.32 53.21,90.05 53.21,89.79 v2(52.95,89.53)
  BOTTOM w0.076: v2(78.28,78.21) 78.06,77.99 77.94,77.99 77.72,77.77 77.72,77.19 78.04,76.87 78.04,76.61 78.17,76.48 78.17,76.25 78.12,76.12 78.12,75.87 78.13,75.84 78.15,75.78 78.16,75.69 78.16,75.63 78.15,75.56 78.1,75.42 78.1,75.31 78.1,75.22 78.13,75.16 78.14,75.16 78.18,75.04 78.22,74.98 78.3,74.87 78.3,74.86 78.38,74.79 U2030.AT69
  BOTTOM w0.102: v2(52.95,89.53) 53.19,89.3 53.19,88.88 52.76,88.45 JDIM2000.32
M_A_DQS#2: length 34
  IN1 w0.089: v2(69.42,77.71) 69.58,77.71 69.7,77.83 69.7,78.44 69.54,78.6 69.15,78.6 69.05,78.5 69.05,78.32 68.85,78.12 68.42,78.12 62.23,84.31 57.53,84.31 57.02,84.82 55.77,84.82 55.67,84.72 55.67,84.4 55.75,84.31 v2(56.06,84.31)
  BOTTOM w0.076: v2(69.42,77.71) 69.61,77.71 69.69,77.63 69.69,77.1 70.23,76.56 71.49,76.56 71.99,76.05 71.99,75.26 72.49,74.77 72.49,73.64 74,72.13 74.88,72.13 75.02,72.18 75.13,72.18 75.25,72.13 75.53,72.13 75.61,72.16 75.83,72.16 75.96,72.1 76.04,72.02 76.04,71.94 75.99,71.89 U2030.BA64
  BOTTOM w0.114: v2(56.06,84.31) 55.83,84.31 55.68,84.16 55.68,83.3 55.95,83.03 57.42,83.03 57.6,83.21 JDIM2000.53
M_A_DQS#3: length 32.6
  IN1 w0.089: v2(70.29,72.21) 70.52,72.45 70.52,72.57 70.52,72.8 69.63,73.69 67.38,73.69 62.75,78.31 54.35,78.31 53.97,77.93 52.68,77.93 52.47,78.13 52.47,78.33 v2(52.22,78.58)
  BOTTOM w0.076: U2030.AY60 76.37,69.44 76.22,69.44 76.14,69.36 76.14,69.28 76.05,69.2 75.87,69.11 75.58,69.11 75.5,69.14 75.29,69.14 75.18,69.09 74.96,69.09 74.85,69.14 74.59,69.14 74.47,69.02 73.92,69.02 71.96,70.98 71.14,70.98 70.57,71.55 70.57,71.93 v2(70.29,72.21)
  BOTTOM w0.102: v2(52.22,78.58) 52.43,78.37 52.43,78.16 52.1,77.83 51.26,77.83 51.13,77.95 JDIM2000.74
M_A_DQS#4: length 30.1
  IN1 w0.089: v2(55.81,50.32) 55.46,50.67 55.46,50.84 55.71,51.09 57.33,51.09 58.54,52.3 58.54,53.76 59.86,55.08 61.2,55.08 62.35,56.22 67.59,56.22 67.79,56.42 69.92,56.42 70.16,56.67 70.16,56.87 v2(70.38,57.1)
  BOTTOM w0.076: v2(70.38,57.1) 70.26,57.1 70.12,57.24 70.12,57.39 70.27,57.54 72.4,57.54 72.59,57.36 73.76,57.36 73.98,57.58 74.35,57.58 74.52,57.4 74.88,57.4 75.02,57.46 75.13,57.46 75.26,57.4 75.53,57.4 75.63,57.44 75.81,57.44 75.83,57.44 75.89,57.41 75.97,57.36 76,57.3 76,57.21 75.95,57.17 U2030.BA38
  BOTTOM w0.102: v2(55.81,50.32) 55.53,50.32 55.43,50.22 55.43,50.05 55.57,49.91 57.22,49.91 57.37,50.05 57.37,50.14 57.43,50.2 JDIM2000.177
M_A_DQS#5: length 34.2
  IN1 w0.089: v2(69.44,53.57) 69.23,53.79 69.23,54.01 69.04,54.19 66.84,54.19 64.95,52.31 63.95,52.31 62.61,50.97 62.61,50.37 60.16,47.92 60.16,47.5 57.26,44.61 55.02,44.61 53.83,43.42 52.83,43.42 52.7,43.54 52.7,43.67 v2(53,43.96)
  BOTTOM w0.076: U2030.AY34 76.25,54.72 76.16,54.63 76.16,54.59 76.01,54.45 75.86,54.38 75.58,54.38 75.45,54.44 75.34,54.44 75.18,54.37 74.99,54.37 74.82,54.43 74.57,54.43 74.37,54.23 69.32,54.23 69.22,54.13 69.22,53.79 v2(69.44,53.57)
  BOTTOM w0.102: JDIM2000.198 51.15,44.95 51.27,44.83 52.47,44.83 52.72,44.58 52.72,44.24 v2(53,43.96)
M_A_DQS#6: length 35.2
  IN1 w0.089: v2(55.72,38.93) 55.99,38.66 55.99,38.46 56.21,38.23 58.97,38.23 63.11,42.37 63.82,42.37 66.14,44.69 66.14,44.98 65.3,45.82 65.3,45.95 65.54,46.19 65.66,46.19 66.15,45.7 66.44,45.7 66.69,45.94 66.69,48.9 67.59,49.81 67.59,50.22 68.07,50.7 68.75,50.7 68.95,50.9 70.34,50.9 70.68,51.25 70.68,51.46 v2(70.91,51.69)
  BOTTOM w0.076: 71.45,52.11 71.6,52.27 73.33,52.27 73.51,52.45 74.14,52.45 74.17,52.42 74.82,52.42 arc(74.89,52.43) 74.95,52.45 74.99,52.47 arc(75,52.47) 75.01,52.47 75.05,52.47 arc(75.12,52.47) 75.19,52.45 arc(75.25,52.43) 75.31,52.42 arc(75.31,52.42) 75.31,52.42 75.46,52.42 arc(75.5,52.42) 75.54,52.43 75.61,52.45 arc(75.61,52.45) 75.62,52.45 arc(75.63,52.46) 75.63,52.46 75.72,52.47 arc(75.75,52.47) 75.77,52.47 75.78,52.47 75.89,52.43 75.94,52.39 arc(75.96,52.38) 75.97,52.37 75.99,52.35 75.99,52.25 75.93,52.19 75.72,52.19 U2030.BA30
  BOTTOM w0.102: JDIM2000.219 57.45,39.71 57.39,39.65 56.14,39.65 55.92,39.43 55.92,39.13 v2(55.72,38.93) ; 71.45,52.11 70.82,52.11 70.72,52.02 70.72,51.88 v2(70.91,51.69)
M_A_DQS#7: length 40.5
  IN1 w0.089: v2(71.09,48.23) 70.91,48.05 70.91,46.08 70.73,45.91 70.73,42.47 67.23,38.97 67.23,38.52 65.09,36.37 64.46,36.37 61.97,33.88 55.84,33.88 55.64,34.08 55.64,34.43 55.55,34.51 55.24,34.51 55.15,34.43 55.15,34.03 54.91,33.8 54.49,33.8 54.27,34.01 54.27,34.68 54.18,34.77 53.88,34.77 53.78,34.67 53.78,34.26 53.58,34.06 52.86,34.06 52.77,33.97 52.77,33.71 v2(52.99,33.48)
  BOTTOM w0.076: U2030.AY26 76.19,49.55 76.14,49.55 75.97,49.45 75.86,49.4 75.59,49.4 75.49,49.45 75.31,49.45 75.16,49.38 74.99,49.38 74.83,49.44 74.58,49.44 74.36,49.22 73.31,49.22 73.3,49.21
  BOTTOM w0.102: 73.3,49.21 72.86,48.77 71.58,48.77 71.56,48.76 70.92,48.76 70.86,48.7 70.86,48.47 v2(71.09,48.23) ; JDIM2000.240 51.18,34.45 51.3,34.33 52.43,34.33 52.73,34.03 52.73,33.75 v2(52.99,33.48)
M_A_DQS#8: length 2.6
  TOP w0.102: R2173.2 56.97,73.06 v2(57.01,73.01)
  BOTTOM w0.102: JDIM2000.95 57.32,72.7 v2(57.01,73.01)
M_A_EVENT#: length 2.4
  TOP w0.102: R2187.2 52.21,63.54 v2(51.62,62.95)
  BOTTOM w0.102: v2(51.62,62.95) JDIM2000.134
M_A_ODT0_DIMM: length 40.9
  IN1 w0.14: v2(78.83,60.75) 78.41,60.33 77.43,60.33 75.95,58.85 75.95,57.79 76.09,57.65 76.31,57.65 76.45,57.51 76.45,57.23 76.31,57.09 76.09,57.09 75.95,56.95 75.95,55.08 75.47,54.6 75.47,52.39 75.31,52.23 75.02,52.23 74.87,52.37 74.87,54.53 73.19,56.21 73.19,57.26 72.36,58.09 68.92,58.09 68.51,58.5 67.55,58.5 66.84,59.21 61.18,59.21 60.96,58.99 59.63,58.99 56.81,56.17 56.14,56.17 v2(55.71,55.74)
  BOTTOM w0.165: U2030.AT45 78.51,61.16 v2(78.83,60.75) ; v2(55.71,55.74) 55.71,55.43 55.88,55.26 57.14,55.26 57.58,55.7 JDIM2000.155
M_A_ODT1_DIMM: length 42.5
  IN1 w0.14: v2(55.56,54.4) 55.67,54.4 59.84,58.57 60.03,58.57 60.16,58.44 60.16,58.24 60.3,58.1 60.48,58.1 60.62,58.24 60.62,58.47 60.72,58.57 61.17,58.57 61.36,58.76 66.75,58.76 67.47,58.04 68.54,58.04 68.77,57.81 72.17,57.81 72.65,57.34 72.65,56.14 74.38,54.4 74.38,51.1 74.52,50.96 74.76,50.96 74.92,51.13 74.92,51.6 75.06,51.74 75.78,51.74 75.92,51.88 75.92,54.42 76.12,54.62 76.7,54.62 77.02,54.94 77.02,59.27 77.16,59.41 77.76,59.41 v2(78.18,59.84)
  BOTTOM w0.165: JDIM2000.161 57.21,54.2 57.02,54.4 v2(55.56,54.4) ; v2(78.18,59.84) 78.18,59.99 78.49,60.29 U2030.AT43
M_A_PARITY: length 43.5
  TOP w0.165: v2(56.28,61.38) 57.82,61.38 58.26,61.82 58.26,62.87 58.6,63.22 62.63,63.22 63.68,64.26 67.32,64.26 67.47,64.11 67.47,63.73 67.64,63.56 67.88,63.56 68.1,63.78 68.1,64.46 68.29,64.65 68.54,64.65 68.72,64.48 68.72,64.01 68.88,63.84 69.2,63.84 69.33,63.97 69.33,64.35 69.56,64.58 72.68,64.58 72.85,64.74 72.85,65.29 73.73,66.18 74.48,66.18 74.71,66.41 74.71,67.19 75.17,67.65 75.17,69.73 75.32,69.89 75.65,69.89 75.8,69.73 75.8,67.55 75.96,67.4 76.24,67.4 76.44,67.6 76.44,69.74 76.59,69.9 76.92,69.9 77.07,69.74 77.07,64.86 77.27,64.67 77.71,64.67 78.19,65.15 v2(78.19,65.33)
  BOTTOM w0.127: U2030.AT52 78.5,64.88 78.39,65.04 v2(78.19,65.33)
  BOTTOM w0.165: JDIM2000.143 56.96,60.7 v2(56.28,61.38)
M_A_RAS#: length 41.2
  IN1 w0.14: v2(77.54,63.58) 76.6,62.63 76.26,62.63 74.79,61.16 68.39,61.16 64.99,64.57 59.55,64.57 57.24,62.26 56.48,62.26 56.14,61.93 55.96,61.93 55.82,62.06 55.63,62.06 55.43,61.86 55.43,61.67 55.56,61.53 55.56,61.35 55.32,61.1 55.14,61.1 54.98,61.27 54.8,61.27 54.63,61.11 54.63,60.91 54.89,60.65 54.89,60.45 54.71,60.27 54.51,60.27 54.23,60.54 54.09,60.54 53.87,60.33 53.87,60.14 54.3,59.72 54.3,59.54 54.12,59.36 53.92,59.36 53.54,59.74 53.34,59.74 53.17,59.57 53.17,59.37 53.54,59.01 53.54,58.81 53.31,58.59 53.11,58.59 52.77,58.93 52.57,58.93 52.33,58.68 52.33,58.49 53.4,57.42 53.4,56.88 53.05,56.53 51.75,56.53 51.57,56.35 v2(51.57,56.02)
  BOTTOM w0.165: JDIM2000.152 51.47,56.46 51.57,56.35 v2(51.57,56.02) ; v2(77.54,63.58) 77.54,63.62 77.71,63.8 U2030.AU50
M_A_WE#: length 42.5
  IN1 w0.079: 76.92,61.32 77.75,61.32 v2(78.14,61.71)
  IN1 w0.14: 76.92,61.32 76.8,61.32 75.58,60.1 73.98,60.1 73.54,59.67 68.24,59.67 67.18,60.72 63.59,60.72 63.16,61.15 63.16,63.15 63.05,63.26 62.77,63.26 62.65,63.14 62.65,61.9 62.5,61.75 62.29,61.75 62.11,61.92 62.11,63.13 61.98,63.26 61.76,63.26 61.61,63.11 61.61,61.91 61.45,61.75 61.24,61.75 61.06,61.93 61.06,63.08 60.94,63.21 60.74,63.21 60.59,63.06 60.59,61.92 60.41,61.75 60.21,61.75 60.07,61.89 60.07,62.69 59.93,62.83 59.73,62.83 59.58,62.68 59.58,62.22 59.44,62.08 58.95,62.08 54.89,58.02 v2(54.89,57.09)
  BOTTOM w0.165: U2030.AT46 78.48,62.12 78.14,61.78 v2(78.14,61.71) ; JDIM2000.151 57.58,56.7 57.15,56.27 55.03,56.27 54.89,56.41 v2(54.89,57.09)
M_B1_ZQ0: length 4.7
  TOP w0.102: U2012.F9 42.46,38.09 42.46,35.34 v1(42.84,34.96) 43.14,34.66 R2223.1
M_B2_ZQ0: length 3.6
  TOP w0.102: U2011.F9 42.48,51.28 42.48,48.44 R2191.1
M_B3_ZQ0: length 4.6
  TOP w0.102: R2159.1 42.89,69 42.89,70.73 42.27,71.35 U2010.F9
M_B4_ZQ0: length 8.9
  TOP w0.102: R2138.1 49.68,84.49 43.43,84.49 42.62,85.31 42.62,85.81 U2009.F9
M_B_A0: length 172.1
  TOP w0.102: U2011.P3 35.87,56.66 35.8,56.73 35.65,56.73 35.45,56.53 v2(35.45,55.83) ; v2(35.8,94.8) 35.8,94.11 35.36,93.66 35.36,92.99 35.47,92.88 35.47,92.32 35.65,92.14 36.07,92.14 36.26,91.94 36.26,91.36 35.87,90.97 U2009.P3 ; U2010.P3 36.05,77.51 36.05,77.28 35.22,76.44 v2(35.02,76.44) ; v2(35.59,42.61) 35.87,42.89 U2012.P3
  TOP w0.165: v1(34.5,100.75) 34.73,100.98 R2088.2
  IN1 w0.089: v2(35.8,94.8) 36.41,93.32 36.41,90.95 35.73,90.27 35.73,88.78 35.09,87.81 35.09,85.31 34.76,84.98 34.76,79.38 35.07,79.08 35.07,78.63 35.02,78.58 v2(35.02,76.44) 34.71,76.14 34.71,70.35 35.93,69.13 35.93,67.32 35.83,67.21 35.48,67.21 35.4,67.13 35.4,66.93 35.52,66.81 35.83,66.81 35.93,66.71 35.93,66.3 35.8,66.17 35.8,59.46 36.07,59.2 36.07,57.39 35.45,56.76 v2(35.45,55.83) 35.71,56.09 35.84,56.09 35.9,56.03 35.9,55.66 35.69,55.45 35.33,55.45 35.27,55.39 35.27,50.13 35.36,50.04 35.56,50.04 35.65,49.95 35.65,49.8 35.59,49.74 35.36,49.74 35.27,49.65 35.27,49.13 35.49,48.92 35.86,48.92 35.94,48.83 35.94,47.32 35.85,47.23 35.73,47.23 35.64,47.14 35.64,47.01 35.73,46.92 35.89,46.92 35.99,46.83 35.99,46.7 35.9,46.62 35.73,46.62 35.64,46.53 35.64,46.4 35.73,46.31 35.89,46.31 35.97,46.23 35.97,45.96 35.86,45.86 35.54,45.86 35.45,45.77 35.45,45.64 35.54,45.55 35.85,45.55 35.96,45.44 35.96,43.7 35.84,43.58 35.39,43.58 35.3,43.5 35.3,43.26 35.37,43.19 36.11,43.19 36.23,43.07 36.23,42.25 36.12,42.14 35.99,42.14 35.89,42.25 35.89,42.54 35.83,42.61 v2(35.59,42.61)
  IN3 w0.089: v2(73.03,60.74) 73.03,60.95 72.91,61.07 68.94,61.07
  IN3 w0.102: v1(34.5,100.75) 34.38,100.62 34.38,97.34 35.67,96.05 35.67,94.94 v2(35.8,94.8)
  IN3 w0.14: v2(35.59,42.61) 35.06,42.61 34.94,42.48 34.94,41.96 34.81,41.84 34.59,41.84 34.45,41.97 34.45,42.96 34.61,43.12 35.65,43.12 35.75,43.22 35.75,43.69 35.62,43.83 35.39,43.83 35.16,43.6 34.36,43.6 34.18,43.78 34.18,43.92 34.3,44.04 34.95,44.04 35.07,44.16 35.07,44.34 34.95,44.46 34.3,44.46 34.18,44.58 34.18,44.76 34.3,44.88 34.95,44.88 35.07,45 35.07,45.18 34.95,45.3 33.85,45.3 33.68,45.47 33.68,45.62 33.82,45.76 34.15,45.76 34.26,45.87 34.26,46.06 34.14,46.18 32.97,46.18 32.85,46.3 32.85,46.48 32.97,46.6 34.14,46.6 34.26,46.72 34.26,46.94 34.17,47.03 32.71,47.03 32.56,47.18 32.56,47.33 32.69,47.46 33.87,47.46 34.02,47.61 34.02,47.74 33.87,47.89 32.69,47.89 32.56,48.02 32.56,48.21 32.68,48.32 33.77,48.32 33.87,48.42 33.87,48.59 33.7,48.76 32.69,48.76 32.56,48.9 32.56,49.07 32.68,49.19 33.31,49.19 33.44,49.31 33.44,49.52 33.33,49.62 32.71,49.62 32.56,49.77 32.56,49.93 32.68,50.05 33.36,50.05 33.44,50.13 33.44,50.34 33.33,50.45 32.69,50.45 32.56,50.58 32.56,50.77 32.68,50.9 32.93,50.9 33.09,51.07 33.09,51.41 32.84,51.66 32.84,52.27 33.42,52.84 33.42,54.99 33.61,55.18 34.66,55.18 34.76,55.28 34.76,55.51 34.66,55.61 33.55,55.61 33.42,55.74 33.42,55.92 33.55,56.04 34.65,56.04 34.75,56.15 34.75,56.35 34.66,56.45 33.33,56.45 33.2,56.58 33.2,56.76 33.34,56.89 34.16,56.89 34.3,57.03 34.3,57.69 34.41,57.8 34.63,57.8 34.75,57.68 34.75,57.14 35.08,56.81 35.78,56.81 36.3,57.32 36.3,58.6 36.02,58.88 36.02,59.06 36.14,59.18 36.31,59.18 36.44,59.05 36.61,59.05 36.74,59.18 36.74,59.35 36.61,59.48 36.61,59.65 36.73,59.77 36.9,59.77 37.03,59.65 37.21,59.65 37.33,59.77 37.33,59.94 37.2,60.07 37.2,60.24 37.32,60.37 37.5,60.37 37.63,60.24 37.8,60.24 37.92,60.36 37.92,60.53 37.79,60.66 37.79,60.84 37.92,60.96 38.09,60.96 38.22,60.83 38.39,60.83 38.52,60.96 38.52,61.15 38.39,61.28 38.39,61.43 38.54,61.58 38.67,61.58 38.82,61.43 38.99,61.43 40.81,63.25 50.35,63.25 51.34,62.26 51.57,62.26 51.67,62.16 51.67,61.78 51.8,61.66 52.08,61.66 52.18,61.76 52.18,61.9 52.36,62.08 54.42,62.08 55.14,62.81 55.58,62.81 56.01,62.37 62.79,62.37 63.12,62.05 63.4,61.77 66.21,61.77 66.23,61.74 68.27,61.74 68.94,61.07
  BOTTOM w0.076: U2030.BA46 75.4,61.46 75.22,61.46 74.95,61.2 73.09,61.2 73.03,61.13 v2(73.03,60.74)
M_B_A1: length 184.6
  TOP w0.102: v2(34.54,89.23) 34.66,89.23 35.87,88.02 U2009.P7 ; U2010.P7 35.61,74.5 34.89,75.22 33.58,75.22 33.19,74.83 32.33,74.83 31.9,74.4 v2(31.35,74.4) ; U2011.P7 35.87,53.71 34.94,54.65 33.98,54.65 33.49,54.16 33.34,54.16 33.26,54.25 33.09,54.25 32.96,54.12 32.96,54 33.07,53.89 33.07,53.74 32.88,53.55 v2(31.87,53.55) ; v2(32.19,40.2) 32.82,40.2 33.17,40.56 34.99,40.56 35.42,40.12 35.63,40.12 U2012.P7
  TOP w0.165: v2(31.19,92.11) 30.81,91.73 R2118.2
  IN1 w0.089: v2(34.54,89.23) 34.78,89.23 34.97,89.42 34.97,89.64 34.87,89.74 34.03,89.74 33.72,90.05 32.7,90.05 32.27,89.62 32.27,87.87 31.83,87.44 31.83,83.07 31.93,82.97 32.06,82.97 32.13,82.9 32.13,82.7 32.05,82.62 31.89,82.62 31.82,82.54 31.82,82.23 31.89,82.15 32.45,82.15 32.51,82.08 32.51,81.81 32.43,81.73 31.93,81.73 31.86,81.65 31.86,81.2 31.73,81.07 31.51,81.07 31.41,80.97 31.41,80.8 31.49,80.72 31.58,80.72 31.64,80.65 31.64,80.46 31.57,80.39 31.49,80.39 31.4,80.31 31.4,80.15 31.47,80.09 31.55,80.09 31.65,79.99 31.65,79.69 31.57,79.61 31.14,79.61 30.92,79.39 30.92,76.48 31.33,76.08 31.33,75.9 31.4,75.83 31.54,75.83 31.6,75.77 31.6,75.55 31.54,75.48 31.21,75.48 31.13,75.4 31.13,74.48 31.22,74.4 v2(31.35,74.4) 31.51,74.25 31.51,71.34 31.62,71.22 31.74,71.22 31.84,71.12 31.84,70.92 31.75,70.83 31.61,70.83 31.52,70.74 31.52,70.56 31.62,70.46 31.78,70.46 31.86,70.38 31.86,68.86 31.51,68.51 31.51,68.31 31.29,68.1 31.29,57.61 32.18,56.72 32.18,56.39 32.04,56.25 32.04,56.03 31.94,55.93 31.75,55.93 31.64,55.82 31.64,55.64 31.75,55.52 31.93,55.52 32.04,55.42 32.04,55.22 31.93,55.12 31.7,55.12 31.65,55.07 31.65,54.95 31.91,54.68 31.91,54.52 31.7,54.31 31.7,53.72 v2(31.87,53.55) 32.33,53.55 32.47,53.41 32.47,51.48 32.31,51.32 32.31,49.91 32.69,49.52 32.69,42.45 32.47,42.23 32.47,42.1 32.61,41.96 32.74,41.96 32.9,42.12 32.98,42.12 33.23,41.87 33.23,41.67 33.14,41.58 32.74,41.58 32.66,41.5 32.66,41.27 32.73,41.2 33.2,41.2 33.29,41.11 33.29,39.69 33.18,39.58 33.04,39.58 32.95,39.67 32.95,40.78 32.85,40.88 32.7,40.88 32.6,40.78 32.6,40.05 32.54,39.99 32.4,39.99 v2(32.19,40.2)
  IN3 w0.102: v2(31.19,92.11) 31.31,91.98 31.31,90.86 32.02,90.16 32.02,88.81 32.83,87.99 33.92,87.99 34.54,88.61 v2(34.54,89.23) ; 32.4,40.95 32.43,40.98
  IN3 w0.14: v2(70.59,63.11) 70,63.11 69.56,63.55 69.56,63.83 68.55,64.84 67.49,64.84 65.21,67.12 58.99,67.12 58.24,67.86 49.93,67.86 49.92,67.88 44.39,67.88 44.26,67.75 44.26,66.85 44.14,66.72 43.97,66.72 43.84,66.85 43.84,67.75 43.72,67.88 43.55,67.88 43.43,67.75 43.43,66.42 43.3,66.3 43.13,66.3 43.01,66.42 43.01,67.75 42.88,67.88 42.64,67.88 42.52,67.75 42.52,66.42 42.4,66.3 42.22,66.3 42.1,66.42 42.1,67.75 41.98,67.88 41.8,67.88 41.68,67.75 41.68,66.42 41.56,66.3 41.39,66.3 41.26,66.42 41.26,67.75 41.14,67.88 40.97,67.88 40.84,67.75 40.84,66.42 40.72,66.3 40.51,66.3 40.4,66.41 40.4,66.64 40.27,66.76 40.09,66.76 39.97,66.64 39.97,66.46 39.8,66.3 39.5,66.3 38.23,65.03 37.23,65.03 35.7,63.5 35.7,63.24 34.99,62.53 33.24,62.53 28.43,57.71 28.43,53.46 29.33,52.56 29.33,50.32 29.54,50.1 29.54,45.26 30.32,44.48 30.32,43.76 31.15,42.92 31.15,42.18 31.28,42.05 31.28,41.26 31.42,41.11 31.61,41.11 31.66,41.06 31.81,41.06 32.18,41.44 32.33,41.44 32.43,41.34 32.43,40.98 ; 32.4,40.95 31.98,40.53 31.98,40.27 32.05,40.2 v2(32.19,40.2)
  BOTTOM w0.076: U2030.AY46 75.79,61.56 75.69,61.66 75.47,61.74 75.34,61.74 75.11,61.67 74.97,61.67 74.85,61.73 74.75,61.74 74.42,61.73 74.23,61.55 73.42,61.55 73.33,61.63
  BOTTOM w0.102: 73.33,61.63 68.48,61.63 68.38,61.73 68.38,63.01 68.48,63.11 v2(70.59,63.11)
M_B_A2: length 188.2
  TOP w0.102: v2(33.57,91.17) 33.72,91.32 34.71,91.32 U2009.R3 ; U2010.R3 34.32,76.95 33.74,76.95 33.54,77.15 32.91,77.15 32.19,76.44 29.96,76.44 29.78,76.26 v2(29.78,75.92) ; v2(31.68,41.51) 34.22,41.51 34.33,41.61 34.33,41.82 34.43,41.92 34.61,41.92 34.68,41.85 34.68,41.62 34.79,41.51 34.98,41.51 35.07,41.6 U2012.R3 ; v2(30.51,56.36) 31.11,56.36 31.26,56.22 31.26,55.51 31.36,55.41 31.56,55.41 31.67,55.51 31.67,55.89 31.77,55.99 31.97,55.99 32.39,55.58 33.11,55.58 33.37,55.84 34.62,55.84 U2011.R3
  TOP w0.165: v1(31.74,98.28) 31.86,98.41 31.92,98.41 R2102.2
  IN1 w0.089: v2(33.57,91.17) 33.4,91.17 33.33,91.24 33.33,91.69 33.42,91.77 33.65,91.77 33.74,91.86 33.74,91.99 33.65,92.08 33.42,92.08 33.32,92.17 33.32,93.61 33.23,93.71 33.09,93.71 33,93.63 33,91.98 32.47,91.46 32.47,90.84 32.19,90.55 32.04,90.55 31.93,90.67 31.83,90.67 31.7,90.54 31.7,90.41 31.81,90.3 31.81,90.17 31.51,89.88 31.51,89.21 30.25,87.94 30.25,85.01 29.78,84.54 29.78,83.26 29.97,83.07 30.24,83.07 30.57,82.74 30.67,82.74 30.86,82.55 30.86,82.29 30.69,82.12 29.92,82.12 29.78,81.98 v2(29.78,75.92) 29.51,75.92 29.34,75.75 29.34,74.92 29.66,74.6 29.66,68.58 30.16,68.09 30.16,59.68 30.05,59.58 29.58,59.58 29.48,59.48 29.48,59.28 29.58,59.18 30.13,59.18 30.23,59.07 30.23,58.87 30.13,58.77 29.58,58.77 29.48,58.67 29.48,58.46 29.58,58.36 30.05,58.36 30.16,58.26 30.16,56.72 v2(30.51,56.36) 29.98,55.83 29.98,54.93 30.22,54.7 30.55,54.7 30.64,54.61 30.64,54.22 30.57,54.14 30.26,54.14 30.17,54.05 30.17,51.55 30.06,51.44 30.06,48.09 31.41,46.74 31.41,43.42 31.22,43.23 30.53,43.23 30.41,43.12 30.41,42.95 30.5,42.86 30.95,42.86 31.02,42.79 31.02,42.58 30.95,42.51 30.31,42.51 30.24,42.43 30.24,42.24 30.31,42.16 31.02,42.16 v2(31.68,41.51)
  IN3 w0.089: 69.88,62.86 70.01,62.73 70.81,62.73 70.99,62.91 70.99,63.56 v2(70.81,63.73)
  IN3 w0.102: v1(31.74,98.28) 31.84,98.18 31.84,96.32 31.96,96.2 31.96,95.3 32.63,94.64 32.63,92.11 v2(33.57,91.17)
  IN3 w0.14: 69.88,62.86 69.19,63.55 69.19,63.78 68.43,64.55 67.37,64.55 65.09,66.83 58.86,66.83 58.12,67.57 49.61,67.57 49.49,67.45 49.49,67.07 49.37,66.95 47.04,66.95 46.95,67.04 46.95,67.45 46.85,67.55 45.58,67.55 45.4,67.38 45.4,66.25 45.26,66.1 45.08,66.1 44.98,66.2 44.98,67.47 44.87,67.58 44.67,67.58 44.56,67.46 44.56,66.73 44.55,66.72 44.55,66.14 44.42,66 44.26,66 44.14,66.13 44.14,66.31 44.01,66.43 43.84,66.43 43.72,66.31 43.72,66.13 43.6,66 39.62,66 38.35,64.74 37.35,64.74 37.23,64.61 37.23,64.24 37.12,64.14 36.76,64.14 36.58,63.97 36.58,63.62 36.48,63.51 36.13,63.51 35.99,63.38 35.99,63.36 35.99,63.12 35.11,62.23 33.36,62.23 32.95,61.82 32.95,61.55 33.29,61.21 33.29,61 33.16,60.87 32.99,60.87 32.58,61.28 32.41,61.28 32.29,61.15 32.29,60.98 32.69,60.58 32.69,60.4 32.57,60.28 32.39,60.28 31.99,60.68 31.82,60.68 31.69,60.56 31.69,60.39 32.1,59.98 32.1,59.81 31.98,59.69 31.8,59.69 31.4,60.09 31.22,60.09 31.1,59.97 31.1,59.8 31.5,59.39 31.5,59.22 31.38,59.09 31.21,59.09 30.8,59.5 30.63,59.5 30.51,59.38 30.51,59.2 30.91,58.8 30.91,58.62 30.79,58.5 30.62,58.5 30.21,58.91 30.04,58.91 29.91,58.78 29.91,58.61 30.32,58.2 30.32,58.03 30.19,57.9 30.03,57.9 29.75,58.18 29.61,58.18 29.48,58.05 29.48,57.77 29.68,57.57 29.68,57.39 29.5,57.21 29.5,56.28 29.41,56.19 29.12,56.19 28.72,55.79 28.72,53.58 29.62,52.68 29.62,50.44 29.83,50.23 29.83,45.38 30.44,44.77 30.61,44.6 30.61,43.88 31.68,42.81 31.68,42.41 32.1,41.99 32.1,41.77 31.84,41.51 v2(31.68,41.51)
  BOTTOM w0.076: U2030.AY47 76.06,61.86 75.64,61.86 75.52,61.9 75.48,61.91 75.34,61.91 75.12,61.85 74.99,61.85 74.89,61.89 74.65,61.92 74.35,61.92 74.14,61.71 73.61,61.71 73.46,61.86
  BOTTOM w0.102: 73.46,61.86 69.1,61.86 68.95,62.01 68.95,62.62 69.06,62.73 70.75,62.73 70.98,62.97 70.98,63.56 v2(70.81,63.73)
M_B_A3: length 185.5
  TOP w0.102: v2(31.6,75.06) 31.76,75.23 33.03,75.23 33.4,75.6 35.6,75.6 35.72,75.47 35.72,75.31 35.58,75.17 35.58,75.05 35.73,74.9 35.89,74.9 36,75.02 36.15,75.02 U2010.N7 ; v2(30.96,40.25) 30.96,40.51 31.11,40.66 32.86,40.66 33.05,40.86 35.3,40.86 35.64,40.51 36.32,40.51 36.67,40.16 U2012.N7 ; v2(32.36,54.76) 33.56,54.76 33.81,55.01 35.18,55.01 36.03,54.17 36.17,54.17 36.47,54.47 36.59,54.47 36.74,54.32 36.74,54.16 36.46,53.88 36.46,53.73 36.67,53.52 U2011.N7 ; v2(33.83,89.35) 34.16,89.67 34.76,89.67 36.21,88.22 36.21,88.22 U2009.N7
  TOP w0.165: R2114.2 30.34,94.78 v2(30.79,94.33)
  IN1 w0.089: v2(30.96,40.25) 31.45,39.76 31.68,39.76 31.77,39.67 31.77,38.91 31.86,38.82 31.99,38.82 32.07,38.91 32.07,39.67 32.16,39.76 32.34,39.76 32.43,39.67 32.43,38.86 32.52,38.77 32.7,38.77 33.51,39.59 33.51,41.95 32.98,42.48 32.98,49.69 32.57,50.11 32.57,51.28 32.7,51.42 32.7,54.42 v2(32.36,54.76) 32.36,54.91 32.29,54.98 32.29,56.21 32.43,56.35 32.43,56.91 31.59,57.75 31.59,66.61 31.69,66.71 32.09,66.71 32.19,66.81 32.19,67.01 32.09,67.11 31.69,67.11 31.59,67.22 31.59,67.42 31.69,67.52 32.09,67.52 32.19,67.62 32.19,67.83 32.09,67.93 31.88,67.93 31.79,68.02 31.79,68.2 32.17,68.58 32.17,71.23 31.79,71.6 31.79,74.87 v2(31.6,75.06) 31.81,75.27 31.81,75.96 31.19,76.57 31.19,77.88 31.28,77.97 31.91,77.97 32.03,77.84 32.5,77.84 32.58,77.92 32.58,78.03 32.33,78.27 31.24,78.27 31.16,78.35 31.16,78.56 31.22,78.63 31.54,78.63 31.64,78.73 31.64,78.87 31.54,78.97 31.29,78.97 31.19,79.08 31.19,79.29 31.26,79.36 31.63,79.36 31.87,79.61 31.87,80.81 32.74,81.68 32.74,82.24 32.6,82.38 32.42,82.38 32.32,82.47 32.32,82.63 32.42,82.73 32.63,82.73 32.74,82.84 32.74,83 32.64,83.1 32.31,83.1 32.16,83.25 32.16,87.47 32.5,87.8 32.5,89.42 32.89,89.81 33.6,89.81 33.83,89.58 v2(33.83,89.35)
  IN3 w0.102: v2(33.83,89.35) 32.94,90.24 32.83,90.24 31.99,91.08 31.99,93.13 v2(30.79,94.33)
  IN3 w0.14: v2(70.23,63.72) 70.14,63.72 68.72,65.14 67.61,65.14 65.34,67.41 59.11,67.41 58.35,68.17 40.65,68.17 40.55,68.07 40.55,67.27 40.4,67.12 40.27,67.12 40.12,67.27 40.12,68.03 39.98,68.17 39.77,68.17 39.66,68.06 39.66,66.87 38.11,65.32 37.11,65.32 35.41,63.62 35.41,63.36 34.87,62.82 33.12,62.82 28.13,57.83 28.13,53.34 28.93,52.54 28.93,52.4 28.83,52.29 28.45,52.29 28.35,52.19 28.35,51.96 28.45,51.85 28.89,51.85 29.01,51.73 29.01,51.5 28.9,51.39 28.71,51.39 28.61,51.29 28.61,51.06 28.71,50.96 28.9,50.96 29.03,50.83 29.03,50.67 28.9,50.54 28.18,50.54 28.08,50.44 28.08,49.82 28.18,49.71 29.12,49.71 29.25,49.59 29.25,49.39 29.12,49.27 28.78,49.27 28.65,49.15 28.65,48.97 28.78,48.85 29.12,48.85 29.25,48.73 29.25,48.56 29.12,48.43 28.78,48.43 28.65,48.31 28.65,48.14 28.78,48.01 29.12,48.01 29.25,47.89 29.25,47.72 29.12,47.59 28.69,47.59 28.59,47.49 28.59,47.28 28.69,47.17 29.09,47.17 29.22,47.05 29.22,46.86 29.12,46.75 28.79,46.75 28.69,46.65 28.69,46.44 28.79,46.33 29.04,46.33 29.25,46.13 29.25,45.14 29.51,44.87 29.51,44.65 29.35,44.49 29.35,44.31 29.48,44.18 29.63,44.18 29.81,44.36 29.93,44.36 30.03,44.27 30.03,43.64 30.85,42.82 30.85,42.07 30.94,41.97 30.94,41.05 31.08,40.91 31.21,40.91 31.33,40.79 31.33,40.59 30.99,40.25 v2(30.96,40.25)
  BOTTOM w0.076: 72.73,61.35 72.96,61.35 72.99,61.38 74.66,61.38 U2030.BB46
  BOTTOM w0.102: 72.73,61.35 68.74,61.35 67.99,61.35 67.83,61.52 67.83,63.36 67.97,63.5 70.01,63.5 v2(70.23,63.72)
